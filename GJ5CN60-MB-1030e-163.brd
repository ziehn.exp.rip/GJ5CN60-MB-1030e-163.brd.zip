# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Nets (continued)
GND POWER: AB1.1 AB3.1 AB4.1 AB5.1 AC4.2 AC5.2 AC8.2 AC9.2 ACN1.S1 ACN1.S2 C2.1 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C13.2 C14.2 C15.2 C21.1 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.1 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C69.2 C70.2 C71.2 C73.1 C74.1 C75.2 C77.2 C78.1 C79.2 C80.2 C81.2 C82.1 C83.1 C84.1 C85.1 C86.1 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C120.2 C121.2 C122.2 C123.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.1 C132.2 C133.2 C135.2 C136.1 C137.1 C142.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C152.2 C153.2 C159.2 C160.2 C162.2 C164.1 C167.2 C168.2 C169.2 C170.2 C171.2 C172.1 C173.2 C174.2 C175.2 C176.2 C177.2 C180.2 C181.2 C182.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C196.2 C197.1 C198.2 C200.1 C201.1 C202.1 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C225.2 C227.2 C231.1 C232.2 C240.2 C244.2 C246.2 C247.2 C248.2 C252.2 C253.2 C254.2 C255.1 C256.2 C257.2 C258.2 C259.2 C260.1 C263.2 C264.2 C267.2 C276.2 C277.2 C278.2 C279.2 C280.1 C281.1 C282.1 C283.2 C284.1 C285.1 C286.2 C290.1 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C305.2 C308.2 C309.2 C311.2 C320.1 C321.1 C322.1 C323.1 C324.1 C325.1 C326.1 C327.1 C328.1 C329.1 C330.2 C331.1 C332.2 C334.1 C335.1 C339.1 C340.2 C341.1 C347.2 C353.2 C355.2 C359.2 C364.2 C366.2 C367.2 C368.2 C370.2 C371.2 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C386.2 C387.2 C388.2 C389.2 C390.2 C391.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C405.2 C406.2 C407.1 C410.2 C412.1 C413.1 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.1 C429.2 C430.2 C431.2 C432.2 C433.2 C435.1 C436.2 C445.2 C450.2 C452.2 C456.1 C465.2 C466.2 C469.2 C470.2 C473.2 C486.2 C492.2 C493.2 C499.2 C500.2 C522.2 C529.2 C540.2 C545.2 C546.2 C548.2 C550.2 C553.2 C554.2 C556.2 C576.2 C577.2 C578.2 C579.2 C580.2 C582.2 C583.2 C584.2 C585.2 C586.2 C587.2 C588.1 C589.2 C590.2 C591.2 C593.2 C594.2 C595.1 C596.2 C597.2 C598.2 C599.2 C600.2 C601.2 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C641.2 C653.2 C654.1 C663.2 C666.2 C667.2 C668.2 C669.2 C673.2 C674.2 C675.2 C677.2 C686.2 C687.2 C688.2 C689.2 C690.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C719.2 C738.2 C782.1 C783.1 C784.1 C785.1 C800.2 C803.1 C816.2 C817.2 C818.2 C819.1 C849.1 C856.2 C857.1 C858.1 C860.2 C861.2 C862.2 C863.1 C864.1 C865.2 C866.2 C870.1 C871.2 C872.1 C874.1 C875.1 C876.1 C877.1 C878.1 C879.1 C880.1 C881.1 C882.1 C883.1 C884.1 C885.2 C886.2 C887.2 C888.2 C889.2 C890.1 C891.1 C892.2 C893.1 C894.2 C895.2 C896.2 C897.2 C898.2 C899.2 C900.2 C901.2 C902.1 C903.2 C904.1 C905.1 C906.2 C907.2 C908.2 C909.2 C910.2 C911.2 C912.2 C913.2 C914.2 C915.1 C916.2 C917.1 C918.1 C919.2 C920.2 C921.2 C922.2 C923.2 C924.2 C925.2 C926.2 C927.2 C928.1 C929.2 C930.2 C931.1 C932.1 C933.2 C934.2 C935.2 C936.2 C937.2 C938.2 C939.1 C940.1 C941.1 C942.1 C943.2 C944.2 C945.2 C946.2 C947.1 C948.2 C949.1 C950.1 C951.2 C952.1 C953.2 C954.2 C955.1 C956.1 C957.1 C958.2 C959.2 C960.2 C961.2 C962.2 C963.1 C964.2 C965.2 C966.2 C967.2 C968.2 C969.2 C970.2 C971.2 C972.2 C973.1 C974.2 C975.2 C976.2 C977.2 C978.1 C979.1 C980.1 C981.2 C982.1 C983.2 C984.1 C985.1 C986.2 C987.1 C988.2 C989.1 C990.1 C991.2 C992.1 C993.2 C994.1 C995.1 C996.2 C997.1 C998.2 C999.1 C1000.1 C1001.2 C1002.1 C1003.2 C1004.1 C1005.2 C1006.2 C1007.2 C1008.2 C1009.2 C1010.2 C1011.2 C1012.2 C1013.2 C1014.2 C1015.2 C1016.2 C1017.1 C1018.2 C1019.1 C1020.2 C1021.1 C1022.2 C1023.2 C1024.2 C1025.2 C1026.1 C1027.2 C1028.2 C1029.2 C1030.2 C1031.2 C1032.1 C1033.2 C1034.2 C1035.2 C1036.2 C1037.2 C1038.2 C1039.2 C1040.1 C1041.2 C1042.1 C1043.2 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.1 C1051.2 C1052.2 C1053.1 C1054.1 C1055.2 C1056.2 C1057.2 C1058.2 C1059.2 C1060.2 C1061.2 C1062.2 C1063.2 C1064.1 C1065.2 C1066.2 C1067.2 C1068.1 C1069.2 C1070.2 C1071.2 C1072.2 C1073.2 C1074.1 C1075.2 C1076.1 C1077.1 C1078.2 C1128.1 C1137.1 C1138.1 C1139.1 C1144.1 C1151.1 C1152.1 C1153.1 C1161.1 C1163.1 C1164.1 C1165.1 C1167.1 C1169.1 C1176.2 C1179.2 C1180.2 C1181.1 C1182.1 C1183.1 C1184.1 C1185.2 C1186.1 C1187.1 C1188.1 C1189.1 C1190.1 C1191.1 C1192.1 C1193.2 C1194.2 C1195.2 C1196.2 C1197.2 C1216.2 C1217.2 C1218.1 C1219.2 C1220.2 C1221.2 C1222.2 C1235.2 C1236.2 C1237.2 C1243.2 C1244.1 C1245.1 C1246.1 C1248.1 C1249.1 C1250.1 C1251.1 C1252.1 C1253.1 C1254.1 C1255.1 C1256.1 C1257.1 C1260.1 C1261.1 C1262.1 C1263.1 C1264.1 C1265.1 C1266.1 C1267.1 C1268.1 C1269.1 C1270.2 C1271.2 C1272.2 C1273.1 C1274.1 C1275.1 C1276.2 C1277.1 C1278.2 C1279.1 C1280.2 C1281.1 C1282.1 C1283.1 C1284.1 C1285.1 C1286.1 C1287.1 C1288.1 C1289.1 C1290.2 C1291.1 C1292.1 C1293.2 C1294.2 C1295.2 C1296.2 C1297.2 C1298.1 C1299.1 C1300.2 C1301.2 C1302.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.1 C1310.2 C1311.2 C1312.2 C1313.1 C1318.1 C1319.1 C1320.1 C1321.1 C1322.1 C1326.1 C1327.1 C1328.1 C1329.1 C1330.1 C1331.1 C1332.1 C1333.1 C1334.1 C1335.1 C1336.1 C1337.1 C1338.1 C1339.1 C1340.1 C1341.1 C1342.1 C1343.1 C1344.1 C1345.1 C1346.1 C1347.1 C1348.1 C1349.1 C1350.2 C1351.2 C1352.2 C1353.2 C1354.2 C1355.2 C1356.2 C1357.2 C1358.2 C1361.1 C1362.1 C1363.2 C1364.1 C1367.2 C1368.2 C1369.2 C1370.2 C1371.2 C1372.2 C1373.2 C1374.2 C1375.2 C1376.2 C1377.2 C1378.2 C1382.1 C1383.1 C1384.1 C1385.2 C1386.1 C1387.1 C1388.1 C1389.1 C1390.1 C1391.1 C1392.1 C1393.1 C1394.2 C1395.1 C1396.2 C1397.1 C1398.1 C1399.1 C1400.1 C1401.1 C1402.1 C1403.2 C1404.1 C1405.1 C1406.1 C1407.1 C1408.1 C1409.1 C1410.2 C1411.1 C1412.1 C1413.1 C1414.2 C1415.1 C1416.1 C1417.1 C1418.1 C1419.1 C1420.2 C1421.1 C1422.1 C1423.2 C1424.2 C1425.2 C1426.2 C1427.2 C1428.2 C1429.2 C1431.1 C1432.1 C1433.1 C1434.2 C1435.2 C1436.2 C1437.2 C1438.2 C1439.2 C1440.2 C1441.2 C1442.1 C1443.1 C1444.1 C1445.1 C1446.1 C1447.2 C1448.2 C1449.2 C1450.2 C1451.1 C1452.1 C1453.2 C1454.2 C1455.2 C1456.1 C1457.1 C1458.1 C1459.2 C1463.2 C1464.2 C1465.2 C1466.2 C1467.2 C1468.2 C1469.2 C1470.2 C1471.2 C1472.2 C2396.2 C2397.2 C2398.2 C2575.2 C2578.2 C2579.2 C2745.2 C2746.2 C2747.2 C2821.2 C3384.2 C3399.1 C3401.1 C3416.2 C3417.2 C3418.2 C3419.2 C3420.2 C3421.1 C3422.2 C3423.2 C3424.1 C3425.2 C3426.1 C3427.2 C3428.2 C3431.2 C3432.2 C3438.2 C3439.2 C3440.2 C3441.2 C3443.1 C3445.1 C3447.2 C3463.1 C3464.1 C3465.1 C3466.1 C3467.1 C3468.1 C3470.2 C3471.2 C3491.1 C3493.1 C3495.1 C3496.1 C3538.2 C3539.2 C3540.2 C3543.2 C3544.2 C3545.2 C3546.2 C3547.2 C3548.2 C3549.2 C3550.2 C3551.2 C3552.2 C3553.2 C3554.2 C3558.1 C3561.2 C3562.2 C3563.2 C3566.2 C3567.2 C3568.2 C3569.2 C3570.2 C3571.2 C3573.1 C3578.2 C3581.2 C3583.1 C3584.2 C3585.2 C3586.2 C3587.2 C3588.2 C3589.2 C3590.2 C3591.2 C3592.2 C3593.2 C3594.2 C3595.2 C3596.2 C3597.2 C3598.2 C3599.2 C3600.2 C3601.2 C3602.2 C3605.2 C3606.2 C3607.2 C3608.2 C3609.2 C3610.2 C3611.2 C3612.2 C3613.2 C3614.2 C3615.2 C3616.1 C3617.1 C3618.2 C3619.2 C3620.1 C3621.1 C3622.1 C3623.2 C3624.2 C3625.1 C3626.1 C3627.1 C3628.2 C3629.2 C3630.1 C3631.1 C3632.2 C3633.2 C3634.1 C3635.1 C3636.2 C3637.2 C3638.1 C3641.2 C3642.2 C3643.2 C3644.2 C3646.2 C3647.2 C3648.2 C3649.2 C3651.2 C3652.2 C3653.2 C3654.2 C3655.2 C3656.2 C3657.2 C3658.2 C3659.2 C3660.2 C3661.2 C3742.1 C3743.1 C3744.2 C3745.2 C3747.2 C3847.2 C3892.2 C3893.1 C3895.1 C3896.1 C3897.2 C3898.2 C3899.2 C3901.2 C3902.2 C3903.2 C3904.2 C3912.2 C3913.2 C3939.2 C3940.2 C3941.2 C3962.2 C3988.2 C3989.2 C3990.2 C3991.2 C3992.2 C4078.2 C4079.2 C4084.2 C4085.2 C4092.2 C4093.2 C4094.2 C4102.2 C4103.2 C4104.2 C4105.2 C4106.2 C4107.2 C4108.2 C4109.2 C4110.2 C4114.2 C4115.2 C4117.2 C4118.2 C4119.2 C4120.2 C4121.2 CN1.1 CN1.2 CN1.5 CN1.6 CN1.9 CN1.10 CN1.14 CN1.15 CN1.18 CN1.19 CN1.22 CN1.23 CN1.26 CN1.27 CN1.30 CN1.31 CN1.35 CN1.36 CN1.39 CN1.40 CN1.43 CN1.44 CN1.47 CN1.48 CN1.51 CN1.52 CN1.56 CN1.57 CN1.60 CN1.61 CN1.64 CN1.65 CN1.68 CN1.69 CN1.72 CN1.73 CN1.77 CN1.78 CN1.81 CN1.82 CN1.85 CN1.86 CN1.89 CN1.90 CN1.93 CN1.94 CN1.98 CN1.99 CN1.102 CN1.103 CN1.106 CN1.107 CN1.167 CN1.168 CN1.171 CN1.172 CN1.175 CN1.176 CN1.180 CN1.181 CN1.184 CN1.185 CN1.188 CN1.189 CN1.192 CN1.193 CN1.196 CN1.197 CN1.201 CN1.202 CN1.205 CN1.206 CN1.209 CN1.210 CN1.213 CN1.214 CN1.217 CN1.218 CN1.222 CN1.223 CN1.226 CN1.227 CN1.230 CN1.231 CN1.234 CN1.235 CN1.238 CN1.239 CN1.243 CN1.244 CN1.247 CN1.248 CN1.251 CN1.252 CN1.261 CN1.262 CN4.2 CN4.S1 CN4.S2 CN9.6 CN9.S1 CN9.S2 CN11.1 CN11.2 CN11.5 CN11.6 CN11.9 CN11.10 CN11.14 CN11.15 CN11.18 CN11.19 CN11.22 CN11.23 CN11.26 CN11.27 CN11.30 CN11.31 CN11.35 CN11.36 CN11.39 CN11.40 CN11.43 CN11.44 CN11.47 CN11.48 CN11.51 CN11.52 CN11.56 CN11.57 CN11.60 CN11.61 CN11.64 CN11.65 CN11.68 CN11.69 CN11.72 CN11.73 CN11.77 CN11.78 CN11.81 CN11.82 CN11.85 CN11.86 CN11.89 CN11.90 CN11.93 CN11.94 CN11.98 CN11.99 CN11.102 CN11.103 CN11.106 CN11.107 CN11.167 CN11.168 CN11.171 CN11.172 CN11.175 CN11.176 CN11.180 CN11.181 CN11.184 CN11.185 CN11.188 CN11.189 CN11.192 CN11.193 CN11.196 CN11.197 CN11.201 CN11.202 CN11.205 CN11.206 CN11.209 CN11.210 CN11.213 CN11.214 CN11.217 CN11.218 CN11.222 CN11.223 CN11.226 CN11.227 CN11.230 CN11.231 CN11.234 CN11.235 CN11.238 CN11.239 CN11.243 CN11.244 CN11.247 CN11.248 CN11.251 CN11.252 CN11.261 CN11.262 CN12.13 CN12.17 CN12.19 CN12.26 CN12.32 CN12.35 CN12.36 CN12.39 CN12.45 CN12.48 CN12.S1 CN12.S2 CN14.1 CN14.4 CN14.7 CN14.S1 CN17.5 CN17.S1 CN17.S2 CN18.3 CN18.S1 CN18.S2 CN19.S1 CN19.S2 CN23.4 CN23.7 CN23.H1 CN23.H2 CN23.H3 CN23.H4 CN26.2 CN26.5 CN26.8 CN26.11 CN26.17 CN26.H1 CN26.H2 CN26.H3 CN26.H4 CN30.9 CN30.U9 CN32.4 CN32.7 CN32.H1 CN32.H2 CN32.H3 CN32.H4 CN34.GND1 CN34.GND2 CN41.S1 CN41.S2 CN42.3 CN42.4 CN42.S1 CN42.S2 CNDCIN1.2 CNDCIN1.3 CNDCIN1.4 CNDCIN1.5 CNDEG1.2 CNDEG1.3 CNDEG1.S2 CNDEG2.2 CNDEG2.S1 CNDEG2.S2 CNEDP1.1 CNEDP1.4 CNEDP1.7 CNEDP1.10 CNEDP1.13 CNEDP1.16 CNEDP1.19 CNEDP1.20 CNEDP1.22 CNEDP1.23 CNEDP1.24 CNEDP1.36 CNEDP1.S1 CNEDP1.S2 CNFAN1.1 CNFAN1.S1 CNFAN1.S2 CNFAN2.1 CNFAN2.S1 CNFAN2.S2 CNHDD1.1 CNHDD1.4 CNHDD1.7 CNHDD1.8 CNHDD1.17 CNHDD1.18 CNHDD1.S1 CNHDD1.S2 CNKB1.33 CNKB1.36 CNKB1.S1 CNKB1.S2 CNSSD1.1 CNSSD1.3 CNSSD1.9 CNSSD1.15 CNSSD1.21 CNSSD1.27 CNSSD1.33 CNSSD1.39 CNSSD1.45 CNSSD1.51 CNSSD1.57 CNSSD1.71 CNSSD1.73 CNSSD1.75 CNSSD1.MTG76 CNSSD1.MTG77 CNSSD2.1 CNSSD2.3 CNSSD2.9 CNSSD2.15 CNSSD2.21 CNSSD2.27 CNSSD2.33 CNSSD2.39 CNSSD2.45 CNSSD2.51 CNSSD2.57 CNSSD2.71 CNSSD2.73 CNSSD2.75 CNSSD2.MTG76 CNSSD2.MTG77 CNWLAN1.1 CNWLAN1.7 CNWLAN1.13 CNWLAN1.18 CNWLAN1.19 CNWLAN1.33 CNWLAN1.39 CNWLAN1.45 CNWLAN1.51 CNWLAN1.57 CNWLAN1.63 CNWLAN1.69 CNWLAN1.75 CNWLAN1.76 CNWLAN1.77 CON3.A1 CON3.A12 CON3.B1 CON3.B12 CON3.G1 CON3.G2 CON3.G3 CON3.G4 CON3.S3 CON3.S4 D10.1 D37.3 D38.3 D39.3 D42.3 D43.3 D44.3 D45.3 D59.3 D60.3 D61.3 D62.3 ESD1.3 ESD1.8 ESD2.3 ESD2.8 ESD3.3 ESD3.8 G1.A2 G1.A3 G1.A26 G1.A29 G1.A32 G1.A50 G1.A51 G1.AA8 G1.AA49 G1.AB2 G1.AB4 G1.AB6 G1.AB8 G1.AB10 G1.AB14 G1.AB15 G1.AB16 G1.AB17 G1.AB18 G1.AB19 G1.AB20 G1.AB21 G1.AB22 G1.AB23 G1.AB24 G1.AB25 G1.AB26 G1.AB27 G1.AB28 G1.AB29 G1.AB30 G1.AB31 G1.AB32 G1.AB33 G1.AB34 G1.AB35 G1.AB36 G1.AB37 G1.AB38 G1.AB39 G1.AB43 G1.AB45 G1.AB47 G1.AB49 G1.AB51 G1.AD14 G1.AD15 G1.AD16 G1.AD17 G1.AD18 G1.AD19 G1.AD20 G1.AD21 G1.AD22 G1.AD23 G1.AD24 G1.AD25 G1.AD26 G1.AD27 G1.AD28 G1.AD29 G1.AD30 G1.AD31 G1.AD32 G1.AD33 G1.AD34 G1.AD35 G1.AD36 G1.AD37 G1.AD38 G1.AD39 G1.AD44 G1.AE2 G1.AE4 G1.AE6 G1.AE8 G1.AE10 G1.AE43 G1.AE45 G1.AE47 G1.AE49 G1.AE51 G1.AF1 G1.AF5 G1.AF19 G1.AF20 G1.AF21 G1.AF22 G1.AF23 G1.AF27 G1.AF28 G1.AF29 G1.AF35 G1.AF36 G1.AF37 G1.AF38 G1.AF39 G1.AF45 G1.AG3 G1.AG14 G1.AG15 G1.AG16 G1.AG17 G1.AG18 G1.AG24 G1.AG25 G1.AG26 G1.AG30 G1.AG31 G1.AG32 G1.AG33 G1.AG34 G1.AG44 G1.AH2 G1.AH4 G1.AH6 G1.AH8 G1.AH10 G1.AH43 G1.AH45 G1.AH47 G1.AH49 G1.AH51 G1.AJ2 G1.AJ9 G1.AJ14 G1.AJ15 G1.AJ16 G1.AJ17 G1.AJ18 G1.AJ19 G1.AJ20 G1.AJ21 G1.AJ22 G1.AJ23 G1.AJ24 G1.AJ25 G1.AJ26 G1.AJ27 G1.AJ28 G1.AJ29 G1.AJ30 G1.AJ31 G1.AJ32 G1.AJ33 G1.AJ34 G1.AJ35 G1.AJ36 G1.AJ37 G1.AJ38 G1.AJ39 G1.AK1 G1.AK44 G1.AK47 G1.AL2 G1.AL4 G1.AL6 G1.AL8 G1.AL10 G1.AL14 G1.AL15 G1.AL16 G1.AL17 G1.AL18 G1.AL19 G1.AL20 G1.AL21 G1.AL22 G1.AL23 G1.AL24 G1.AL25 G1.AL26 G1.AL27 G1.AL28 G1.AL29 G1.AL30 G1.AL31 G1.AL32 G1.AL33 G1.AL34 G1.AL35 G1.AL36 G1.AL37 G1.AL38 G1.AL39 G1.AL43 G1.AL45 G1.AL47 G1.AL49 G1.AL51 G1.AM4 G1.AM9 G1.AN4 G1.AN5 G1.AN8 G1.AN14 G1.AN15 G1.AN16 G1.AN17 G1.AN18 G1.AN19 G1.AN20 G1.AN21 G1.AN22 G1.AN23 G1.AN24 G1.AN25 G1.AN26 G1.AN27 G1.AN28 G1.AN29 G1.AN30 G1.AN31 G1.AN32 G1.AN33 G1.AN34 G1.AN35 G1.AN36 G1.AN37 G1.AN38 G1.AN39 G1.AP2 G1.AP4 G1.AP6 G1.AP8 G1.AP10 G1.AP43 G1.AP45 G1.AP47 G1.AP49 G1.AP51 G1.AR4 G1.AR9 G1.AR14 G1.AR15 G1.AR16 G1.AR17 G1.AR18 G1.AR19 G1.AR20 G1.AR21 G1.AR22 G1.AR23 G1.AR24 G1.AR25 G1.AR26 G1.AR27 G1.AR28 G1.AR29 G1.AR30 G1.AR31 G1.AR32 G1.AR33 G1.AR34 G1.AR35 G1.AR36 G1.AR37 G1.AR38 G1.AR39 G1.AR52 G1.AT4 G1.AT5 G1.AT8 G1.AT51 G1.AT52 G1.AU2 G1.AU4 G1.AU6 G1.AU8 G1.AU10 G1.AU14 G1.AU15 G1.AU16 G1.AU17 G1.AU18 G1.AU19 G1.AU20 G1.AU21 G1.AU22 G1.AU23 G1.AU24 G1.AU25 G1.AU26 G1.AU27 G1.AU28 G1.AU29 G1.AU30 G1.AU31 G1.AU32 G1.AU33 G1.AU34 G1.AU35 G1.AU36 G1.AU37 G1.AU38 G1.AU39 G1.AU45 G1.AU47 G1.AU49 G1.AU51 G1.AV4 G1.AV9 G1.AV45 G1.AW4 G1.AW5 G1.AW8 G1.AW14 G1.AW15 G1.AW16 G1.AW17 G1.AW18 G1.AW19 G1.AW20 G1.AW21 G1.AW22 G1.AW23 G1.AW24 G1.AW25 G1.AW26 G1.AW27 G1.AW28 G1.AW29 G1.AW30 G1.AW31 G1.AW32 G1.AW33 G1.AW34 G1.AW35 G1.AW36 G1.AW37 G1.AW38 G1.AW39 G1.AW46 G1.AW52 G1.AY2 G1.AY4 G1.AY6 G1.AY8 G1.AY10 G1.AY47 G1.AY49 G1.AY51 G1.B1 G1.B2 G1.B5 G1.B7 G1.B10 G1.B13 G1.B16 G1.B19 G1.B22 G1.B25 G1.B28 G1.B31 G1.B34 G1.B37 G1.B40 G1.B43 G1.B46 G1.B48 G1.B51 G1.B52 G1.BA48 G1.BB49 G1.BC2 G1.BC4 G1.BC6 G1.BC8 G1.BC13 G1.BC16 G1.BC19 G1.BC22 G1.BC24 G1.BC25 G1.BC28 G1.BC31 G1.BC34 G1.BC37 G1.BC51 G1.BD24 G1.BD26 G1.BD29 G1.BD32 G1.BD35 G1.BD38 G1.BD52 G1.BE10 G1.BE13 G1.BE15 G1.BE16 G1.BE18 G1.BE19 G1.BE21 G1.BE22 G1.BE24 G1.BE25 G1.BE27 G1.BE28 G1.BE30 G1.BE31 G1.BE33 G1.BE34 G1.BE36 G1.BE37 G1.BE39 G1.BE40 G1.BF2 G1.BF4 G1.BF6 G1.BF41 G1.BG7 G1.BG10 G1.BG13 G1.BG16 G1.BG19 G1.BG22 G1.BG25 G1.BG28 G1.BG31 G1.BG34 G1.BG37 G1.BG40 G1.BG42 G1.BH2 G1.BH5 G1.BH15 G1.BH18 G1.BH21 G1.BH24 G1.BH27 G1.BH30 G1.BH33 G1.BH36 G1.BH39 G1.BH42 G1.BJ7 G1.BJ10 G1.BJ12 G1.BJ13 G1.BJ14 G1.BJ15 G1.BJ16 G1.BJ17 G1.BJ18 G1.BJ19 G1.BJ20 G1.BJ21 G1.BJ22 G1.BJ23 G1.BJ24 G1.BJ25 G1.BJ26 G1.BJ27 G1.BJ28 G1.BJ29 G1.BJ30 G1.BJ31 G1.BJ32 G1.BJ33 G1.BJ34 G1.BJ35 G1.BJ36 G1.BJ37 G1.BJ38 G1.BJ39 G1.BJ40 G1.BJ41 G1.BJ42 G1.BJ43 G1.BK1 G1.BL1 G1.BL2 G1.BL5 G1.BL7 G1.BL10 G1.BL13 G1.BL16 G1.BL19 G1.BL22 G1.BL25 G1.BL28 G1.BL31 G1.BL34 G1.BL37 G1.BL40 G1.BL43 G1.BM2 G1.BM3 G1.C1 G1.C5 G1.C29 G1.C33 G1.C51 G1.C52 G1.D4 G1.D7 G1.D10 G1.D12 G1.D13 G1.D16 G1.D19 G1.D22 G1.D24 G1.D25 G1.D28 G1.D30 G1.D31 G1.D34 G1.D37 G1.D40 G1.D43 G1.D46 G1.D49 G1.E2 G1.E4 G1.E5 G1.E8 G1.E48 G1.E51 G1.F7 G1.F10 G1.F13 G1.F16 G1.F17 G1.F19 G1.F21 G1.F22 G1.F25 G1.F28 G1.F31 G1.F34 G1.F35 G1.F37 G1.F40 G1.F43 G1.F44 G1.F46 G1.F52 G1.G2 G1.G4 G1.G6 G1.G38 G1.G47 G1.G49 G1.G51 G1.H1 G1.H10 G1.H13 G1.H16 G1.H19 G1.H22 G1.H25 G1.H28 G1.H31 G1.H34 G1.H37 G1.H40 G1.H43 G1.J1 G1.J12 G1.J17 G1.J20 G1.J38 G1.J49 G1.J52 G1.K2 G1.K4 G1.K6 G1.K8 G1.K13 G1.K16 G1.K19 G1.K22 G1.K25 G1.K28 G1.K31 G1.K34 G1.K37 G1.K40 G1.K45 G1.K47 G1.K49 G1.K51 G1.M6 G1.M52 G1.N2 G1.N4 G1.N6 G1.N8 G1.N10 G1.N43 G1.N45 G1.N47 G1.N49 G1.N51 G1.P14 G1.P15 G1.P16 G1.P17 G1.P18 G1.P19 G1.P20 G1.P21 G1.P22 G1.P23 G1.P24 G1.P25 G1.P26 G1.P27 G1.P28 G1.P29 G1.P30 G1.P31 G1.P32 G1.P33 G1.P34 G1.P35 G1.P36 G1.P37 G1.P38 G1.P39 G1.P51 G1.R49 G1.R52 G1.T2 G1.T4 G1.T6 G1.T8 G1.T10 G1.T14 G1.T15 G1.T16 G1.T17 G1.T18 G1.T19 G1.T20 G1.T21 G1.T22 G1.T23 G1.T24 G1.T25 G1.T26 G1.T27 G1.T28 G1.T29 G1.T30 G1.T31 G1.T32 G1.T33 G1.T34 G1.T35 G1.T36 G1.T37 G1.T38 G1.T39 G1.T43 G1.T45 G1.T47 G1.T49 G1.T51 G1.U7 G1.U9 G1.V14 G1.V15 G1.V16 G1.V17 G1.V18 G1.V19 G1.V20 G1.V21 G1.V22 G1.V23 G1.V24 G1.V25 G1.V26 G1.V27 G1.V28 G1.V29 G1.V30 G1.V31 G1.V32 G1.V33 G1.V34 G1.V35 G1.V36 G1.V37 G1.V38 G1.V39 G1.V49 G1.V52 G1.W2 G1.W4 G1.W6 G1.W8 G1.W10 G1.W43 G1.W45 G1.W47 G1.W49 G1.W51 G1.Y9 G1.Y14 G1.Y15 G1.Y16 G1.Y17 G1.Y18 G1.Y19 G1.Y20 G1.Y21 G1.Y22 G1.Y23 G1.Y24 G1.Y25 G1.Y26 G1.Y27 G1.Y28 G1.Y29 G1.Y30 G1.Y31 G1.Y32 G1.Y33 G1.Y34 G1.Y35 G1.Y36 G1.Y37 G1.Y38 G1.Y39 H2.1 H3.1 H4.1 H5.1 H6.1 H7.1 H8.1 H12.1 H13.1 H14.1 H15.1 H16.1 H18.1 H19.1 H20.1 H23.1 H24.1 H25.1 JP1.2 JP2.2 M41.A1 M41.A3 M41.A12 M41.A14 M41.B5 M41.B10 M41.C1 M41.C3 M41.C4 M41.C11 M41.C12 M41.C14 M41.D10 M41.E1 M41.E3 M41.E12 M41.E14 M41.F5 M41.F10 M41.G5 M41.G10 M41.H1 M41.H2 M41.H13 M41.H14 M41.J10 M41.K1 M41.K2 M41.K13 M41.K14 M41.L5 M41.L10 M41.M5 M41.M10 M41.N1 M41.N3 M41.N12 M41.N14 M41.P10 M41.R1 M41.R3 M41.R4 M41.R11 M41.R12 M41.R14 M41.T5 M41.T10 M41.V1 M41.V3 M41.V12 M41.V14 M42.A1 M42.A3 M42.A12 M42.A14 M42.B5 M42.B10 M42.C1 M42.C3 M42.C4 M42.C11 M42.C12 M42.C14 M42.D10 M42.E1 M42.E3 M42.E12 M42.E14 M42.F5 M42.F10 M42.G5 M42.G10 M42.H1 M42.H2 M42.H13 M42.H14 M42.J1 M42.J10 M42.K1 M42.K2 M42.K13 M42.K14 M42.L5 M42.L10 M42.M5 M42.M10 M42.N1 M42.N3 M42.N12 M42.N14 M42.P10 M42.R1 M42.R3 M42.R4 M42.R11 M42.R12 M42.R14 M42.T5 M42.T10 M42.V1 M42.V3 M42.V12 M42.V14 M43.A1 M43.A3 M43.A12 M43.A14 M43.B5 M43.B10 M43.C1 M43.C3 M43.C4 M43.C11 M43.C12 M43.C14 M43.D10 M43.E1 M43.E3 M43.E12 M43.E14 M43.F5 M43.F10 M43.G5 M43.G10 M43.H1 M43.H2 M43.H13 M43.H14 M43.J10 M43.K1 M43.K2 M43.K13 M43.K14 M43.L5 M43.L10 M43.M5 M43.M10 M43.N1 M43.N3 M43.N12 M43.N14 M43.P10 M43.R1 M43.R3 M43.R4 M43.R11 M43.R12 M43.R14 M43.T5 M43.T10 M43.V1 M43.V3 M43.V12 M43.V14 M44.A1 M44.A3 M44.A12 M44.A14 M44.B5 M44.B10 M44.C1 M44.C3 M44.C4 M44.C11 M44.C12 M44.C14 M44.D10 M44.E1 M44.E3 M44.E12 M44.E14 M44.F5 M44.F10 M44.G5 M44.G10 M44.H1 M44.H2 M44.H13 M44.H14 M44.J1 M44.J10 M44.K1 M44.K2 M44.K13 M44.K14 M44.L5 M44.L10 M44.M5 M44.M10 M44.N1 M44.N3 M44.N12 M44.N14 M44.P10 M44.R1 M44.R3 M44.R4 M44.R11 M44.R12 M44.R14 M44.T5 M44.T10 M44.V1 M44.V3 M44.V12 M44.V14 M45.A1 M45.A3 M45.A12 M45.A14 M45.B5 M45.B10 M45.C1 M45.C3 M45.C4 M45.C11 M45.C12 M45.C14 M45.D10 M45.E1 M45.E3 M45.E12 M45.E14 M45.F5 M45.F10 M45.G5 M45.G10 M45.H1 M45.H2 M45.H13 M45.H14 M45.J10 M45.K1 M45.K2 M45.K13 M45.K14 M45.L5 M45.L10 M45.M5 M45.M10 M45.N1 M45.N3 M45.N12 M45.N14 M45.P10 M45.R1 M45.R3 M45.R4 M45.R11 M45.R12 M45.R14 M45.T5 M45.T10 M45.V1 M45.V3 M45.V12 M45.V14 M46.A1 M46.A3 M46.A12 M46.A14 M46.B5 M46.B10 M46.C1 M46.C3 M46.C4 M46.C11 M46.C12 M46.C14 M46.D10 M46.E1 M46.E3 M46.E12 M46.E14 M46.F5 M46.F10 M46.G5 M46.G10 M46.H1 M46.H2 M46.H13 M46.H14 M46.J1 M46.J10 M46.K1 M46.K2 M46.K13 M46.K14 M46.L5 M46.L10 M46.M5 M46.M10 M46.N1 M46.N3 M46.N12 M46.N14 M46.P10 M46.R1 M46.R3 M46.R4 M46.R11 M46.R12 M46.R14 M46.T5 M46.T10 M46.V1 M46.V3 M46.V12 M46.V14 PJP5.2 PJP11.2 PJP13.2 PJP15.2 PJP28.2 PJP34.2 PJP3210.2 PQ37.5 PQ37.6 PQ37.7 PQ40.5 PQ40.6 PQ40.7 PQ41.5 PQ41.6 PQ41.7 PQ42.5 PQ42.6 PQ42.7 PQ43.5 PQ43.6 PQ43.7 PQ44.5 PQ44.6 PQ44.7 PQ48.5 PQ48.6 PQ48.7 PQ49.5 PQ49.6 PQ49.7 PQ52.5 PQ52.6 PQ52.7 PQ53.5 PQ53.6 PQ53.7 Q1.S Q2.1 Q2.4 Q3.1 Q3.4 Q4.1 Q4.4 Q12.S Q16.1 Q16.4 Q20.E Q30.S Q44.1 Q44.4 Q45.E Q47.1 Q47.4 Q48.S Q49.S Q53.E Q57.S Q59.S Q62.S Q64.S Q66.S Q67.S Q69.S Q70.S Q71.S Q86.S Q88.1 Q88.4 Q92.1 Q92.4 Q96.3 Q99.3 Q100.1 Q100.4 Q104.1 Q104.4 Q113.1 Q113.4 Q116.1 Q116.4 Q119.1 Q119.4 Q120.1 Q120.4 Q123.S Q124.S Q125.S Q126.S Q128.1 Q128.4 Q130.1 Q130.4 Q136.S Q137.S Q139.S Q146.S Q148.S Q157.S Q158.S Q159.S Q160.S Q161.S Q162.S Q163.S Q165.3 Q182.E Q183.S Q188.S Q190.S R1.1 R2.1 R3.2 R4.1 R6.2 R9.1 R11.1 R12.1 R14.1 R19.1 R22.1 R24.1 R27.2 R30.1 R35.2 R39.2 R40.2 R44.2 R45.2 R46.2 R48.1 R51.1 R52.1 R56.1 R67.1 R78.1 R83.1 R84.1 R96.1 R97.1 R99.1 R105.2 R113.1 R141.2 R150.1 R157.2 R165.1 R167.1 R174.2 R180.1 R183.1 R187.2 R189.2 R190.2 R192.2 R195.1 R196.2 R200.2 R202.1 R203.1 R205.1 R211.1 R215.2 R217.1 R219.1 R221.2 R241.1 R249.1 R252.1 R283.1 R285.1 R293.1 R303.1 R304.1 R306.1 R307.1 R310.2 R322.2 R325.1 R337.2 R340.1 R347.2 R354.2 R357.1 R358.2 R359.1 R360.2 R362.1 R363.1 R367.2 R371.1 R377.2 R412.1 R432.2 R433.2 R442.1 R443.1 R544.2 R765.2 R787.2 R791.2 R792.2 R816.2 R818.2 R820.2 R821.2 R824.2 R835.2 R836.2 R854.2 R860.2 R867.2 R869.2 R886.1 R894.2 R895.2 R896.1 R897.1 R901.2 R903.2 R906.2 R917.2 R919.2 R939.2 R945.2 R946.2 R947.1 R948.2 R950.2 R954.2 R957.1 R965.1 R968.2 R987.2 R988.1 R1912.1 R1936.2 R2685.2 R2686.2 R2691.2 R2715.2 R2716.2 R2717.2 R2718.2 R2729.1 R2731.2 R2732.2 R2755.1 R2759.2 R2760.2 R2771.1 R2773.1 R2781.1 R2798.1 R2799.2 R2800.2 R2801.1 R2803.1 R2806.1 R2836.2 R2878.1 R2879.2 R2880.2 R3204.2 R3247.1 R3308.2 R3310.2 R3316.2 R3333.2 R3368.1 R3382.1 R3541.1 R3585.1 R3624.2 R3722.2 RCH1.1 RCH2.1 RT10.1 S1.2 S4.2 S5.2 S6.2 S7.2 S8.2 S10.2 S11.2 S12.2 S13.2 S14.2 S15.2 S16.2 S17.2 S18.2 S19.2 S20.2 S21.2 S22.2 S23.2 S25.2 S26.2 S27.2 S28.2 S29.2 S30.2 S106.2 S107.2 S108.2 S109.2 S110.2 S111.2 S112.2 S113.2 S114.2 S115.2 S116.2 S117.2 SW1.3 SW1.4 SW1.5 SW1.6 SW2.3 SW2.4 SW2.5 SW2.6 SW3.1 SW3.2 SW3.5 SW3.6 SW5.2 SW6.3 SW6.4 U1.3 U1.S1 U2.2 U4.5 U4.6 U4.7 U4.8 U4.9 U4.10 U4.11 U4.12 U4.13 U4.19 U5.1 U5.3 U5.27 U5.49 U5.75 U5.91 U5.113 U5.122 U5.128 U6.5 U6.6 U6.7 U6.8 U6.9 U6.10 U6.11 U6.12 U6.13 U6.19 U7.7 U7.42 U7.43 U7.S1 U8.4 U9.12 U9.13 U9.14 U9.15 U9.19 U10.5 U10.6 U10.7 U10.8 U10.9 U10.10 U10.11 U10.12 U10.13 U10.19 U11.5 U11.6 U11.7 U11.8 U11.9 U11.10 U11.11 U11.12 U11.13 U11.19 U12.12 U12.13 U12.14 U12.15 U12.19 U13.5 U13.6 U13.7 U13.8 U13.9 U13.10 U13.11 U13.12 U13.13 U13.19 U14.5 U14.6 U14.7 U14.8 U15.5 U15.6 U15.7 U15.8 U15.9 U15.10 U15.11 U15.12 U15.13 U15.19 U16.5 U16.6 U16.7 U16.8 U17.12 U17.13 U17.14 U17.15 U17.19 U18.12 U18.13 U18.14 U18.15 U18.19 U19.11 U20.4 U23.3 U24.3 U25.2 U26.A3 U26.A4 U26.A6 U26.A9 U26.A10 U26.A12 U26.A14 U26.A16 U26.A18 U26.A20 U26.A22 U26.A24 U26.A26 U26.A28 U26.A30 U26.A34 U26.AA12 U26.AA29 U26.AA30 U26.AB6 U26.AB33 U26.AB34 U26.AC1 U26.AC2 U26.AC3 U26.AC4 U26.AC5 U26.AC6 U26.AC12 U26.AC37 U26.AC38 U26.AD6 U26.AD7 U26.AD8 U26.AD9 U26.AD10 U26.AD11 U26.AD12 U26.AD29 U26.AD30 U26.AE6 U26.AE33 U26.AE34 U26.AF1 U26.AF2 U26.AF3 U26.AF4 U26.AF12 U26.AF13 U26.AF14 U26.AG6 U26.AG7 U26.AG8 U26.AG10 U26.AG11 U26.AG13 U26.AG29 U26.AG30 U26.AH6 U26.AH12 U26.AH33 U26.AH34 U26.AH35 U26.AH36 U26.AJ1 U26.AJ2 U26.AJ3 U26.AJ4 U26.AJ5 U26.AJ6 U26.AJ13 U26.AJ37 U26.AJ38 U26.AK4 U26.AK29 U26.AK30 U26.AL4 U26.AL7 U26.AL8 U26.AL9 U26.AL10 U26.AL12 U26.AL14 U26.AL33 U26.AL34 U26.AM1 U26.AM2 U26.AM3 U26.AM4 U26.AM5 U26.AM12 U26.AM37 U26.AM38 U26.AN5 U26.AN6 U26.AN12 U26.AN29 U26.AN30 U26.AP8 U26.AP9 U26.AP10 U26.AP11 U26.AP12 U26.AP33 U26.AP34 U26.AR1 U26.AR2 U26.AR3 U26.AR4 U26.AR5 U26.AR13 U26.AR14 U26.AR29 U26.AR30 U26.AR31 U26.AR32 U26.AR33 U26.AR34 U26.AR35 U26.AR36 U26.AR37 U26.AR38 U26.AT6 U26.AT29 U26.AT30 U26.AU6 U26.AU7 U26.AU8 U26.AU9 U26.AU10 U26.AU11 U26.AU12 U26.AU33 U26.AU34 U26.AV37 U26.AV38 U26.AW1 U26.AW2 U26.AW3 U26.AW4 U26.AW5 U26.AW12 U26.AW29 U26.AW30 U26.AY12 U26.AY14 U26.AY33 U26.AY34 U26.B3 U26.B9 U26.B37 U26.BA6 U26.BA7 U26.BA8 U26.BA9 U26.BA10 U26.BA11 U26.BA12 U26.BA37 U26.BA38 U26.BB1 U26.BB2 U26.BB3 U26.BB4 U26.BB5 U26.BB6 U26.BB12 U26.BB29 U26.BB30 U26.BC6 U26.BC12 U26.BC13 U26.BC14 U26.BC33 U26.BC34 U26.BD6 U26.BD7 U26.BD8 U26.BD9 U26.BD10 U26.BD11 U26.BD12 U26.BD37 U26.BD38 U26.BE1 U26.BE2 U26.BE3 U26.BE4 U26.BE5 U26.BE6 U26.BE29 U26.BE30 U26.BF6 U26.BF12 U26.BF33 U26.BF34 U26.BG6 U26.BG12 U26.BG13 U26.BG14 U26.BG37 U26.BG38 U26.BH1 U26.BH2 U26.BH3 U26.BH4 U26.BH5 U26.BH6 U26.BH7 U26.BH8 U26.BH9 U26.BH10 U26.BH11 U26.BH12 U26.BH14 U26.BJ12 U26.BJ14 U26.BJ15 U26.BJ18 U26.BJ22 U26.BJ25 U26.BJ29 U26.BJ30 U26.BJ31 U26.BJ32 U26.BJ33 U26.BJ34 U26.BJ35 U26.BJ36 U26.BK6 U26.BK13 U26.BK14 U26.BK15 U26.BK18 U26.BK22 U26.BK25 U26.BK29 U26.BL6 U26.BL13 U26.BL14 U26.BL18 U26.BL19 U26.BL20 U26.BL21 U26.BL22 U26.BL29 U26.BL33 U26.BL35 U26.BL38 U26.BM2 U26.BM3 U26.BM5 U26.BM6 U26.BM7 U26.BM8 U26.BM9 U26.BM11 U26.BM12 U26.BM13 U26.BM14 U26.BM18 U26.BM21 U26.BM22 U26.BM23 U26.BM24 U26.BM25 U26.BM26 U26.BM27 U26.BM28 U26.BM29 U26.BM33 U26.BM35 U26.BM38 U26.BN2 U26.BN4 U26.BN7 U26.BN12 U26.BN14 U26.BN18 U26.BN19 U26.BN20 U26.BN21 U26.BN24 U26.BN29 U26.BN30 U26.BN31 U26.BN34 U26.BP7 U26.BP12 U26.BP14 U26.BP18 U26.BP21 U26.BP24 U26.BP25 U26.BP26 U26.BP29 U26.BP33 U26.BP34 U26.BR7 U26.BR9 U26.BR12 U26.BR14 U26.BR18 U26.BR21 U26.BR24 U26.BR25 U26.BR26 U26.BR29 U26.BR33 U26.BR34 U26.BR36 U26.BR38 U26.BT3 U26.BT4 U26.BT5 U26.BT8 U26.BT12 U26.BT14 U26.BT18 U26.BT21 U26.BT24 U26.BT26 U26.BT29 U26.BT32 U26.BT35 U26.BT36 U26.C2 U26.C5 U26.C8 U26.C9 U26.C11 U26.C13 U26.C15 U26.C17 U26.C19 U26.C21 U26.C23 U26.C25 U26.C27 U26.C29 U26.C31 U26.C37 U26.D3 U26.D6 U26.D9 U26.D10 U26.D12 U26.D14 U26.D16 U26.D18 U26.D20 U26.D22 U26.D24 U26.D26 U26.D28 U26.D30 U26.D33 U26.D38 U26.E4 U26.E9 U26.E34 U26.E35 U26.E38 U26.F2 U26.F3 U26.F4 U26.F5 U26.F8 U26.F9 U26.F11 U26.F13 U26.F15 U26.F17 U26.F19 U26.F21 U26.F23 U26.F25 U26.F27 U26.F29 U26.F31 U26.F36 U26.G4 U26.G5 U26.G6 U26.G8 U26.G9 U26.G10 U26.G12 U26.G14 U26.G16 U26.G18 U26.G20 U26.G22 U26.G23 U26.G24 U26.G26 U26.G28 U26.H11 U26.H12 U26.H18 U26.H22 U26.H25 U26.H32 U26.H35 U26.J4 U26.J7 U26.J10 U26.J18 U26.J22 U26.J25 U26.J32 U26.J33 U26.J36 U26.K1 U26.K2 U26.K3 U26.K4 U26.K5 U26.K7 U26.K8 U26.K9 U26.K10 U26.K11 U26.K38 U26.L29 U26.L30 U26.L33 U26.L34 U26.M6 U26.M12 U26.M13 U26.M14 U26.N1 U26.N2 U26.N3 U26.N4 U26.N5 U26.N6 U26.N7 U26.N8 U26.N9 U26.N10 U26.N11 U26.N12 U26.N33 U26.N34 U26.P6 U26.P12 U26.P37 U26.P38 U26.R12 U26.R29 U26.R30 U26.T1 U26.T2 U26.T3 U26.T4 U26.T5 U26.T7 U26.T8 U26.T9 U26.T10 U26.T11 U26.T12 U26.T13 U26.T14 U26.T33 U26.T34 U26.U6 U26.U37 U26.U38 U26.V6 U26.V12 U26.V29 U26.V30 U26.W1 U26.W2 U26.W3 U26.W4 U26.W5 U26.W12 U26.W33 U26.W34 U26.Y7 U26.Y8 U26.Y9 U26.Y10 U26.Y11 U26.Y13 U26.Y14 U26.Y37 U26.Y38 U27.1 U28.A2 U28.A3 U28.A4 U28.A5 U28.A8 U28.A28 U28.A33 U28.A37 U28.A45 U28.A46 U28.A47 U28.A48 U28.AA5 U28.AA19 U28.AA20 U28.AA25 U28.AA27 U28.AA28 U28.AA30 U28.AA31 U28.AA49 U28.AB19 U28.AB25 U28.AB31 U28.AC4 U28.AC12 U28.AC17 U28.AC33 U28.AC38 U28.AC46 U28.AD1 U28.AD2 U28.AD19 U28.AD22 U28.AD25 U28.AD49 U28.AE4 U28.AE12 U28.AE33 U28.AE38 U28.AE46 U28.AF22 U28.AF25 U28.AF28 U28.AG1 U28.AG22 U28.AG23 U28.AG25 U28.AG27 U28.AG28 U28.AG30 U28.AG49 U28.AH12 U28.AH17 U28.AH33 U28.AH38 U28.AJ19 U28.AJ20 U28.AJ25 U28.AJ27 U28.AJ28 U28.AJ30 U28.AJ31 U28.AK4 U28.AK19 U28.AK20 U28.AK25 U28.AK27 U28.AK28 U28.AK30 U28.AK31 U28.AK46 U28.AL12 U28.AL17 U28.AL21 U28.AL24 U28.AL26 U28.AL29 U28.AL33 U28.AL38 U28.AM1 U28.AM18 U28.AM32 U28.AM49 U28.AN12 U28.AN16 U28.AN34 U28.AN38 U28.AP4 U28.AP46 U28.AR12 U28.AR16 U28.AR34 U28.AR38 U28.AT1 U28.AT16 U28.AT18 U28.AT21 U28.AT24 U28.AT26 U28.AT29 U28.AT32 U28.AT34 U28.AT45 U28.AV11 U28.AV39 U28.AW4 U28.AW10 U28.AW40 U28.AW46 U28.B47 U28.B48 U28.B49 U28.BA5 U28.BA6 U28.BA12 U28.BA14 U28.BA44 U28.BB9 U28.BB41 U28.BB43 U28.BC8 U28.BC10 U28.BC13 U28.BC15 U28.BC19 U28.BC24 U28.BC26 U28.BC31 U28.BC35 U28.BC40 U28.BC45 U28.BD43 U28.BE44 U28.BF1 U28.BF2 U28.BF3 U28.BF48 U28.BF49 U28.BG2 U28.BG3 U28.BG4 U28.BG17 U28.BG22 U28.BG25 U28.BG28 U28.BG33 U28.BG37 U28.BG48 U28.C4 U28.C5 U28.C12 U28.C25 U28.C30 U28.C48 U28.D8 U28.D12 U28.D16 U28.D17 U28.D30 U28.D33 U28.E8 U28.E10 U28.E13 U28.E15 U28.E17 U28.E19 U28.E22 U28.E24 U28.E26 U28.E31 U28.E33 U28.E35 U28.E40 U28.E42 U28.F41 U28.F43 U28.F47 U28.G6 U28.G44 U28.H8 U28.J4 U28.J9 U28.J10 U28.J26 U28.J29 U28.J40 U28.J46 U28.J47 U28.J48 U28.K11 U28.K39 U28.M5 U28.M16 U28.M18 U28.M21 U28.M24 U28.M32 U28.M34 U28.M49 U28.N12 U28.N16 U28.N34 U28.N35 U28.N37 U28.N38 U28.P4 U28.P26 U28.P29 U28.P46 U28.R3 U28.R4 U28.R12 U28.R16 U28.R26 U28.R29 U28.R34 U28.R38 U28.T4 U28.T5 U28.T7 U28.T17 U28.T18 U28.T32 U28.T49 U28.U12 U28.U15 U28.U17 U28.U21 U28.U24 U28.U33 U28.U38 U28.V4 U28.V20 U28.V22 U28.V46 U28.W25 U28.W27 U28.W28 U28.W30 U28.Y9 U28.Y10 U28.Y12 U28.Y17 U28.Y33 U28.Y38 U29.3 U30.11 U31.1 U32.4 U32.9 U83.4 U84.11 U104.11 U104.S1 U105.11 U105.S1 U106.11 U106.S1 U107.11 U107.S1 U721.S1 U722.S1 U733.1 U1901.S1 Y2.2 Y2.4 Y3.2 Y3.4
GND_BQ24781S: C3535.1 C3536.2 C3537.1 C3557.1 C3559.1 C3560.1 C3565.1 C3572.1 C3576.1 C3579.2 C3580.1 PJP28.1 R3309.2 R3328.2 U97.13 U97.22 U97.29
PVDD_+1.8VA: C402.1 C1423.1 PJP17.1 U19.9 U19.10
VCC_+1.0VA: C83.2 R924.1 U17.21
VCC_+3.3VA: C82.2 R881.1 U12.21
VCC_DRV_NVD: C257.1 R278.1 R280.1 U32.6
VCC_VCCIO: C86.2 R941.1 U18.21
VCCDPHY_1P24: C341.2 R389.2 U28.AJ22 U28.AJ23 U28.AK22 U28.AK23
VCCDSW_PCH: C285.2 U28.BG45 U28.BG46
VCCGT_SENSE: R50.1 R539.1 U26.AH38
VCCIO_ON: R3820.1 U5.84
VCCIO_ON_R: R3494.2 R3821.2 U24.4
VCCIO_SENSE: C3669.1 R54.1 R3366.2 R3369.2 U26.H14
VCCMPHY_SENSE: R370.2 R3395.1 U28.K47
VCCSA_SENSE: R55.1 R536.1 U26.M38
VCCST_PG_EN: Q2.2 U23.4
VCCST_PWRGD: Q2.3 R20.1 R33.1
VCCST_PWRGD_R: R20.2 U26.H13
VCCST_PWRON_R: C3623.1 R3372.2 U105.3
VDD33_MPS: C216.1 R560.2 U3.44
VIN: B7.1 C407.2 C3532.1 C3536.1 C3538.1 C3539.1 C3540.1 C3554.1 C3573.2 PJP9.2 PJP12.2 PJP14.2 PJP16.2 PJP18.1 PJP19.1 PJP20.1 PJP21.1 PJP22.1 PJP23.2 PJP24.1 PQ37.2 PQ37.3 PQ37.4 Q10.5 Q10.6 Q10.7 Q10.8 R199.2 R218.2 R297.2 R344.2 R345.1 R558.1 R899.1 R1091.2 R3298.2
VIN1N_INA: C1247.2 R181.2 R252.2 U1.11
VIN1P_INA: C1247.1 R177.2 R241.2 U1.12
VIN2N_INA: C1258.2 R185.2 R303.2 U1.14
VIN2P_INA: C1258.1 R182.2 R283.2 U1.15
VIN3N_INA: C1259.2 R204.2 R306.2 U1.1
VIN3P_INA: C1259.1 R208.2 R304.2 U1.2
VIN_1.2VS: C159.1 C160.1 C185.1 C193.1 PJP23.1 U25.1
VIN_+1.0VA: C3600.1 C3601.1 C3602.1 C3628.1 PJP14.1 R1397.1 U17.8 U17.9 U17.22
VIN_+2.5VS: C1236.1 R3822.2 U25.8
VIN_+3.3VA: C1270.1 C1271.1 C1272.1 C1358.1 PJP12.1 R879.1 U12.8 U12.9 U12.22
VIN_+5VA: C3561.1 C3562.1 C3563.1 C3593.1 C4117.1 PJP9.1 R220.1 R224.1 U9.7 U9.8 U9.9 U9.22
VIN_+VCCCORE: C1293.1 C1294.1 C1300.1 C1301.1 C3571.1 C3584.1 C3585.1 C3586.1 C3587.1 C3588.1 C3589.1 C3590.1 C3591.1 C3592.1 C3594.1 C3595.1 C3596.1 C3597.1 C3598.1 C3599.1 C3605.1 C3607.1 C3608.1 C3609.1 C4118.1 PJP18.2 PJP19.2 PJP22.2 PJP24.2 U4.1 U4.14 U6.1 U6.14 U10.1 U10.14 U11.1 U11.14
VIN_+VCCGT: C1308.1 C3610.1 C3614.1 C3615.1 C3618.1 C3619.1 C4119.1 PJP20.2 U13.1 U13.14
VIN_LCD: B26.2 Q42.D R3036.1
VIN_LCD_CON: B26.1 CNEDP1.28 CNEDP1.29 CNEDP1.30
VIN_LCD_IN0: B7.2 C473.1 Q42.S R405.1
VIN_NV: PJP10.1 R345.2 R346.2 R387.2 R1083.2 R1084.2 R1085.2
VIN_VCCIO: C3633.1 C3660.1 C3661.1 C3743.2 PJP16.1 R1398.1 U18.8 U18.9 U18.22
VIN_VCCSA: C1307.1 C3624.1 C3629.1 C3636.1 C3637.1 PJP21.2 U15.1 U15.14
VSS_AL37: TP24.1 U28.AL37
VSSGT_SENSE: R51.2 R547.1 U26.AH37
VSSIO_SENSE: R52.2 R3370.2 R3375.1 U26.J14
VSSMPHY_SENSE: R377.1 R3402.1 U28.K46
VSSSA_SENSE: R56.2 R538.1 U26.M37
687_GND_+1.2VS: C119.2 PJP34.1 R134.2 U25.4
+V_DDR_VREFCA_CHB_DIMM: C78.2 CN11.164 R41.1 R42.2 R44.1
A0_INA: R200.1 R201.1 U1.5
A_COVER LED_ BL: CNEDP1.26 Q27.D
AC DETECT: C3583.2 Q67.D R3305.2 R3308.1 U97.6
AC_IN+: B13.1 B20.1 C578.1 C597.1 C3578.1 CNDCIN1.1
AC_REMOVAL: Q3.5 Q3.6 Q4.5 Q4.6 R32.1 U5.107
ACZ_BITCLK: C260.2 R110.1 R119.1
ACZ_BITCLK_PCH: R110.2 U28.BD11
ACZ_RST#: C137.2 R176.1 U7.11
ACZ_RST#_PCH: R176.2 U28.BE10
ACZ_SDATAIN0: R117.1 U28.BE11
ACZ_SDATAOUT: C172.2 R271.1 U7.5
ACZ_SDOUT_PCH: R271.2 R284.1 U28.BF12
ACZ_SPKR: C131.2 R136.2 U28.AW29
ACZ_SPKR_B1: C131.1 C138.1 R101.2
ACZ_SPKR_B2: C130.2 C139.1 R97.2 R101.1
ACZ_SYNC: C136.2 R295.1 U7.10
ACZ_SYNC_PCH: R295.2 U28.BG13
ADAP_IN: C2.2 Q3.2 Q4.2 R3306.2 U5.18 U28.BG42 U97.5
AMP_MUTE#: CN12.1 R121.1 U5.20
APU_LCDVDD_EN_G: C1347.2 Q113.2 R986.2
AUDIO_USB_OC#: R79.2 R3628.2 U28.AL41
AUX_EDP_CH_N: C345.2 CNEDP1.14
AUX_EDP_CH_P: C346.2 CNEDP1.15
AUX_OFF#: Q51.C R902.1
BAT1C: C3552.1 CN30.8 CN30.U8 D42.1 R3314.2 S108.1
BAT1D: C3549.1 CN30.7 CN30.U7 D42.2 R3315.2 S106.1
BAT+: B36.1 B37.1 C3551.1 C3558.2 C3575.1 C3577.1 CN30.10 CN30.11 CN30.12 CN30.13 CN30.U10 CN30.U11 CN30.U12 CN30.U13 Q12.G R186.2 R194.1 R3333.1
BAT_I: C347.1 R348.1 R3299.2 U5.70
BAT_SMBCLK: Q60.6 R145.1 R3314.1 U5.110 U97.12
BAT_SMBDAT: Q60.3 R144.1 R3315.1 U5.111 U97.11
BAT_V: C232.1 Q119.6 R187.1 R194.2 U5.73
BAT_V_ON#: Q119.2 Q119.3 Q155.G R186.1 R3316.1
BATLOW#: R111.1 U28.BF44
BATPRESS: Q12.D R3310.1 R3334.2 U97.15
BATT-: C3575.2 C3577.2 CN30.1 CN30.2 CN30.3 CN30.4 CN30.U1 CN30.U2 CN30.U3 CN30.U4 R317.1 RCH1.2 RCH2.2
BATT_DUMP(ROM_PWR): C3553.1 CN30.6 CN30.U6 D43.1 Q155.D S107.1
BATT_TEMP: R3324.1 U5.71
BATT_TEMP_R: C3550.1 CN30.5 CN30.U5 D43.2 R3313.2 R3324.2 S109.1
BATT_VA_OFF#: Q88.2 R896.2 U5.79
BL_ON: CNEDP1.25 U29.4
BOARD ID: Q57.G R174.1 R246.2 U5.34
BOOT_GCORE1: R925.2 U721.1
BST1_NVD: R232.1 U722.1
BST2_NVD: R239.1 U722.18
BST3_NVD: R242.1 U32.2
BST_1.2VS: R842.2 U25.10
BST_+1.0VA: R3361.2 U17.20
BST_+3.3VA: R66.2 U12.20
BST_+5VA: R223.2 U9.20
BST_VCCIO: R3379.2 U18.20
BT_ON: CNWLAN1.54 R103.2 R105.1 R3247.2 U5.87
BTL_BEEP: C138.2 U5.28
C COVER LIGHT: R3692.2 U5.97
CAP+: C179.1 U7.36
CAP-: C179.2 U7.35
CATERR#: R26.1 U26.BM30
CFG0: R9.2 U26.BN25
CFG2: R11.2 U26.BN26
CFG4: R22.2 U26.BR20
CFG5: R12.2 U26.BM20
CFG6: R14.2 U26.BT20
CFG7: R19.2 U26.BP20
CFG8: TP41.1 U26.BR23
CFG9: TP42.1 U26.BR22
CFG10: TP44.1 U26.BT23
CFG11: TP43.1 U26.BT22
CFG12: TP46.1 U26.BM19
CFG13: TP45.1 U26.BR19
CFG14: TP47.1 U26.BP19
CFG15: TP48.1 U26.BT19
CFG16: TP52.1 U28.AK48
CHG_G_LED: CN9.3 CN12.42 R3723.1 U5.24
CHG_LX: C3541.2 L49.2 PQ37.9 R3312.2 U97.27
CHG_REF: C353.1 R326.2 U5.81
CHGR_LED: C14.1 LED2.C Q190.D R10.1
CLEAR CMOS: C3384.1 Q16.2 Q16.5 U5.99
CLK_CPU_24MHZ_DN: U26.D31 U28.C6
CLK_CPU_24MHZ_DP: U26.E31 U28.D7
CLK_CPU_BCLK_DN: U26.A32 U28.C8
CLK_CPU_BCLK_DP: U26.B31 U28.B8
CLK_CPU_PCIBCLK_DN: U26.C36 U28.B6
CLK_CPU_PCIBCLK_DP: U26.D35 U28.A6
CLK_EC_LPC: R323.2 U5.13
CLK_LAN_REQ: R312.2 R1907.2 U28.BB30 U1901.12
CLK_PCIE_GFX_DN: G1.BM27 U28.AH9
CLK_PCIE_GFX_DP: G1.BM26 U28.AH10
CLK_PCIE_LAN_DN: U28.AE6 U1901.16
CLK_PCIE_LAN_DP: U28.AE7 U1901.15
CLK_PCIE_WLAN_DN: CNWLAN1.49 U28.AB2
CLK_PCIE_WLAN_DP: CNWLAN1.47 U28.AB3
CLK_TPM: CNDEG1.6 R334.2
CLKIN_XTAL: CNWLAN1.64 R443.2 U28.R6
CLKREQ_MD2_SSD1: CNSSD1.52 R350.2 U28.AE41
CLKREQ_MD2_SSD2: CNSSD2.52 R341.2 U28.AR32
CNV_BRI_DT: CNWLAN1.36 R368.2 U28.AV4
CNV_BRI_RSP: CNWLAN1.22 U28.AY2
CNV_RF_RESET#: CNWLAN1.10 R442.2 U28.BE16
CNV_RGI_DT: CNWLAN1.32 R356.2 R362.2 U28.BA4
CNV_RGI_RSP: CNWLAN1.34 U28.AV3
CNV_WR_CLKN: CNWLAN1.21 U28.BD4
CNV_WR_CLKP: CNWLAN1.23 U28.BE3
CNV_WR_D0N: CNWLAN1.15 U28.BB3
CNV_WR_D0P: CNWLAN1.17 U28.BB4
CNV_WR_D1N: CNWLAN1.9 U28.BA3
CNV_WR_D1P: CNWLAN1.11 U28.BA2
CNV_WT_CLKN: CNWLAN1.71 U28.BC5
CNV_WT_CLKP: CNWLAN1.73 U28.BB6
CNV_WT_D0N: CNWLAN1.65 U28.BE6
CNV_WT_D0P: CNWLAN1.67 U28.BD7
CNV_WT_D1N: CNWLAN1.59 U28.BG6
CNV_WT_D1P: CNWLAN1.61 U28.BF6
CNV_WT_RCOMP: R367.1 U28.BA1
CODEC_BITCLK: C164.2 R119.2 U7.6
CODEC_DIN: R117.2 U7.8
CODEC_EAPD: R123.2 U7.47
CODEC_GND: AB1.2 AB3.2 AB4.2 AB5.2 AC3.2 AR6.2 AR25.2 C143.1 C161.2 C163.2 C178.2 C183.2 C194.2 C195.2 C199.1 C1234.2 U7.26 U7.37
CODEC_PCBEEP: C139.2 U7.12
CORE_PLLVDD_GPU: B34.2 C677.1 C719.1 C1432.2 C1433.2 C1442.2 C1443.2 C1444.2 C1445.2 C1446.2 C1457.2 G1.AF11 G1.BB24 G1.BC12 G1.BD12 G1.BD15 G1.BD21 G1.U42
CPU_2_PCH_TRIGGER: R431.2 U28.AK2
CPU_PROCHOT#: R29.2 U3.31
CPU_TRST#_PCH: TP55.1 U28.AM4
CPU_VCCIO_PWR_GATE#: TP38.1 U28.AY3
CPUCORE_ON_EC: R505.1 U5.100
CPVEE: C178.1 U7.34
CT1_1V8_AON: C3893.2 U107.12
CT2_1V8_MAIN: C3896.2 U107.10
DAS_SSD2: CNSSD1.10 CNSSD2.10 TP198.1 TP199.1
DC_IN: C3582.1 D28.1 Q8.5 Q8.6 Q8.7 Q8.8 Q41.5 Q41.6 Q41.7 Q41.8 Q41.S1 Q43.5 Q43.6 Q43.7 Q43.8 Q43.S1 R900.1 R3305.1
DC_IN+: B13.2 B20.2 C469.1 C470.1 C595.2 C596.1 Q41.1 Q41.2 Q41.3 Q43.1 Q43.2 Q43.3 R393.1 R403.1 R412.2
DC_IN_B: C456.2 C3532.2 C3535.2 Q9.5 Q9.6 Q9.7 Q9.8 R344.1 R3295.2
DCIN_G: Q41.4 Q43.4 R403.2 R420.1
DDR0_A_ALERT_N: CN1.116 U26.AU5
DDR0_A_PARITY: CN1.143 U26.AG3
DDR0_VREF_DQ: TP39.1 U26.BP13
DDR1_B_ALERT_N: CN11.116 U26.AR8
DDR1_B_PARITY: CN11.143 U26.AJ7
DDR4_DIMM_DRAMRST#: C74.2 CN1.108 CN11.108 R43.1
DDR4_DRAMRST#: R43.2 R53.2 U28.BB46
DDR_RCOMP0: R1.2 U26.G1
DDR_RCOMP1: R2.2 U26.H1
DDR_RCOMP2: R4.2 U26.J2
DDR_VTT_PG_CTRL: R305.2 U26.BT13
DGPU_PEX_RXN_0: C1516.2 G1.BK27
DGPU_PEX_RXN_1: C1514.2 G1.BL29
DGPU_PEX_RXN_2: C1512.2 G1.BM30
DGPU_PEX_RXN_3: C1510.2 G1.BK30
DGPU_PEX_RXN_4: C1491.2 G1.BL32
DGPU_PEX_RXN_5: C1490.2 G1.BM33
DGPU_PEX_RXN_6: C1489.2 G1.BK33
DGPU_PEX_RXN_7: C1488.2 G1.BL35
DGPU_PEX_RXN_8: C1483.2 G1.BM36
DGPU_PEX_RXN_9: C1482.2 G1.BK36
DGPU_PEX_RXN_10: C1481.2 G1.BL38
DGPU_PEX_RXN_11: C1480.2 G1.BM39
DGPU_PEX_RXN_12: C1479.2 G1.BK39
DGPU_PEX_RXN_13: C1478.2 G1.BL41
DGPU_PEX_RXN_14: C1477.2 G1.BM42
DGPU_PEX_RXN_15: C1476.2 G1.BK42
DGPU_PEX_RXP_0: C1515.2 G1.BL27
DGPU_PEX_RXP_1: C1513.2 G1.BK29
DGPU_PEX_RXP_2: C1511.2 G1.BM29
DGPU_PEX_RXP_3: C1509.2 G1.BL30
DGPU_PEX_RXP_4: C1507.2 G1.BK32
DGPU_PEX_RXP_5: C1506.2 G1.BM32
DGPU_PEX_RXP_6: C1505.2 G1.BL33
DGPU_PEX_RXP_7: C1504.2 G1.BK35
DGPU_PEX_RXP_8: C1499.2 G1.BM35
DGPU_PEX_RXP_9: C1498.2 G1.BL36
DGPU_PEX_RXP_10: C1497.2 G1.BK38
DGPU_PEX_RXP_11: C1496.2 G1.BM38
DGPU_PEX_RXP_12: C1495.2 G1.BL39
DGPU_PEX_RXP_13: C1494.2 G1.BK41
DGPU_PEX_RXP_14: C1493.2 G1.BM41
DGPU_PEX_RXP_15: C1492.2 G1.BL42
DGPU_PEX_TXN_0: C1227.2 G1.BH26
DGPU_PEX_TXN_1: C1225.2 G1.BE26
DGPU_PEX_TXN_2: C1223.2 G1.BG27
DGPU_PEX_TXN_3: C867.2 G1.BH29
DGPU_PEX_TXN_4: C855.2 G1.BE29
DGPU_PEX_TXN_5: C853.2 G1.BG30
DGPU_PEX_TXN_6: C851.2 G1.BH32
DGPU_PEX_TXN_7: C847.2 G1.BE32
DGPU_PEX_TXN_8: C834.2 G1.BG33
DGPU_PEX_TXN_9: C833.2 G1.BH35
DGPU_PEX_TXN_10: C831.2 G1.BE35
DGPU_PEX_TXN_11: C829.2 G1.BG36
DGPU_PEX_TXN_12: C828.2 G1.BH38
DGPU_PEX_TXN_13: C826.2 G1.BE38
DGPU_PEX_TXN_14: C824.2 G1.BG39
DGPU_PEX_TXN_15: C822.2 G1.BG41
DGPU_PEX_TXP_0: C1224.2 G1.BG26
DGPU_PEX_TXP_1: C1226.2 G1.BF26
DGPU_PEX_TXP_2: C859.2 G1.BF27
DGPU_PEX_TXP_3: C868.2 G1.BG29
DGPU_PEX_TXP_4: C852.2 G1.BF29
DGPU_PEX_TXP_5: C854.2 G1.BF30
DGPU_PEX_TXP_6: C846.2 G1.BG32
DGPU_PEX_TXP_7: C848.2 G1.BF32
DGPU_PEX_TXP_8: C832.2 G1.BF33
DGPU_PEX_TXP_9: C830.2 G1.BG35
DGPU_PEX_TXP_10: C827.2 G1.BF35
DGPU_PEX_TXP_11: C789.2 G1.BF36
DGPU_PEX_TXP_12: C825.2 G1.BG38
DGPU_PEX_TXP_13: C823.2 G1.BF38
DGPU_PEX_TXP_14: C821.2 G1.BF39
DGPU_PEX_TXP_15: C788.2 G1.BH41
DGPU_PWR_ON: D4.1 Q96.1 R978.2 U28.AW24
DGPU_RST_PCH#: Q99.2 R363.2 U28.BF21
DIMM_DQ_CPU_VREF_B: C76.2 R41.2 U26.BR13
DMI_RXN0: U26.E8 U28.C33
DMI_RXN1: U26.F6 U28.C32
DMI_RXN2: U26.E5 U28.C31
DMI_RXN3: U26.J9 U28.C29
DMI_RXP0: U26.D8 U28.B33
DMI_RXP1: U26.E6 U28.B32
DMI_RXP2: U26.D5 U28.B31
DMI_RXP3: U26.J8 U28.B29
DMI_TXN0: U26.A8 U28.K34
DMI_TXN1: U26.B6 U28.G33
DMI_TXN2: U26.A5 U28.K32
DMI_TXN3: U26.B4 U28.G30
DMI_TXP0: U26.B8 U28.J35
DMI_TXP1: U26.C6 U28.F34
DMI_TXP2: U26.B5 U28.J32
DMI_TXP3: U26.D4 U28.F30
DMIC_CLK: B16.1 CNEDP1.34 D44.1
DMIC_CLK_L: B16.2 C2579.1 U7.3
DMIC_DATA: B15.1 CNEDP1.33 D44.2
DMIC_DATA_L: B15.2 C2578.1 U7.2
DP_D0+: C352.1 CNEDP1.12
DP_D0-: C354.1 CNEDP1.11
DP_D1+: C349.1 CNEDP1.9
DP_D1-: C351.1 CNEDP1.8
DP_D2+: C360.1 CNEDP1.6
DP_D2-: C361.1 CNEDP1.5
DP_D3+: C363.1 CNEDP1.3
DP_D3-: C362.1 CNEDP1.2
DSW_PWROK: R311.2 U28.AW41
E-USB-N1: CN23.2 D37.2 L22.4 R606.1 S26.1
E-USB-N2: CN32.2 D61.2 L65.4 R3695.1 S117.1
E-USB-P1: CN23.3 D37.1 L22.1 R605.1 S28.1
E-USB-P2: CN32.3 D61.1 L65.1 R3694.1 S116.1
EC_3.3VA: B1.2 C126.1 C142.1 C177.1 U5.26 U5.50 U5.92 U5.114 U5.121 U5.127
EC_BL_ON: U5.76 U29.1
EC_EXTSMI#: R116.1 U5.15 U28.AL47
EC_LANWAKE: R226.2 U5.104
EC_OVERT_GPU#: D51.2 Q63.D R236.1 U5.16
EC_PECI: R3129.1 U5.117
EC_PROCHOT: Q1.G R30.2 U5.77
ECSCI#: D30.C R114.1 U5.23
EDP_AUXN: C345.1 U26.B26
EDP_AUXP: C346.1 U26.C26
EDP_HPD: C466.1 CNEDP1.21 R371.2 S18.1 U28.AN6
EDP_TXN0: C354.2 U26.E29
EDP_TXN1: C351.2 U26.E28
EDP_TXN2: C361.2 U26.B29
EDP_TXN3: C362.2 U26.B28
EDP_TXP0: C352.2 U26.D29
EDP_TXP1: C349.2 U26.F28
EDP_TXP2: C360.2 U26.A29
EDP_TXP3: C363.2 U26.C28
EN1_1.2VS: C113.1 Q146.D R172.1 R3198.1 U25.16
EN2_1.2VS: C145.1 R156.2 U25.15
EN3_NVD: C282.2 R278.2 U32.7
EN_+1.0VA: C85.2 R64.1 U17.2
EN_+3.3VA: C84.2 R63.1 U12.2
EN_+5VA: C286.1 Q163.D R220.2 R221.1 R902.2 U9.2
EN_VCCIO: C3742.2 R3494.1 U18.2
EN_VRA: C588.2 R505.2 U3.37
EXT_Q_KEY0: CN9.8 R313.1
EXT_Q_KEY1: CN9.7 R3702.1
FAN0_DETECT: CNFAN2.2 R250.1 U5.47
FAN1_DETECT: CNFAN1.2 R254.1 U5.48
FAN_CTRL0: R248.1 U5.78 U16.4
FAN_CTRL1: R247.1 U5.80 U14.4
FAN_SPEED: C293.1 CNFAN1.3 R230.1
FAN_SPEED1: C305.1 CNFAN2.3 R214.1
FB_1.2VS: R134.1 R163.2 R3201.1 U25.13
FB_+1.0VA: C3604.2 R3365.1 R3385.2 U17.5
FB_+1.8VA: C134.2 R193.1 R219.2 U19.6
FB_+3.3VA: C1508.2 R880.1 R886.2 U12.5
FB_+5VA: C3650.2 R3381.1 R3382.2 U9.5
FB_EN_GC6_PCH: D16.2 Q92.3 Q165.2 R3540.2 U28.V48
FB_REFPLL_AVDD_GPU: B27.2 C819.2 C849.2 C871.1 C881.2 C882.2 C883.2 G1.AF42 G1.AN42 G1.L17 G1.L29 G1.L38 G1.V11
FB_VCCIO: C3669.2 R3366.1 R3375.2 U18.5
FB_VREF_PROBE: G1.P45 TP3.1
FBA_CLK0_N: G1.AG46 M41.J11 R2735.2
FBA_CLK0_P: G1.AG45 M41.J12 R2733.2
FBA_CLK1_N: G1.AK45 M42.J11 R2736.2
FBA_CLK1_P: G1.AK46 M42.J12 R2734.2
FBA_CMD0: G1.Y51 M41.G3
FBA_CMD1: G1.Y52 M41.J3 R890.2
FBA_CMD2: G1.Y49 M41.J2 R894.1
FBA_CMD3: G1.AA52 M41.L3
FBA_CMD4: G1.AA51 M41.K5
FBA_CMD5: G1.AA50 M41.K4
FBA_CMD6: G1.AC50 M41.J5
FBA_CMD7: G1.AC51 M41.J4
FBA_CMD8: G1.AC52 M41.H5
FBA_CMD9: G1.AC49 M41.H4
FBA_CMD10: G1.AD52 M41.G12
FBA_CMD11: G1.AD51 M41.H10
FBA_CMD12: G1.AD50 M41.H11
FBA_CMD13: G1.AF50 M41.K11
FBA_CMD14: G1.AF51 M41.K10
FBA_CMD15: G1.AF52 M41.L12
FBA_CMD16: G1.AN50 M42.L3
FBA_CMD17: G1.AN51 M42.J3 R893.2
FBA_CMD18: G1.AN52 M42.J2 R895.1
FBA_CMD19: G1.AM49 M42.G3
FBA_CMD20: G1.AM52 M42.H5
FBA_CMD21: G1.AM51 M42.H4
FBA_CMD22: G1.AM50 M42.J5
FBA_CMD23: G1.AK50 M42.J4
FBA_CMD24: G1.AK51 M42.K5
FBA_CMD25: G1.AK52 M42.K4
FBA_CMD26: G1.AJ49 M42.L12
FBA_CMD27: G1.AJ52 M42.K10
FBA_CMD28: G1.AJ51 M42.K11
FBA_CMD29: G1.AJ50 M42.H11
FBA_CMD30: G1.AG50 M42.H10
FBA_CMD31: G1.AG51 M42.G12
FBA_D0: G1.U51 M41.V4
FBA_D1: G1.U48 M41.V2
FBA_D2: G1.U50 M41.T4
FBA_D3: G1.U49 M41.T2
FBA_D4: G1.R51 M41.N4
FBA_D5: G1.R50 M41.N2
FBA_D6: G1.R47 M41.M4
FBA_D7: G1.U46 M41.M2
FBA_D8: G1.V46 M41.V11
FBA_D9: G1.Y45 M41.V13
FBA_D10: G1.Y47 M41.T11
FBA_D11: G1.Y46 M41.T13
FBA_D12: G1.V50 M41.N11
FBA_D13: G1.V47 M41.N13
FBA_D14: G1.U52 M41.M11
FBA_D15: G1.V51 M41.M13
FBA_D16: G1.AJ44 M41.A11
FBA_D17: G1.AG48 M41.A13
FBA_D18: G1.AJ45 M41.B11
FBA_D19: G1.AG49 M41.B13
FBA_D20: G1.AF46 M41.E11
FBA_D21: G1.AF47 M41.E13
FBA_D22: G1.AF48 M41.F11
FBA_D23: G1.AD47 M41.F13
FBA_D24: G1.AD49 M41.A4
FBA_D25: G1.AD48 M41.A2
FBA_D26: G1.AC46 M41.B4
FBA_D27: G1.AC47 M41.B2
FBA_D28: G1.AA47 M41.E4
FBA_D29: G1.AA46 M41.E2
FBA_D30: G1.AA45 M41.F4
FBA_D31: G1.Y44 M41.F2
FBA_D32: G1.AW51 M42.A4
FBA_D33: G1.BA52 M42.A2
FBA_D34: G1.AW50 M42.B4
FBA_D35: G1.BA51 M42.B2
FBA_D36: G1.BA50 M42.E4
FBA_D37: G1.BB50 M42.E2
FBA_D38: G1.BA49 M42.F4
FBA_D39: G1.AW49 M42.F2
FBA_D40: G1.AV48 M42.A11
FBA_D41: G1.AT49 M42.A13
FBA_D42: G1.AT47 M42.B11
FBA_D43: G1.AT48 M42.B13
FBA_D44: G1.AT46 M42.E11
FBA_D45: G1.AV51 M42.E13
FBA_D46: G1.AV52 M42.F11
FBA_D47: G1.AV49 M42.F13
FBA_D48: G1.AJ48 M42.V11
FBA_D49: G1.AJ46 M42.V13
FBA_D50: G1.AJ47 M42.T11
FBA_D51: G1.AK49 M42.T13
FBA_D52: G1.AM47 M42.N11
FBA_D53: G1.AM46 M42.N13
FBA_D54: G1.AN48 M42.M11
FBA_D55: G1.AN49 M42.M13
FBA_D56: G1.AM44 M42.V4
FBA_D57: G1.AM45 M42.V2
FBA_D58: G1.AN45 M42.T4
FBA_D59: G1.AN46 M42.T2
FBA_D60: G1.AR48 M42.N4
FBA_D61: G1.AN47 M42.N2
FBA_D62: G1.AR47 M42.M4
FBA_D63: G1.AR46 M42.M2
FBA_DBI0: G1.U47 M41.P2
FBA_DBI1: G1.Y48 M41.P13
FBA_DBI2: G1.AG47 M41.D13
FBA_DBI3: G1.AC48 M41.D2
FBA_DBI4: G1.BB51 M42.D2
FBA_DBI5: G1.AV50 M42.D13
FBA_DBI6: G1.AM48 M42.P13
FBA_DBI7: G1.AR49 M42.P2
FBA_DEBUG0: G1.Y50 R887.2
FBA_DEBUG1: G1.AR50 R888.2
FBA_EDC0: G1.R48 M41.R2
FBA_EDC1: G1.V48 M41.R13
FBA_EDC2: G1.AF44 M41.C13
FBA_EDC3: G1.AA48 M41.C2
FBA_EDC4: G1.BB52 M42.C2
FBA_EDC5: G1.AT50 M42.C13
FBA_EDC6: G1.AK48 M42.R13
FBA_EDC7: G1.AR51 M42.R2
FBA_VREFC: C874.2 C880.2 M41.J14 M42.J14 R2691.1 R2692.2 R2693.1
FBA_WCK01_N: G1.U44 M41.P5
FBA_WCK01_P: G1.U45 M41.P4
FBA_WCK23_N: G1.AC44 M41.D5
FBA_WCK23_P: G1.AC45 M41.D4
FBA_WCK45_N: G1.AV46 M42.D5
FBA_WCK45_P: G1.AV47 M42.D4
FBA_WCK67_N: G1.AR44 M42.P5
FBA_WCK67_P: G1.AR45 M42.P4
FBA_ZQ0: M41.J13 R2685.1
FBA_ZQ2: M42.J13 R2686.1
FBB_CLK0_N: G1.G42 M43.J11 R2738.2
FBB_CLK0_P: G1.H42 M43.J12 R2737.2
FBB_CLK1_N: G1.E47 M44.J11 R2740.2
FBB_CLK1_P: G1.F47 M44.J12 R2739.2
FBB_CMD0: G1.B35 M43.G3
FBB_CMD1: G1.A35 M43.J3 R898.2
FBB_CMD2: G1.D35 M43.J2 R903.1
FBB_CMD3: G1.A36 M43.L3
FBB_CMD4: G1.B36 M43.K5
FBB_CMD5: G1.C36 M43.K4
FBB_CMD6: G1.C38 M43.J5
FBB_CMD7: G1.B38 M43.J4
FBB_CMD8: G1.A38 M43.H5
FBB_CMD9: G1.D38 M43.H4
FBB_CMD10: G1.A39 M43.G12
FBB_CMD11: G1.B39 M43.H10
FBB_CMD12: G1.C39 M43.H11
FBB_CMD13: G1.C41 M43.K11
FBB_CMD14: G1.B41 M43.K10
FBB_CMD15: G1.A41 M43.L12
FBB_CMD16: G1.B49 M44.L3
FBB_CMD17: G1.A49 M44.J3 R904.2
FBB_CMD18: G1.A48 M44.J2 R906.1
FBB_CMD19: G1.D47 M44.G3
FBB_CMD20: G1.A47 M44.H5
FBB_CMD21: G1.B47 M44.H4
FBB_CMD22: G1.C47 M44.J5
FBB_CMD23: G1.C45 M44.J4
FBB_CMD24: G1.B45 M44.K5
FBB_CMD25: G1.A45 M44.K4
FBB_CMD26: G1.D44 M44.L12
FBB_CMD27: G1.A44 M44.K10
FBB_CMD28: G1.B44 M44.K11
FBB_CMD29: G1.C44 M44.H11
FBB_CMD30: G1.C42 M44.H10
FBB_CMD31: G1.B42 M44.G12
FBB_D0: G1.H32 M43.V4
FBB_D1: G1.D32 M43.V2
FBB_D2: G1.A33 M43.T4
FBB_D3: G1.B32 M43.T2
FBB_D4: G1.E32 M43.N4
FBB_D5: G1.G32 M43.N2
FBB_D6: G1.J30 M43.M4
FBB_D7: G1.F32 M43.M2
FBB_D8: G1.H36 M43.V11
FBB_D9: G1.G36 M43.V13
FBB_D10: G1.J36 M43.T11
FBB_D11: G1.F36 M43.T13
FBB_D12: G1.F33 M43.N11
FBB_D13: G1.D33 M43.N13
FBB_D14: G1.J32 M43.M11
FBB_D15: G1.G33 M43.M13
FBB_D16: G1.E45 M43.A11
FBB_D17: G1.D45 M43.A13
FBB_D18: G1.F45 M43.B11
FBB_D19: G1.G45 M43.B13
FBB_D20: G1.D42 M43.E11
FBB_D21: G1.E42 M43.E13
FBB_D22: G1.F42 M43.F11
FBB_D23: G1.H41 M43.F13
FBB_D24: G1.E41 M43.A4
FBB_D25: G1.F39 M43.A2
FBB_D26: G1.E39 M43.B4
FBB_D27: G1.D39 M43.B2
FBB_D28: G1.F38 M43.E4
FBB_D29: G1.E38 M43.E2
FBB_D30: G1.D36 M43.F4
FBB_D31: G1.E36 M43.F2
FBB_D32: G1.M50 M44.A4
FBB_D33: G1.P48 M44.A2
FBB_D34: G1.M51 M44.B4
FBB_D35: G1.M49 M44.B2
FBB_D36: G1.P47 M44.E4
FBB_D37: G1.P52 M44.E2
FBB_D38: G1.R46 M44.F4
FBB_D39: G1.P46 M44.F2
FBB_D40: G1.L50 M44.A11
FBB_D41: G1.L51 M44.A13
FBB_D42: G1.L52 M44.B11
FBB_D43: G1.L49 M44.B13
FBB_D44: G1.M46 M44.E11
FBB_D45: G1.L47 M44.E13
FBB_D46: G1.M48 M44.F11
FBB_D47: G1.M47 M44.F13
FBB_D48: G1.D48 M44.V11
FBB_D49: G1.C50 M44.V13
FBB_D50: G1.C48 M44.T11
FBB_D51: G1.C49 M44.T13
FBB_D52: G1.E49 M44.N11
FBB_D53: G1.E50 M44.N13
FBB_D54: G1.F49 M44.M11
FBB_D55: G1.F48 M44.M13
FBB_D56: G1.F50 M44.V4
FBB_D57: G1.D52 M44.V2
FBB_D58: G1.J50 M44.T4
FBB_D59: G1.H48 M44.T2
FBB_D60: G1.H51 M44.N4
FBB_D61: G1.J51 M44.N2
FBB_D62: G1.H49 M44.M4
FBB_D63: G1.H52 M44.M2
FBB_DBI0: G1.C32 M43.P2
FBB_DBI1: G1.E33 M43.P13
FBB_DBI2: G1.E44 M43.D13
FBB_DBI3: G1.G39 M43.D2
FBB_DBI4: G1.P49 M44.D2
FBB_DBI5: G1.L48 M44.D13
FBB_DBI6: G1.D50 M44.P13
FBB_DBI7: G1.H50 M44.P2
FBB_DEBUG0: G1.C35 R892.2
FBB_DEBUG1: G1.B50 R907.2
FBB_EDC0: G1.B33 M43.R2
FBB_EDC1: G1.E35 M43.R13
FBB_EDC2: G1.G44 M43.C13
FBB_EDC3: G1.H38 M43.C2
FBB_EDC4: G1.P50 M44.C2
FBB_EDC5: G1.J48 M44.C13
FBB_EDC6: G1.D51 M44.R13
FBB_EDC7: G1.F51 M44.R2
FBB_VREFC: C884.2 C955.2 M43.J14 M44.J14 R2712.2 R2713.1 R2716.1
FBB_WCK01_N: G1.H33 M43.P5
FBB_WCK01_P: G1.J33 M43.P4
FBB_WCK23_N: G1.H39 M43.D5
FBB_WCK23_P: G1.J39 M43.D4
FBB_WCK45_N: G1.L45 M44.D5
FBB_WCK45_P: G1.L46 M44.D4
FBB_WCK67_N: G1.H46 M44.P5
FBB_WCK67_P: G1.H47 M44.P4
FBB_ZQ0: M43.J13 R2715.1
FBB_ZQ2: M44.J13 R2731.1
FBC_CLK0_N: G1.F15 M45.J11 R2742.2
FBC_CLK0_P: G1.G15 M45.J12 R2741.2
FBC_CLK1_N: G1.J21 M46.J11 R2745.2
FBC_CLK1_P: G1.H21 M46.J12 R2746.2
FBC_CMD0: G1.C11 M45.G3
FBC_CMD1: G1.B11 M45.J3 R915.2
FBC_CMD2: G1.A11 M45.J2 R917.1
FBC_CMD3: G1.D11 M45.L3
FBC_CMD4: G1.A12 M45.K5
FBC_CMD5: G1.B12 M45.K4
FBC_CMD6: G1.C12 M45.J5
FBC_CMD7: G1.C14 M45.J4
FBC_CMD8: G1.B14 M45.H5
FBC_CMD9: G1.A14 M45.H4
FBC_CMD10: G1.D14 M45.G12
FBC_CMD11: G1.A15 M45.H10
FBC_CMD12: G1.B15 M45.H11
FBC_CMD13: G1.C15 M45.K11
FBC_CMD14: G1.C17 M45.K10
FBC_CMD15: G1.B17 M45.L12
FBC_CMD16: G1.B24 M46.L3
FBC_CMD17: G1.A24 M46.J3 R916.2
FBC_CMD18: G1.D23 M46.J2 R919.1
FBC_CMD19: G1.A23 M46.G3
FBC_CMD20: G1.B23 M46.H5
FBC_CMD21: G1.C23 M46.H4
FBC_CMD22: G1.C21 M46.J5
FBC_CMD23: G1.B21 M46.J4
FBC_CMD24: G1.A21 M46.K5
FBC_CMD25: G1.D20 M46.K4
FBC_CMD26: G1.A20 M46.L12
FBC_CMD27: G1.B20 M46.K10
FBC_CMD28: G1.C20 M46.K11
FBC_CMD29: G1.C18 M46.H11
FBC_CMD30: G1.B18 M46.H10
FBC_CMD31: G1.A18 M46.G12
FBC_D0: G1.C6 M45.V4
FBC_D1: G1.D6 M45.V2
FBC_D2: G1.A6 M45.T4
FBC_D3: G1.B6 M45.T2
FBC_D4: G1.B4 M45.N4
FBC_D5: G1.A4 M45.N2
FBC_D6: G1.B3 M45.M4
FBC_D7: G1.C4 M45.M2
FBC_D8: G1.D9 M45.V11
FBC_D9: G1.C9 M45.V13
FBC_D10: G1.E9 M45.T11
FBC_D11: G1.B9 M45.T13
FBC_D12: G1.B8 M45.N11
FBC_D13: G1.A8 M45.N13
FBC_D14: G1.F6 M45.M11
FBC_D15: G1.E6 M45.M13
FBC_D16: G1.F18 M45.A11
FBC_D17: G1.G18 M45.A13
FBC_D18: G1.E18 M45.B11
FBC_D19: G1.H18 M45.B13
FBC_D20: G1.D15 M45.E11
FBC_D21: G1.E15 M45.E13
FBC_D22: G1.G17 M45.F11
FBC_D23: G1.H17 M45.F13
FBC_D24: G1.J15 M45.A4
FBC_D25: G1.H15 M45.A2
FBC_D26: G1.E14 M45.B4
FBC_D27: G1.F14 M45.B2
FBC_D28: G1.H11 M45.E4
FBC_D29: G1.G11 M45.E2
FBC_D30: G1.F11 M45.F4
FBC_D31: G1.E11 M45.F2
FBC_D32: G1.J29 M46.A4
FBC_D33: G1.F30 M46.A2
FBC_D34: G1.H29 M46.B4
FBC_D35: G1.G30 M46.B2
FBC_D36: G1.B30 M46.E4
FBC_D37: G1.A30 M46.E2
FBC_D38: G1.H30 M46.F4
FBC_D39: G1.C30 M46.F2
FBC_D40: G1.D27 M46.A11
FBC_D41: G1.J26 M46.A13
FBC_D42: G1.F27 M46.B11
FBC_D43: G1.G27 M46.B13
FBC_D44: G1.C27 M46.E11
FBC_D45: G1.B27 M46.E13
FBC_D46: G1.A27 M46.F11
FBC_D47: G1.G29 M46.F13
FBC_D48: G1.H20 M46.V11
FBC_D49: G1.D18 M46.V13
FBC_D50: G1.G20 M46.T11
FBC_D51: G1.E20 M46.T13
FBC_D52: G1.F23 M46.N11
FBC_D53: G1.E21 M46.N13
FBC_D54: G1.D21 M46.M11
FBC_D55: G1.E23 M46.M13
FBC_D56: G1.G24 M46.V4
FBC_D57: G1.H26 M46.V2
FBC_D58: G1.F24 M46.T4
FBC_D59: G1.G26 M46.T2
FBC_D60: G1.F26 M46.N4
FBC_D61: G1.D26 M46.N2
FBC_D62: G1.B26 M46.M4
FBC_D63: G1.C26 M46.M2
FBC_DBI0: G1.A5 M45.P2
FBC_DBI1: G1.C8 M45.P13
