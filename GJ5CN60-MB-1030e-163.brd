# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCCORE on L5_VCC2: 128.2,111.71 127.71,112.2 127.71,113 129.11,114.4 129.11,131.63 128.2,132.54 125.02,132.54 118.44,139.12 118.44,146.41 119.69,147.65 146.53,147.65 147.01,147.17 147.01,132.39 146.51,131.88 146.51,111.94 146.27,111.71
+VCCCORE on L6_IN2: 121.26,147.45 146.18,147.45 148.49,145.14 148.49,136.88 145.01,133.4 129.89,133.4 127.63,135.66 127.63,139.91 126.34,141.2 120.24,141.2 119.02,142.42 119.02,145.21
+VCCCORE on L6_IN2: 131.14,124.18 146.66,124.18 147.34,123.5 147.34,112.58 146.2,111.43 127.43,111.43 127.05,111.81 127.05,112.19 129.87,115.01 129.87,122.91
+VCCCORE on L6_IN2: 143.01,131.99 144.36,130.64 146.16,130.64 146.23,130.57 146.23,125.66 146.05,125.48 144.98,125.48 144.8,125.66 130.48,125.66 129.54,126.6 129.54,131.63 129.91,131.99
+VCCCORE on L8_IN3: 120.9,146.87 146.91,146.87 148.39,145.39 148.39,137.34 146.15,135.11 146.15,124.82 147.12,123.85 147.12,114.61 145.97,113.46 139.11,113.46 137.69,112.04 128.52,112.04 128.04,112.53 128.04,113.29 128.83,114.07 128.83,122.71 129.39,123.27 129.39,126.65 124.51,131.52 124.51,139.86 122.99,141.38 119.68,141.38 118.9,142.17 118.9,144.86
+VCCDSW_3P3 on TOP: 130.76,15.03 129.68,16.1 129.31,16.1 129.09,16.33 128.83,16.33 128.74,16.24 128.74,15.99 128.85,15.88 129.04,15.88 129.22,15.7 129.47,15.7 130.25,14.93 130.25,13.93 130.63,13.54 130.63,10.62 130.76,10.49 131.14,10.49 131.39,10.75 131.39,13.54 130.76,14.18
+VCCGT on TOP (solid shape): outline of 1491 points within 147.27,111.59 163.27,143.6
+VCCGT on BOTTOM (solid shape): outline of 2380 points within 147.29,111.33 164.41,143.84
+VCCGT on L4_VCC1, L5_VCC2: 147.12,111.84 147.01,111.94 147.01,131.67 147.52,132.18 147.52,147.17 148.01,147.65 164.18,147.65 166.95,144.88 166.95,114.1 164.69,111.84
+VCCGT on L6_IN2: 152.35,143.97 161.37,143.97 162.13,143.21 162.13,135.46 160.86,134.19 152.6,134.19 150.7,136.1 150.7,142.32
+VCCGT on L6_IN2: 151.84,123.02 160.1,123.02 160.73,122.38 160.73,113.87 158.83,111.97 148.18,111.97 148.03,112.12 148.03,122.13 149.43,123.52 151.33,123.52
+VCCGT on L8_IN3: 150.95,143.97 161.62,143.97 162.19,143.4 162.19,133.37 163.78,131.78 163.78,114.13 161.87,112.22 157.62,112.22 155.82,114.02 147.64,114.02 147.4,114.27 147.4,124.92 147.01,125.3 147.01,134.57 149.17,136.73 149.17,142.19
+VCCIO on TOP (solid shape): 111,155.6 111,148.34 110.55,147.89 108.3,147.89 105.17,151.02 105.17,155.72 105.36,155.91 110.69,155.91
+VCCIO on TOP (solid shape): outline of 363 points within 125.41,113.73 128.47,123.6
+VCCIO on L6_IN2 (solid shape): outline of 447 points within 137.99,107.25 141.02,112.04
+VCCIO on BOTTOM: 113.7,152.38 114.67,151.41 114.67,144.29 115.65,143.31 115.65,137.75 115.9,137.49 116.42,137.49 117.18,136.73 117.18,134.6 116.42,133.83 111.97,133.83 108.41,137.4 108.41,146.64 106.88,148.16 106.88,151.59 107.67,152.38
+VCCIO on BOTTOM: 130.5,115.52 129.62,115.52 127.84,113.74 127.21,113.74 126.86,114.1 126.86,122.87 127.23,123.24 127.55,123.24 127.76,123.11 127.99,123.1 128.68,123.1 128.68,123.1 130.67,123.1 131.01,122.76 131.01,116.03
+VCCIO on L3_IN1: 127.8,118.91 127.8,116.63 127.75,116.54 127.65,116.54 127.15,116.26 127.65,115.97 127.75,115.97 127.8,115.89 127.8,115.31 128.72,114.39 128.72,111.69 128.45,111.42 126.21,111.42 125.84,111.8 125.84,113.41 125.55,113.69 125.55,119.13 125.81,119.38 127.53,119.38 127.56,119.36 127.71,119.36 127.94,119.59 128.04,119.59 128.09,119.54 128.09,119.21
+VCCIO on L5_VCC2: 112.58,112.09 111.2,113.47 111.2,143.26 107.01,147.45 107.01,150.53 107.43,150.96 116.18,150.96 118.66,148.47 118.66,147.35 117.93,146.62 117.93,138.91 124.81,132.03 127.99,132.03 128.6,131.42 128.6,114.61 127.2,113.21 127.2,112.2 127.1,112.09
+VCCIO on L8_IN3: 125.49,114.07 125.57,114.29 125.49,114.51 125.49,114.85 125.57,115.06 125.49,115.27 125.49,115.64 125.66,115.93 125.49,116.21 125.49,117.22 125.57,117.44 125.49,117.66 125.49,118.79 125.57,119.01 125.49,119.23 125.49,119.49 125.55,119.58 125.66,119.56 126.22,119.78 125.7,120.07 125.63,120.15 125.77,120.28 125.8,120.27 126.23,120.64 125.69,120.84 125.62,120.82 125.56,120.84 125.53,120.87 125.49,120.89 125.49,121.13 125.52,121.18 125.55,121.23 127.33,123.02 127.57,123.02 127.95,122.63 127.95,114 127.7,113.74 125.82,113.74
+VCCSA on TOP (solid shape): outline of 435 points within 115.14,124.08 129.3,134.95
+VCCSA on TOP: 170.71,134.12 167.05,134.12 166.62,133.68 165.07,133.68 164.51,134.24 164.51,137.85 163.98,138.38 162.53,138.38 162.13,138.79 162.13,141.68 162.41,141.96 166.98,141.96 168.99,143.97 170.64,143.97 170.92,143.69 170.92,134.32
+VCCSA on BOTTOM: 170.89,134.95 169.62,133.68 165.18,133.68 164.71,134.14 164.71,137.77 164.4,138.08 162.91,138.08 162.3,138.69 162.3,141.48 162.38,141.56 170.38,141.56 170.89,141.05
+VCCSA on BOTTOM: 124.66,135.08 127.46,135.08 129.49,133.05 129.49,127.71 130,127.21 130.63,127.21 130.76,127.08 130.76,126.57 130.5,126.32 130.12,126.32 129.23,125.43 127.07,125.43 125.13,127.37 122.25,127.37 122.1,127.52 122.1,128.47 122.02,128.56 122.02,132.52 121.74,132.79 120.22,132.79 119.84,133.18 119.84,133.68 120.22,134.06 123.65,134.06
+VCCSA on L3_IN1: 124.28,126.62 124.28,135.46 125.36,136.54 125.42,136.48 127.71,136.48 130,134.19 160.22,134.19 160.6,134.57 160.6,138.13 161.75,139.27 161.75,141.18 162.22,141.65 175.24,141.65 175.97,140.92 175.97,129.75 172.67,126.44 172.67,117.43 168.86,113.62 130.12,113.62 128.6,115.14 128.6,122.76 127.58,123.78 127.12,123.78
+VCCSA on L6_IN2: 124.97,128.43 124.66,128.76 124.59,128.79 124.56,128.86 124.56,130.97 125.3,131.7 129.08,131.7 129.32,131.46 129.32,125.82 128.9,125.39 127.08,125.39 124.56,127.91 124.56,127.99 124.59,128.06 124.66,128.1
GND POWER on TOP (solid shape): 7.31,154.51 7.31,152.1 6.68,151.46 4.9,151.46 4.39,151.97 4.39,154 5.16,154.77 7.06,154.77
GND POWER on TOP (solid shape): 8.3,103.33 8.3,102.06 8.2,101.96 5.66,101.96 5.51,102.11 5.51,103.38 5.56,103.43 8.2,103.43
GND POWER on TOP (solid shape): 24.23,136.76 24.23,132.73 24.1,132.6 20.07,132.6 19.66,133.01 19.66,136.73 19.78,136.85 24.14,136.85
GND POWER on TOP (solid shape): 42.94,163.76 42.94,160.28 42.36,159.71 31.31,159.71 30.99,160.04 30.99,164.08 31.13,164.22 42.47,164.22
GND POWER on TOP (solid shape): 47.23,70.05 47.23,66.88 46.68,66.33 42.26,66.33 41.89,66.71 41.89,69.89 42.13,70.14 47.14,70.14
GND POWER on TOP (solid shape): 63.76,140.61 63.76,140.23 63.17,139.64 62.57,139.64 61.87,140.34 61.87,140.54 62.06,140.73 63.64,140.73
GND POWER on TOP (solid shape): 85.29,52.66 85.29,51.26 84.66,50.63 83.39,50.63 82.88,51.13 82.88,52.66 83.39,53.17 84.78,53.17
GND POWER on TOP (solid shape): 114.53,165.16 114.53,161.66 114.17,161.3 109.86,161.3 109.33,161.83 109.33,164.67 110.21,165.55 114.15,165.55
GND POWER on TOP (solid shape): 114.83,155.76 114.83,149.69 113.84,148.69 111.78,148.69 111.33,149.15 111.33,155.45 111.99,156.11 114.48,156.11
GND POWER on TOP (solid shape): 152.14,139.45 152.14,135.08 151.79,134.72 150.16,134.72 149.6,135.28 149.6,138.38 151,139.78 151.81,139.78
GND POWER on TOP (solid shape): 154.14,92.77 154.14,92.13 154.01,92 138.14,92 138.01,92.13 138.01,92.77 138.14,92.89 154.01,92.89
GND POWER on TOP (solid shape): 164.18,137.7 164.18,134.67 163.96,134.45 162.36,134.45 162.18,134.62 162.18,137.9 162.33,138.05 163.83,138.05
GND POWER on TOP (solid shape): 183.87,14 183.87,12.4 183.77,12.3 181.96,12.3 181.86,12.4 181.86,14 181.96,14.1 183.77,14.1
GND POWER on TOP (solid shape): 83.19,68.89 83.19,62.28 83.1,62.19 81.75,62.19 81.67,62.27 81.67,69.09 81.73,69.15 82.92,69.15
GND POWER on TOP (solid shape): 183.06,38.81 183.06,36.07 182.45,35.46 180.08,35.46 179.63,35.92 179.63,38.95 179.75,39.07 182.8,39.07
GND POWER on TOP (solid shape): 7.5,98.82 7.8,98.82 8.07,98.55 8.07,96.46 7.93,96.32 1.37,96.32 1.22,96.47 1.22,100.03 1.47,100.27 6.05,100.27
GND POWER on TOP (solid shape): 107.26,15.38 107.26,14.37 107.11,14.23 105.38,14.23 105.27,14.35 105.27,15.38 105.52,15.63 106.12,15.63 106.2,15.71 106.93,15.71
GND POWER on TOP (solid shape): 113.99,147.53 113.99,139.4 113.74,139.14 112.72,139.14 112.22,139.65 112.22,147.27 112.72,147.78 113.74,147.78
GND POWER on TOP (solid shape): 67.11,161.48 67.11,160.81 67.01,160.71 67.01,159.74 66.83,159.56 65.87,159.56 65.75,159.67 65.75,159.96 65.92,160.12 65.92,161.57 66.06,161.71 66.87,161.71
GND POWER on TOP (solid shape): 81.36,6.23 81.36,5.11 80.92,4.68 79.4,4.68 79.02,5.06 79.02,6.25 79.27,6.51 81.08,6.51
GND POWER on TOP (solid shape): 150.49,143.59 150.49,139.83 149.38,138.71 149.38,135.23 148.97,134.83 147.52,134.83 147.34,135 147.34,142.45 147.73,142.83 148.03,142.83 148.92,143.72 150.37,143.72
GND POWER on TOP (solid shape): 96.3,158.16 96.3,157.69 96.48,157.51 99.58,157.51 99.69,157.41 99.69,156.27 99.32,155.91 93.92,155.91 93.62,156.21 93.62,158.21 93.7,158.28 96.17,158.28
GND POWER on TOP (solid shape): 127.8,173.8 127.8,168.79 127.53,168.52 125.81,168.52 125.62,168.71 125.62,169.13 125.89,169.4 125.89,172.74 126.01,172.87 126.65,172.87 126.89,173.1 126.89,173.82 126.95,173.88 127.71,173.88
GND POWER on TOP (solid shape): 149.2,161.67 149.2,155.76 148.97,155.53 148.51,155.53 148,155.02 148,154.87 147.85,154.71 147.01,154.71 146.86,154.87 146.86,156.64 146.68,156.82 145.16,156.82 145.11,156.87 145.11,163.78 145.26,163.93 146.94,163.93
GND POWER on TOP (solid shape): 4.8,85.05 4.8,83.45 4.92,83.33 5.72,83.33 5.92,83.53 5.92,84.98 6.14,85.19 10.44,85.19 10.46,85.17 10.46,82.49 10.26,82.29 1.6,82.29 1.27,82.62 1.27,84.86 1.6,85.19 4.67,85.19
GND POWER on TOP (solid shape): 11.74,124.67 11.74,122.81 11.86,122.69 13.3,122.69 13.56,122.95 13.56,124.53 13.71,124.68 17.63,124.68 17.74,124.56 17.74,122.11 16.84,121.21 8.63,121.21 7.79,122.06 7.79,124.61 7.9,124.73 8.48,124.73 11.68,124.73
GND POWER on TOP (solid shape): 29.41,84.6 29.41,82.21 29.32,82.12 28.49,82.12 28.38,82.01 28.38,80.71 28.14,80.47 28.14,77.23 27.87,76.96 24.86,76.96 24.34,77.47 24.34,84.38 24.52,84.56 28.27,84.56 28.41,84.69 29.32,84.69
GND POWER on TOP (solid shape): 191.38,111.06 191.38,109.82 191.16,109.6 188.78,109.6 188.57,109.39 188.57,109.16 188.51,109.1 185.89,109.1 185.86,109.12 185.86,109.58 185.96,109.68 187.87,109.68 188.22,110.03 188.22,110.95 188.47,111.2 191.24,111.2
GND POWER on TOP (solid shape): 2.14,81.74 2.14,79 2.59,78.55 5.27,78.55 5.46,78.36 5.46,75.64 5.82,75.28 9.02,75.28 9.17,75.13 9.17,73.83 8.76,73.42 4.99,73.42 4.39,74.02 4.39,75.01 4.1,75.3 1.82,75.3 1.04,76.09 1.04,81.75 1.18,81.89 2,81.89
GND POWER on TOP (solid shape): 17.6,151.59 17.6,149.18 17.22,148.8 7.85,148.8 7.73,148.92 7.73,151.49 7.84,151.6 8.32,151.6 8.33,151.59 11.25,151.59 11.39,151.44 11.39,150.39 11.59,150.19 12.71,150.19 12.87,150.35 12.87,151.56 13.02,151.72 17.47,151.72
GND POWER on TOP (solid shape): 170.36,158.78 170.36,155.8 171.42,154.74 171.42,151.23 170.64,150.45 168.15,150.45 167.05,149.36 166.14,149.36 166.1,149.4 166.1,151.03 165.79,151.34 164.34,151.34 164.29,151.39 164.29,152.96 164.51,153.19 165.78,153.19 165.99,153.39 165.99,159.39 166.17,159.57 169.57,159.57
GND POWER on TOP (solid shape): 44.91,149.02 44.91,148.58 44.19,147.86 44.19,128.34 40.21,124.36 40.21,123.89 39.58,123.26 31.98,123.26 31.74,123.5 31.74,126.43 32.01,126.7 38.94,126.7 42.1,129.86 42.1,131.07 42.13,131.1 42.13,135.6 42.1,135.62 42.1,139.43 42.13,139.46 42.13,144.84 42.1,144.87 42.1,148.68 42.53,149.11 44.82,149.11
GND POWER on TOP (solid shape): 103.9,186.34 103.9,178.6 103.89,178.6 103.58,178.36 103.41,178 103.41,177.6 103.58,177.24 103.89,177 104.24,176.92 105.53,176.92 106.04,176.41 106.04,171.33 106.3,171.07 106.3,167.74 106.15,167.59 104.93,167.59 104.52,167.19 104.52,166.3 104.42,166.2 93.8,166.2 93.29,166.7 93.29,169.21 95.89,171.81 95.89,179.44 95.51,179.82 95.45,179.82 94.79,180.49 94.79,186.34 95.06,186.62 103.62,186.62
GND POWER on TOP (solid shape): 88.9,118.82 88.95,118.73 88.96,118.63 88.87,118.57 88.34,118.57 88.01,118.24 86.86,118.24 85.64,117.02 85.59,117.01 85.56,117.06 85.56,117.13 86.93,118.51 87.55,118.51 88.02,118.98 88.86,118.98
GND POWER on TOP (solid shape): 125.25,140.85 127.91,140.85 128.22,140.54 128.22,139.58 128.4,139.4 128.4,133.73 128.22,133.56 127.46,133.56 127.4,133.62 127.43,133.65 127.56,133.98 127.36,134.27 127.33,134.29 127.33,134.88 126.82,135.39 124.94,135.39 124.1,134.55 119.33,134.55 117.37,136.5 117.37,141.02 118.69,142.34 123.75,142.34
GND POWER on TOP (solid shape): 161.83,168.27 161.83,161.31 161.84,161.29 161.84,155.77 162.05,155.56 162.05,154.41 161.87,154.23 160.63,154.23 159.42,153.03 159.42,151.39 159.73,151.08 159.73,150.29 159.68,150.23 158.96,150.23 158.82,150.09 158.82,149.76 158.46,149.4 157.28,149.4 157.2,149.48 157.2,151.14 156.95,151.39 155.51,151.39 155.5,151.4 155.5,153.64 155.45,153.7 155.5,153.75 155.5,154.79 155.37,154.92 155.37,156.96 156.15,157.74 156.15,165.59 155.3,166.44 152.07,166.44 151.76,166.75 151.76,169.34 152.2,169.78 160.32,169.78
GND POWER on TOP (solid shape): 133.37,164.06 133.37,158.19 132.94,157.81 133.37,157.43 133.37,155.65 133.29,155.56 133.01,155.56 132.66,155.22 132.66,155.1 132.38,154.82 131.42,154.82 131.32,154.92 131.32,156.87 131.22,156.98 129.62,156.98 129.56,157.03 129.56,164.04 129.95,164.42 133.02,164.42
GND POWER on TOP (solid shape): 140.77,164.81 140.77,157.9 140.73,157.83 140.64,157.81 140.18,157.43 140.64,157.06 140.73,157.04 140.77,156.96 140.77,155.63 140.64,155.5 139.95,155.5 139.83,155.37 139.83,154.61 139.7,154.49 138.78,154.49 138.68,154.59 138.68,156.31 138.48,156.52 136.93,156.52 136.88,156.57 136.88,164.79 137.02,164.93 140.64,164.93
GND POWER on TOP (solid shape): 78.65,97.07 78.73,97.02 78.77,96.97 78.83,96.92 78.85,96.91 78.85,96.85 78.83,96.84 78.73,96.74 78.68,96.62 78.67,96.61 78.53,96.46 78.52,96.46 78.43,96.4 78.37,96.31 78.37,96.3 78.17,96.11 78.17,93.31 78.05,93.18 77.87,93.18 77.72,93.33 77.72,94.06 77.42,94.36 77.42,94.53 77.49,94.6 77.54,94.69 77.54,94.7 77.75,94.91 77.75,96.21 77.85,96.31 77.91,96.44 77.92,96.45 78.07,96.6 78.08,96.61 78.16,96.67 78.22,96.75 78.22,96.76 78.26,96.79 78.49,96.94 78.56,97.02
GND POWER on TOP (solid shape): 78.82,104.01 78.82,103.26 79.2,102.88 79.2,102.75 79.12,102.69 79.07,102.6 78.87,102.41 78.87,101.07 78.75,100.97 78.68,100.82 78.67,100.81 78.53,100.66 78.52,100.66 78.43,100.6 78.37,100.51 78.37,100.5 78.33,100.47 78.09,100.31 78.01,100.21 78,100.18 77.84,100.18 77.83,100.21 77.79,100.27 77.74,100.32 77.72,100.34 77.72,100.39 77.75,100.41 77.86,100.52 77.92,100.67 77.92,100.68 78.03,100.79 78.04,100.79 78.16,100.87 78.24,100.99 78.24,101 78.45,101.21 78.45,102.58 78.6,102.73 78.6,102.96 78.45,103.11 78.45,104.01 78.55,104.11 78.72,104.11
GND POWER on TOP (solid shape): 87.83,137.7 87.83,136.45 87.71,136.33 87.68,136.33 87.64,136.33 87.55,136.3 87.48,136.24 87.33,136.09 87.24,136.07 87.16,136.13 87.07,136.26 86.92,136.32 86.85,136.35 86.83,136.42 86.82,136.49 86.87,136.54 86.89,136.54 87.18,136.78 86.99,137.1 86.92,137.17 86.95,137.27 87.1,137.42 87.15,137.49 87.18,137.57 87.19,137.61 87.38,137.8 87.73,137.8
GND POWER on TOP (solid shape): 40.66,95.74 40.67,95.7 40.69,95.62 40.75,95.55 40.9,95.4 40.93,95.3 40.86,95.23 40.73,95.14 40.67,94.98 40.63,94.92 40.56,94.89 40.49,94.88 40.44,94.93 40.44,94.95 40.2,95.24 39.88,95.06 39.81,94.99 39.72,95.02 39.57,95.17 39.49,95.22 39.41,95.25 39.37,95.26 39.37,95.53 39.22,95.69 39.22,95.81 39.29,95.89 40.51,95.89
GND POWER on TOP (solid shape): 126.49,164.7 126.49,159.46 126.32,159.29 125.1,159.29 125.01,159.21 125.01,159.01 124.97,159.01 124.95,158.98 124.93,158.98 124.61,158.64 124.96,158.32 125,158.31 125.01,158.27 125.01,158.25 125.25,158.02 125.25,157.21 125.12,156.99 125.19,156.75 125.28,156.67 125.4,156.63 125.45,156.57 125.45,156.41 125.59,156.27 125.59,155.74 125.55,155.7 124.97,155.7 124.86,155.59 124.86,155.09 124.7,154.94 123.17,154.94 123.13,154.97 123.13,156.8 122.99,156.94 121.39,156.94 121.34,156.99 121.34,164.48 121.76,164.9 126.29,164.9
GND POWER on TOP (solid shape): 124,185.49 124,178.61 123.68,178.36 123.51,178 123.51,177.6 123.68,177.24 123.99,177 124.34,176.92 125.5,176.92 125.81,176.61 125.81,175.26 124.89,174.35 122.17,174.35 121.66,173.84 121.66,171.07 121.28,170.69 117.68,170.69 117.65,170.72 117.65,171.07 116.97,171.76 115.54,171.76 115.24,172.06 118.24,172.06 118.24,172.01 118.24,171.96 118.26,171.91 118.28,171.86 118.31,171.82 118.35,171.79 118.39,171.75 118.44,171.73 118.49,171.71 118.54,171.71 118.59,171.71 118.64,171.71 118.69,171.73 118.74,171.75 118.78,171.79 118.82,171.82 118.85,171.86 118.87,171.91 118.89,171.96 118.9,172.01 118.9,172.06 118.89,172.11 118.87,172.16 118.85,172.21 118.82,172.25 118.78,172.29 118.74,172.32 118.69,172.34 118.64,172.36 118.59,172.37 118.54,172.37 118.49,172.36 118.44,172.34 118.39,172.32 118.35,172.29 118.31,172.25 118.28,172.21 118.26,172.16 118.24,172.11 118.24,172.06 115.24,172.06 115.21,172.09 115.21,173.97 116.38,175.13 116.38,176.81 116.48,176.92 117.82,176.92 118.17,177 118.48,177.24 118.65,177.6 118.65,178 118.48,178.36 118.16,178.61 118.16,185.49 118.44,185.77 123.72,185.77
GND POWER on TOP (solid shape): 78,99.88 78.05,99.79 78.12,99.73 78.12,99.11 78.37,98.86 78.37,98.85 78.43,98.77 78.52,98.71 78.53,98.7 78.67,98.55 78.68,98.54 78.78,98.36 78.95,98.26 78.97,98.26 79.07,98.16 79.07,98.15 79.13,98.07 79.22,98.01 79.25,97.98 79.25,97.88 79.22,97.86 79.13,97.8 79.07,97.71 79.07,97.7 78.97,97.6 78.95,97.6 78.83,97.54 78.73,97.44 78.65,97.4 78.56,97.44 78.51,97.5 78.45,97.55 78.45,98.18 78.22,98.4 78.22,98.41 78.16,98.5 78.08,98.56 78.07,98.56 77.84,98.78 77.8,98.86 77.75,98.92 77.75,99.75 77.8,99.81 77.84,99.88 77.86,99.91 77.99,99.91
GND POWER on TOP (solid shape): 79.35,83.12 79.43,83.07 79.46,83.04 79.49,83 79.52,82.93 79.49,82.86 79.37,82.51 79.61,82.23 79.67,82.16 79.64,82.07 79.51,81.94 79.51,81.41 79.27,81.16 79.21,81.15 79.18,81.19 79.18,81.24 78.95,81.47 78.95,81.49 78.85,81.71 78.61,81.78 78.53,81.81 78.5,81.88 78.5,82.45 78.63,82.58 78.65,82.58 78.85,82.66 78.95,82.86 78.96,82.89 78.99,82.91 79.15,82.96 79.26,83.07
GND POWER on TOP (solid shape): 60.73,143.32 60.81,143.27 60.9,143.25 60.91,143.25 61.64,142.52 62.51,142.52 62.71,142.32 62.71,141.91 62.58,141.79 61.6,141.79 61.33,142.06 61.32,142.08 61.09,142.38 60.71,142.33 60.53,142.33 60.24,142.41 59.98,142.24 59.9,142.2 59.81,142.24 59.77,142.3 59.71,142.35 59.67,142.43 59.71,142.51 59.84,142.66 59.88,142.84 59.89,142.88 59.92,142.89 60.1,142.96 60.21,143.11 60.22,143.12 60.34,143.25 60.36,143.25 60.43,143.27 60.5,143.31 60.53,143.33 60.71,143.33
GND POWER on TOP (solid shape): 78.15,107.51 78.15,107.34 78,107.04 78.15,106.74 78.15,106.63 78.13,106.61 78.02,106.33 78.15,106.06 78.15,105.25 77.97,104.92 78.17,104.6 78.17,104.51 78.05,104.38 77.82,104.38 77.54,104.66 77.54,104.67 77.48,104.77 77.4,104.85 77.4,105.02 77.48,105.09 77.54,105.19 77.54,105.2 77.75,105.41 77.75,106.03 77.89,106.32 77.76,106.62 77.75,106.63 77.75,106.73 77.76,106.74 77.89,107.04 77.75,107.33 77.75,107.53 77.82,107.61 78.05,107.61
GND POWER on TOP (solid shape): 59.49,135.3 59.56,135.27 59.59,135.21 59.62,135.1 59.68,135.02 59.99,134.71 59.99,134.7 60.11,134.56 60.28,134.5 60.33,134.5 60.33,133.87 60.26,133.78 60.15,133.8 60.12,133.84 60.03,133.9 59.92,133.93 59.85,133.96 59.83,134.03 59.71,134.28 59.46,134.36 59.43,134.36 59.38,134.4 59.38,134.43 59.31,134.62 59.05,134.75 59.03,134.82 59.02,134.89 59.07,134.94 59.09,134.94 59.29,135.02 59.42,135.27 59.49,135.3
GND POWER on TOP (solid shape): 40.56,102.23 40.63,102.2 40.67,102.14 40.75,101.96 40.93,101.87 41,101.84 41.02,101.77 41.07,101.58 41.22,101.45 41.23,101.45 41.25,101.43 41.28,101.34 41.22,101.26 41.06,101.12 41.03,100.9 41.01,100.86 40.97,100.85 40.93,100.85 40.88,100.89 40.88,100.92 40.8,101.18 40.55,101.29 40.49,101.32 40.45,101.38 40.43,101.49 40.37,101.57 40.22,101.72 40.19,101.82 40.25,101.89 40.39,102 40.44,102.16 40.44,102.18 40.49,102.23
GND POWER on TOP (solid shape): 67.03,136.34 67.12,136.37 67.2,136.31 67.34,136.15 67.54,136.11 67.57,136.11 67.61,136.07 67.61,136.01 67.59,135.97 67.55,135.96 67.34,135.92 67.19,135.76 67.19,135.75 66.88,135.44 66.82,135.36 66.79,135.25 66.76,135.19 66.69,135.16 66.63,135.16 66.58,135.2 66.58,135.23 66.51,135.42 66.25,135.55 66.23,135.62 66.22,135.7 66.26,135.74 66.28,135.74 66.49,135.81 66.62,136.07 66.69,136.1 66.88,136.15 67,136.3 67.01,136.31
GND POWER on TOP (solid shape): 42.96,109.42 43.03,109.4 43.16,109.15 43.36,109.07 43.38,109.07 43.43,109.02 43.42,108.96 43.39,108.89 43.33,108.86 43.07,108.66 43.14,108.35 43.31,108.17 43.33,108.06 43.24,108 42.58,108 42.5,108.03 42.48,108.11 42.44,108.32 42.28,108.46 42.27,108.47 42.25,108.49 42.22,108.58 42.28,108.65 42.43,108.78 42.48,108.97 42.51,109.04 42.58,109.07 42.76,109.16 42.84,109.36 42.84,109.38 42.89,109.43
GND POWER on TOP (solid shape): 79.05,92.63 79.05,92.62 79.09,92.51 79.17,92.43 79.17,92.23 79.07,92.1 79.05,91.94 79.05,91.93 79.05,91.33 79.04,91.28 79.05,91.21 79.06,91.19 79.11,91.09 79.2,91.02 79.2,90.88 79.02,90.71 79.02,90.48 79.13,90.37 79.2,90.31 79.2,90.15 79.1,90.06 79.05,89.95 79.05,89.93 78.8,89.68 78.5,89.68 78.4,89.78 78.4,89.88 78.4,89.88 78.62,90.19 78.47,90.54 78.45,90.55 78.45,90.61 78.47,90.62 78.62,90.96 78.42,91.27 78.42,91.38 78.55,91.51 78.55,91.73 78.45,91.83 78.45,92.01 78.63,92.33 78.45,92.65 78.45,92.81 78.52,92.88 78.8,92.88
GND POWER on TOP (solid shape): 63.73,117.45 63.8,117.54 63.91,117.52 64.14,117.28 64.14,116.49 64.79,115.84 64.79,115.34 65.04,115.09 65.04,115.07 65.09,114.93 65.19,114.82 65.24,114.73 65.19,114.64 65.09,114.54 65.04,114.4 65.03,114.37 65,114.36 64.87,114.32 64.77,114.24 64.7,114.21 64.62,114.24 64.59,114.27 64.55,114.3 64.51,114.38 64.55,114.46 64.71,114.88 64.37,115.16 64.24,115.17 64.23,115.2 64.17,115.28 64.1,115.34 64.05,115.43 64.1,115.52 64.24,115.86 63.96,116.09 63.94,116.09 63.82,116.2 63.82,116.85 63.73,116.94
GND POWER on TOP (solid shape): 146.05,188.49 146.05,185.68 145.73,185.35 145.61,184.91 145.61,184.45 145.87,183.83 146.49,183.57 147.19,183.57 147.43,183.35 147.75,183.27 148.46,183.27 148.46,182.58 148.54,182.5 148.54,182.17 147.65,181.28 147.65,179.94 144.25,176.53 142.09,176.53 141.55,176 141.55,171.88 141.55,171.85 141.53,171.82 141.19,171.75 141.05,171.43 141.09,171.22 141.25,171.07 141.27,171.05 141.27,171 140.78,170.5 135.34,170.5 135.08,170.77 135.08,172.67 136.37,173.97 136.37,176.77 136.52,176.92 137.92,176.92 138.27,177 138.58,177.24 138.75,177.6 138.75,178 138.58,178.36 138.26,178.61 138.26,185.49 138.54,185.77 141.78,185.77 142.76,186.17 143.16,187.15 143.16,188.49 143.44,188.77 145.77,188.77
GND POWER on TOP (solid shape): 44.5,110.67 44.51,110.66 44.63,110.62 44.77,110.62 44.85,110.6 44.89,110.52 44.89,110.39 45.55,109.73 45.55,108.3 45.34,108.09 44.25,108.09 44.18,108.12 44.14,108.18 44.08,108.37 43.93,108.51 43.91,108.52 43.91,108.6 43.92,108.6 44.01,108.66 44.07,108.73 44.15,108.77 44.23,108.73 44.88,108.75 44.63,109.34 44.49,109.38 44.49,109.41 44.39,109.6 44.19,109.7 44.16,109.71 44.15,109.75 44.09,109.96 43.93,110.11 43.88,110.14 43.91,110.2 43.92,110.2 44.09,110.35 44.15,110.57 44.16,110.6 44.19,110.62 44.28,110.64 44.36,110.69 44.38,110.7
GND POWER on TOP (solid shape): 87.86,135.33 87.86,134.9 87.82,134.86 87.81,134.86 87.68,134.72 87.64,134.72 87.56,134.69 87.49,134.64 87.19,134.34 87.18,134.33 87.03,134.21 86.98,134.02 86.96,133.95 86.69,133.83 86.61,133.63 86.61,133.6 86.56,133.56 86.5,133.56 86.45,133.56 86.41,133.57 86.4,133.61 86.4,133.63 86.32,133.83 86.05,133.96 86.03,134.03 85.91,134.28 85.66,134.36 85.63,134.36 85.58,134.4 85.58,134.47 85.62,134.51 85.84,134.53 86,134.7 86.01,134.71 86.1,134.8 86.19,134.71 86.19,134.7 86.5,134.5 86.8,134.7 86.81,134.71 87.33,135.23 87.34,135.23 87.49,135.28 87.6,135.38 87.81,135.38
GND POWER on TOP (solid shape): 52.6,135.4 52.67,135.34 52.78,135.23 52.78,135.06 52.68,134.95 52.68,134.73 52.64,134.73 52.55,134.7 52.48,134.64 52.18,134.34 52.17,134.33 52.02,134.21 51.97,134.02 51.94,133.95 51.68,133.82 51.61,133.63 51.61,133.6 51.56,133.56 51.5,133.56 51.43,133.59 51.4,133.65 51.31,133.84 51.12,133.93 51.05,133.96 51.03,134.03 50.91,134.28 50.66,134.36 50.63,134.36 50.58,134.4 50.58,134.45 50.6,134.49 50.64,134.5 50.86,134.54 51,134.7 51.01,134.71 51.1,134.8 51.19,134.71 51.19,134.7 51.51,134.5 51.81,134.72 51.81,134.73 52.39,135.31 52.46,135.34 52.51,135.38
GND POWER on TOP (solid shape): 36.14,120.72 36.15,120.72 37.16,119.71 37.16,118.92 36.98,118.51 37.32,118.21 37.38,118.19 37.42,118.13 37.51,117.92 37.72,117.82 37.76,117.81 37.77,117.77 37.77,117.75 37.76,117.71 37.72,117.7 37.52,117.6 37.42,117.4 37.36,117.4 37.32,117.42 37.27,117.46 37.27,117.48 37.19,117.6 37.07,117.68 37.06,117.68 36.54,118.2 36.57,118.22 36.57,118.9 36.49,118.97 36.49,118.99 36.44,119.14 36.33,119.25 36.28,119.27 36.22,119.29 36.16,119.35 36.16,119.36 35.86,119.69 35.46,119.53 35.37,119.48 35.29,119.54 35.25,119.59 35.25,119.72 35.26,119.74 35.3,119.81 35.33,119.9 35.33,119.91 35.38,119.96 35.38,120.86 35.51,120.98 35.89,120.98
GND POWER on TOP (solid shape): outline of 111 points within 7.13,144.08 19,148.04
GND POWER on TOP (solid shape): 63.11,102.21 63.17,102.19 63.22,102.18 63.25,102.17 63.27,102.13 63.32,101.98 63.44,101.86 63.48,101.78 63.44,101.7 63.4,101.67 63.37,101.64 63.3,101.61 63.22,101.64 62.62,101.57 62.85,101.01 62.96,100.98 62.97,100.96 63.02,100.88 63.09,100.82 63.14,100.73 63.09,100.64 63.03,100.6 62.98,100.53 62.9,100.48 62.81,100.53 62.7,100.64 62.55,100.69 62.53,100.69 62.28,100.94 62.25,100.94 62.17,100.97 62.15,101.05 62.02,101.33 61.71,101.35 61.68,101.34 61.38,101.64 61.03,101.64 60.91,101.76 61.1,101.95 61.6,101.95 61.68,102.02 61.72,101.98 61.72,101.96 62.04,101.66 62.43,101.85 62.49,101.92 62.77,101.92 63.08,102.23
GND POWER on TOP (solid shape): 42.16,102.23 42.23,102.2 42.36,101.95 42.56,101.87 42.58,101.87 42.63,101.82 42.62,101.8 42.67,101.59 42.82,101.45 42.88,101.38 42.85,101.29 42.83,101.27 42.82,101.26 42.63,100.87 43.01,100.63 43.05,100.62 43.07,100.58 43.07,100.54 43.05,100.5 43.01,100.48 42.79,100.45 42.65,100.29 42.64,100.28 42.34,99.97 42.32,99.96 42.24,99.99 42.24,100.09 41.96,100.36 42.02,100.66 41.78,100.84 41.71,100.88 41.68,100.95 41.68,100.96 41.71,101.03 41.78,101.06 42.04,101.25 41.97,101.57 41.82,101.72 41.79,101.82 41.85,101.89 41.99,102 42.04,102.16 42.04,102.18 42.09,102.23
GND POWER on TOP (solid shape): 65,98.18 65.08,98.13 65.14,98.06 65.22,98 65.24,97.99 65.28,97.89 65.54,97.62 65.9,97.7 65.98,97.73 66.05,97.7 66.34,97.56 66.63,97.7 66.7,97.74 66.78,97.71 66.82,97.68 66.82,97.48 66.75,97.42 66.7,97.33 66.69,97.32 66.43,97.06 66.36,97.03 66.28,97.07 66.02,97.18 65.78,97.03 65.7,96.98 65.61,97.03 65.51,97.14 65.37,97.18 65.34,97.2 65.32,97.23 65.06,97.54 64.67,97.44 64.6,97.41 64.52,97.44 64.49,97.47 64.45,97.56 64.51,97.64 64.64,97.74 64.71,97.89 64.75,97.99 64.77,98 64.85,98.06 64.91,98.13
GND POWER on TOP (solid shape): 64,95.73 64.01,95.71 64.29,95.51 64.62,95.62 64.7,95.65 64.77,95.62 64.8,95.59 64.84,95.5 64.78,95.42 64.64,95.31 64.56,95.07 64.53,95.06 64.34,94.8 64.49,94.52 64.54,94.43 64.49,94.34 64.4,94.26 64.35,94.13 64.34,94.12 64.3,94.07 64.25,94.12 64.25,94.13 63.98,94.38 63.67,94.2 63.66,94.18 63.55,94.15 63.53,94.19 63.48,94.28 63.4,94.34 63.35,94.43 63.4,94.52 63.55,94.8 63.37,95.06 63.35,95.07 63.28,95.26 63.22,95.34 63.2,95.42 63.23,95.49 63.27,95.5 63.3,95.49 63.66,95.42 63.91,95.69 63.93,95.75
GND POWER on TOP (solid shape): 92.89,135.3 92.96,135.27 92.99,135.21 93.19,134.95 93.51,135.02 93.66,135.17 93.75,135.19 93.83,135.13 93.93,134.99 94.1,134.94 94.12,134.94 94.17,134.89 94.17,134.82 94.14,134.75 93.88,134.62 93.81,134.43 93.81,134.4 93.76,134.36 93.74,134.36 93.53,134.32 93.39,134.16 93.32,134.1 93.23,134.13 93.21,134.15 93.2,134.16 92.8,134.35 92.57,133.98 92.56,133.93 92.52,133.92 92.48,133.92 92.43,133.93 92.42,133.98 92.38,134.21 92.19,134.35 92.17,134.35 91.95,134.57 91.95,134.58 91.87,134.66 91.77,134.71 91.74,134.72 91.74,134.78 91.77,134.86 91.85,134.88 91.88,134.88 92.05,134.88 92.17,135 92.24,135.03 92.31,135.01 92.61,134.96 92.78,135.21 92.82,135.27 92.89,135.3
GND POWER on TOP (solid shape): 62.94,89.71 63.02,89.67 63.06,89.64 63.11,89.61 63.13,89.59 63.14,89.55 63.36,89.1 63.84,89.28 63.91,89.33 63.99,89.3 64.04,89.26 64.08,89.18 64.04,89.1 63.94,89 63.84,88.77 63.82,88.76 63.74,88.71 63.68,88.63 63.6,88.58 63.51,88.63 63.45,88.71 63.37,88.76 63.35,88.77 63.31,88.87 62.68,89.05 62.85,88.41 62.96,88.38 62.97,88.36 63.02,88.28 63.09,88.22 63.14,88.13 63.09,88.04 63.06,88.02 63.02,87.99 62.94,87.96 62.87,88 62.85,88.03 62.82,88.06 62.36,88.52 62.24,88.52 62.23,88.56 62.16,88.72 62.03,88.83 61.62,88.83 61.42,89.03 61.42,89.18 61.49,89.26 61.78,89.26 62.13,89.61 62.2,89.64 62.27,89.61 62.58,89.49 62.87,89.66
GND POWER on TOP (solid shape): 63.09,98.02 63.16,97.99 63.22,97.98 63.25,97.97 63.27,97.93 63.53,97.62 63.92,97.72 64,97.75 64.07,97.72 64.1,97.69 64.14,97.6 64.08,97.52 63.95,97.42 63.84,97.17 63.82,97.16 63.74,97.11 63.68,97.03 63.6,96.98 63.51,97.03 63.45,97.11 63.37,97.16 63.35,97.17 63.32,97.28 62.7,97.52 62.83,96.87 62.84,96.87 62.95,96.81 62.95,96.79 63.01,96.69 63.09,96.62 63.14,96.53 63.09,96.44 63.06,96.42 63.02,96.39 62.94,96.36 62.87,96.4 62.85,96.43 62.82,96.46 62.36,96.92 62.15,96.92 62.14,96.96 61.99,97.15 61.74,97.17 61.71,97.16 61.43,97.44 61.03,97.44 60.99,97.48 60.99,97.66 61.05,97.73 61.58,97.73 61.58,97.73 61.66,97.76 61.73,97.73 62.09,97.44 62.47,97.7 62.5,97.73 62.75,97.73 63.06,98.04
GND POWER on TOP (solid shape): 56.67,187.84 56.67,181.8 57.35,180.94 58.34,181.42 71.26,181.42 72.25,180.94 72.93,181.8 72.93,187.84 73.21,188.12 74.85,188.12 74.93,188.08 74.97,188 74.97,186 75.23,185.38 75.85,185.12 79.7,185.12 79.79,185.08 79.82,185 79.82,180.52 79.32,180.02 77.43,180.02 77.08,179.69 77.08,176.6 76.53,176.05 73.23,176.05 72.21,177.07 72.21,179.1 70.89,180.42 70.38,180.42 69.62,181.18 58.95,181.18 57.15,179.38 57.15,177.78 56.13,176.76 53.77,176.76 46.67,169.66 46.67,168.62 45.81,167.76 40.58,167.76 40.47,167.86 40.47,168.35 40.52,168.4 41.2,168.4 41.64,168.84 41.64,173.24 41.63,173.26 41.63,175.24 41.91,175.52 46.27,175.52 47.24,176.31 46.66,177.4 46.66,186.04 46.93,186.32 52.12,186.32 53.1,186.72 53.51,187.7 53.51,187.84 53.78,188.12 56.39,188.12
GND POWER on TOP (solid shape): 42.6,111.18 42.75,111.02 42.96,110.96 43,110.95 43.01,110.92 43.11,110.73 43.3,110.62 43.33,110.62 43.35,110.52 43.3,110.51 43.1,110.4 43,110.19 42.98,110.16 42.95,110.15 42.7,110.06 42.57,109.83 42.53,109.7 42.5,109.69 42.31,109.6 42.22,109.41 42.2,109.35 42.09,109.38 42.09,109.41 41.75,109.7 41.42,109.41 41.4,109.35 41.29,109.38 41.29,109.41 41.19,109.6 40.99,109.7 40.96,109.71 40.95,109.75 40.89,109.96 40.73,110.11 40.68,110.14 40.71,110.2 40.72,110.2 40.81,110.26 40.87,110.33 40.95,110.37 41.03,110.33 41.09,110.26 41.17,110.21 41.24,110.17 41.5,109.91 41.87,109.83 42.1,110.13 42.12,110.16 42.15,110.17 42.52,110.44 42.38,110.88 42.34,110.96 42.38,111.04 42.45,111.11 42.51,111.19 42.51,111.2 42.57,111.23
GND POWER on TOP (solid shape): 57.11,135.3 57.18,135.27 57.21,135.21 57.5,134.94 57.78,135.21 57.82,135.27 57.89,135.3 57.89,135.3 57.96,135.27 57.99,135.21 58.08,135.02 58.27,134.93 58.34,134.9 58.37,134.83 58.47,134.59 58.71,134.5 58.78,134.47 58.9,134.22 59.1,134.14 59.12,134.14 59.17,134.09 59.17,134.02 59.14,133.95 58.88,133.82 58.81,133.63 58.81,133.6 58.76,133.56 58.69,133.56 58.62,133.59 58.59,133.65 58.55,133.77 58.48,133.86 58.24,134.09 58.24,134.1 57.88,134.32 57.6,134.01 57.57,133.94 57.5,133.92 57.48,133.92 57.43,133.93 57.42,133.98 57.39,134.19 57.22,134.33 57.21,134.34 56.91,134.64 56.85,134.69 56.77,134.72 56.74,134.73 56.74,134.78 56.72,134.78 56.72,134.89 56.74,134.89 56.74,134.94 56.77,134.95 56.92,135.05 56.98,135.21 57.02,135.27 57.09,135.3
GND POWER on TOP (solid shape): 76.57,141.73 76.62,141.68 76.69,141.64 77.21,141.13 77.9,141.13 77.9,141.07 78.71,141.07 78.71,141.13 78.87,141.13 78.92,141.08 78.92,140.01 78.71,140.01 78.71,140.11 77.9,140.11 77.9,140 77.16,140 76.69,139.52 75.9,139.52 75.77,139.52 75.6,139.35 75.6,139.25 75.59,139.21 75.56,139.18 75.53,139.16 75.49,139.16 75.42,139.19 75.38,139.25 75.1,139.52 74.81,139.25 74.78,139.19 74.71,139.16 74.69,139.16 74.62,139.19 74.58,139.25 74.3,139.52 74.01,139.25 73.98,139.19 73.91,139.16 73.89,139.16 73.82,139.19 73.78,139.25 73.75,139.37 73.67,139.45 73.64,139.53 73.67,139.61 73.79,139.73 73.84,139.79 73.88,139.85 73.92,139.9 73.98,139.91 74.02,139.9 74.05,139.87 74.16,139.77 74.41,139.76 74.5,139.82 75.09,140.41 75.17,140.33 75.82,140.33 76.02,140.52 76.04,140.52 76.15,140.6 76.21,140.71 76.22,140.72 76.34,140.85 76.36,140.85 76.67,141.16 76.49,141.56 76.44,141.64 76.48,141.73 76.5,141.75 76.55,141.75
GND POWER on TOP (solid shape): 93,85.58 93.08,85.53 93.15,85.45 93.23,85.4 93.26,85.39 93.27,85.32 93.32,85.19 93.41,85.08 93.68,84.97 93.93,85.13 93.97,85.15 94.01,85.15 94.23,85.37 95.08,85.37 95.13,85.32 95.13,84.67 94.92,84.46 94.75,84.53 94.57,84.46 94.22,84.46 94.05,84.53 93.87,84.46 93.8,84.46 93.78,84.43 93.7,84.38 93.35,84.59 93,84.38 92.91,84.43 92.43,84.5 92.49,84.02 92.54,83.93 92.49,83.84 92.42,83.78 92.36,83.7 92.35,83.67 92.29,83.66 92.18,83.62 92.08,83.55 92.05,83.53 92.05,83.5 91.98,83.28 92.05,83.06 92.1,83.01 92.1,82.81 92.02,82.73 91.74,82.73 91.57,82.9 91.57,84.83 91.69,84.95 91.79,84.98 91.88,85.04 91.95,85.07 92.02,85.04 92.3,84.94 92.57,85.08 92.67,85.18 92.72,85.32 92.73,85.39 92.76,85.4 92.84,85.45 92.91,85.53
GND POWER on TOP (solid shape): 62.24,100.4 62.24,100.38 62.47,100.09 62.81,100.23 62.9,100.28 62.98,100.23 63.04,100.16 63.12,100.11 63.14,100.08 63.14,100.05 63.37,99.58 63.85,99.78 63.86,99.81 64.12,99.81 64.46,100.14 64.49,100.12 64.55,100.09 64.62,100.08 64.65,100.07 64.67,100.03 64.71,99.9 64.8,99.79 64.84,99.7 64.78,99.62 64.72,99.59 64.67,99.54 64.6,99.51 64.52,99.54 64.15,99.65 63.88,99.37 63.84,99.27 63.82,99.26 63.74,99.21 63.68,99.13 63.6,99.08 63.51,99.13 63.45,99.21 63.37,99.26 63.35,99.27 63.31,99.37 63.04,99.65 62.67,99.54 62.6,99.51 62.52,99.54 62.13,99.64 61.87,99.33 61.85,99.3 61.82,99.28 61.78,99.28 61.71,99.26 61.43,99.54 61.03,99.54 60.73,99.83 61.01,100.11 61.04,100.1 61.33,100.14 61.45,100.42 61.47,100.49 61.55,100.53 62.11,100.53
GND POWER on TOP (solid shape): outline of 134 points within 86.5,89.66 87.2,107.58
GND POWER on TOP (solid shape): 42.22,118.11 42.31,117.92 42.5,117.82 42.53,117.82 42.57,117.68 42.7,117.45 42.95,117.36 42.98,117.35 43,117.32 43.1,117.11 43.3,117.01 43.35,116.99 43.33,116.9 43.3,116.89 43.11,116.79 43.01,116.6 43,116.56 42.96,116.55 42.75,116.5 42.6,116.34 42.56,116.27 42.3,116.01 42.24,115.92 42.2,115.81 42.19,115.77 41.98,115.77 41.86,115.65 41.68,115.65 41.6,115.73 41.6,115.83 41.65,115.88 41.66,115.9 41.74,116.05 42.26,116.57 42.33,116.61 42.55,116.96 42.33,117.31 42.26,117.35 42,117.61 41.63,117.69 41.4,117.4 41.38,117.37 41.35,117.35 41.17,117.31 41.03,117.19 40.95,117.15 40.87,117.19 40.73,117.31 40.55,117.35 40.52,117.37 40.5,117.4 40.47,117.51 40.4,117.61 40.3,117.71 40.27,117.79 40.32,117.87 40.43,117.97 40.49,118.1 40.49,118.13 40.6,118.16 40.62,118.11 40.95,117.82 41.29,118.1 41.29,118.13 41.4,118.16 41.42,118.11 41.75,117.82 42.09,118.1 42.09,118.13 42.2,118.16
GND POWER on TOP (solid shape): 81.45,114.53 81.48,114.51 81.53,114.47 81.59,114.44 81.59,114.17 81.9,113.86 81.88,113.83 81.85,113.77 81.84,113.7 81.83,113.67 81.8,113.66 81.49,113.41 81.58,113.02 81.6,112.93 81.56,112.86 81.39,112.41 81.8,112.16 81.87,112.16 81.88,112.13 81.93,112.07 81.99,112.02 82.04,111.93 81.99,111.84 81.92,111.78 81.87,111.7 81.86,111.68 81.63,111.59 81.53,111.49 81.45,111.45 81.36,111.49 81.34,111.53 81.3,111.56 81.27,111.63 81.3,111.71 81.4,112.13 81.04,112.36 80.78,112.58 80.48,112.43 80.4,112.38 80.31,112.43 80.25,112.51 80.17,112.56 80.15,112.57 80.11,112.68 80.16,112.7 80.35,112.97 80.17,113.26 80.15,113.27 80.11,113.38 80.16,113.4 80.24,113.45 80.31,113.53 80.4,113.58 80.48,113.53 80.78,113.38 81.03,113.59 81.04,113.61 81.17,113.65 81.47,113.98 81.25,114.36 81.23,114.37 81.21,114.44 81.29,114.46 81.35,114.49 81.41,114.52
GND POWER on TOP (solid shape): 57.66,103.77 57.74,103.72 57.75,103.62 57.96,103.1 58.46,103.37 58.46,103.41 59.52,103.41 59.6,103.37 59.62,103.29 59.62,103.22 59.62,103.16 59.6,103.07 59.53,103.04 59.21,103.04 58.99,102.81 58.9,102.81 58.61,102.68 58.52,102.37 58.5,102.29 58.42,102.25 58.22,102.25 58.16,102.31 58.12,102.48 58.12,102.48 57.88,102.79 57.49,102.71 57.42,102.69 57.36,102.72 56.89,102.76 56.74,102.31 56.73,102.22 56.65,102.18 56.49,102.18 56.36,102.31 56.32,102.48 56.32,102.48 55.88,102.81 55.57,102.36 55.56,102.28 55.49,102.24 55.24,102.24 55.23,102.24 55.17,102.42 54.88,102.7 54.5,102.56 54.43,102.52 54.35,102.55 54.3,102.6 54.3,102.87 54.38,103.04 54.43,103.3 54.3,103.52 54.27,103.63 54.36,103.7 56.1,103.7 56.19,103.64 56.17,103.53 56.29,102.94 56.83,103.23 56.83,103.23 56.87,103.4 57.23,103.77
GND POWER on TOP (solid shape): outline of 152 points within 69.32,89.66 70.1,107.61
GND POWER on TOP (solid shape): 78.3,112.18 78.38,112.13 78.45,112.05 78.53,112 78.56,111.99 78.57,111.92 78.54,111.87 78.53,111.86 78.34,111.58 78.53,111.3 78.56,111.29 78.57,111.23 78.86,110.91 79.26,111.07 79.35,111.12 79.43,111.07 79.47,111.02 79.5,110.95 79.46,110.88 79.32,110.59 79.45,110.3 79.48,110.23 79.45,110.15 79.38,110.09 79.31,110.09 78.89,110.51 78.25,110.51 78.15,110.57 78.17,110.68 78.24,110.95 78.06,111.16 78.03,111.17 78.02,111.24 77.38,111.45 77.59,110.81 77.65,110.79 77.66,110.77 77.72,110.67 77.81,110.61 77.84,110.59 77.84,110.51 77.73,110.51 77.33,110.11 77.16,110.11 76.71,110.56 76.18,110.56 76.1,110.61 76.1,110.72 76.14,110.97 75.97,111.16 75.95,111.17 75.92,111.22 75.94,111.29 75.96,111.3 76.05,111.35 76.11,111.43 76.2,111.48 76.28,111.43 76.6,111.28 76.84,111.52 76.88,111.58 76.94,111.6 77.19,111.69 77.32,111.92 77.35,112.08 77.72,112.08 77.98,111.98 78.21,112.13
GND POWER on TOP (solid shape): outline of 83 points within 40.19,80.65 43.43,83.23
GND POWER on TOP (solid shape): 64.36,107.27 64.62,107.08 64.91,107.23 65,107.28 65.08,107.23 65.1,107.2 65.13,107.17 65.13,107.07 65.15,107.05 65.18,106.98 65.14,106.91 65.04,106.64 65.22,106.4 65.24,106.39 65.28,106.29 65.91,106.12 65.74,106.75 65.71,106.76 65.68,106.8 65.69,106.84 65.91,107.06 65.91,107.11 66.08,107.08 66.23,107.14 66.34,107.15 66.39,107.06 66.39,106.52 66.72,106.19 66.77,106.12 66.84,106.06 66.84,105.92 66.76,105.84 66.69,105.81 66.62,105.84 66.25,105.95 65.98,105.67 65.94,105.57 65.92,105.56 65.83,105.49 65.76,105.39 65.75,105.35 65.63,105.39 65.62,105.41 65.52,105.53 65.37,105.58 65.34,105.6 65.32,105.63 65.06,105.94 64.67,105.84 64.6,105.81 64.52,105.84 64.15,105.95 63.88,105.67 63.84,105.57 63.82,105.56 63.74,105.51 63.68,105.43 63.6,105.38 63.51,105.43 63.45,105.51 63.37,105.56 63.35,105.57 63.3,105.72 63.32,105.82 63.41,105.85 63.69,105.9 63.86,106.13 63.91,106.31 63.98,106.38 64,106.38 64.25,106.63 64.1,106.94 64.05,107.03 64.1,107.12 64.17,107.18 64.22,107.26 64.23,107.28 64.35,107.32
GND POWER on TOP (solid shape): 68.91,133.68 68.91,133.43 68.67,133.19 68.67,133.12 68.63,133.11 68.43,132.93 68.47,132.66 68.49,132.62 67.33,131.45 65.57,131.45 65.07,131.96 65.07,132.85 65.08,132.88 65.11,132.9 65.29,132.96 65.4,133.1 65.4,133.11 65.71,133.42 65.77,133.5 65.8,133.6 65.83,133.67 65.9,133.69 65.91,133.7 65.98,133.67 66.1,133.42 66.3,133.34 66.32,133.34 66.37,133.29 66.37,133.22 66.34,133.15 66.08,133.02 66.01,132.83 66.01,132.8 65.96,132.76 65.94,132.76 65.66,132.2 66.22,132.47 66.22,132.49 66.27,132.54 66.29,132.54 66.49,132.62 66.62,132.87 66.69,132.9 66.94,133.01 67.04,133.31 67.08,133.33 67.11,133.33 67.15,133.31 67.17,133.27 67.27,132.99 67.55,132.9 67.59,132.89 67.61,132.85 67.61,132.8 67.56,132.76 67.54,132.76 67.26,132.2 67.82,132.47 67.82,132.49 67.87,132.54 67.89,132.54 68.18,132.82 67.92,133.12 67.85,133.15 67.83,133.22 67.82,133.29 67.87,133.34 67.89,133.34 68.09,133.42 68.22,133.67 68.29,133.7 68.4,133.72 68.5,133.77 68.56,133.79 68.62,133.78 68.66,133.81 68.78,133.81
GND POWER on TOP (solid shape): 56.86,133.78 56.9,133.76 57,133.71 57.11,133.7 57.18,133.67 57.3,133.42 57.5,133.34 57.52,133.34 57.57,133.29 57.57,133.22 57.54,133.15 57.47,133.12 57.21,132.82 57.5,132.54 57.52,132.54 57.57,132.49 57.57,132.47 58.13,132.2 57.86,132.76 57.83,132.76 57.78,132.8 57.78,132.85 57.8,132.89 57.84,132.9 58.13,132.99 58.22,133.28 58.22,133.34 58.32,133.34 58.36,133.32 58.37,133.28 58.45,133.01 58.71,132.9 58.78,132.87 58.9,132.62 59.1,132.54 59.12,132.54 59.17,132.49 59.17,132.47 59.73,132.2 59.46,132.76 59.43,132.76 59.38,132.8 59.38,132.83 59.31,133.02 59.05,133.15 59.03,133.22 59.02,133.29 59.07,133.34 59.09,133.34 59.29,133.42 59.42,133.67 59.49,133.7 59.54,133.7 59.58,133.69 59.59,133.65 59.59,133.63 59.62,133.51 59.68,133.42 59.99,133.11 59.99,133.1 60.11,132.96 60.28,132.9 60.31,132.88 60.33,132.85 60.33,132.4 59.43,131.51 57.75,131.51 56.83,132.43 56.8,132.51 56.85,132.59 56.98,132.87 56.77,133.11 56.74,133.12 56.74,133.36 56.59,133.51 56.59,133.71 56.67,133.78 56.82,133.78
GND POWER on TOP (solid shape): outline of 82 points within 43.2,99.7 46.32,103.48
GND POWER on TOP (solid shape): outline of 99 points within 84.97,110.22 88.61,115.92
GND POWER on TOP (solid shape): outline of 93 points within 60.83,103.04 66.84,105.22
GND POWER on TOP (solid shape): outline of 177 points within 83.7,89.66 84.4,107.58
GND POWER on TOP (solid shape): outline of 163 points within 70.72,89.66 71.5,107.61
GND POWER on TOP (solid shape): outline of 165 points within 85.1,89.66 85.8,107.58
GND POWER on TOP (solid shape): outline of 167 points within 82.3,89.66 83,107.58
GND POWER on TOP (solid shape): outline of 166 points within 79.5,89.66 80.2,107.58
GND POWER on TOP (solid shape): outline of 171 points within 80.9,89.66 81.6,107.58
GND POWER on TOP (solid shape): outline of 173 points within 72.12,89.66 72.9,107.61
GND POWER on TOP (solid shape): outline of 184 points within 73.52,89.66 74.3,107.61
GND POWER on TOP (solid shape): outline of 188 points within 74.92,89.66 75.7,107.61
GND POWER on TOP (solid shape): outline of 196 points within 76.32,89.66 77.1,107.61
GND POWER on TOP (solid shape): outline of 509 points within 59.85,114.91 72.53,129.86
GND POWER on TOP (solid shape): outline of 509 points within 58.04,76.01 65.49,85.44
GND POWER on TOP (solid shape): outline of 580 points within 157.48,115.44 163.78,129.61
GND POWER on TOP (solid shape): outline of 242 points within 63.11,107.99 68.99,115.93
GND POWER on TOP (solid shape): outline of 937 points within 0.38,0.38 195.82,188.77
GND POWER on TOP (solid shape): outline of 1154 points within 73.78,127.75 87.86,139.18
GND POWER on TOP (solid shape): outline of 1206 points within 36.6,115.65 52.86,138.94
GND POWER on TOP (solid shape): outline of 1296 points within 38.03,81.85 45.28,95.91
GND POWER on TOP (solid shape): outline of 1526 points within 28.43,70.37 37.32,88.72
GND POWER on TOP (solid shape): outline of 3358 points within 15.44,88.81 37.82,122.63
GND POWER on TOP (solid shape): outline of 5079 points within 45.28,115.53 104.6,149.28
GND POWER on TOP (solid shape): outline of 7796 points within 59.77,79.94 92.02,89.78
GND POWER on BOTTOM (solid shape): 8.2,78.31 8.2,74.5 7.06,73.36 4.65,73.36 3.76,74.25 3.76,77.17 5.66,79.07 7.44,79.07
GND POWER on BOTTOM (solid shape): 114.5,173.69 114.5,169.88 114.12,169.5 110.31,169.5 110.18,169.62 110.18,173.43 110.82,174.07 114.12,174.07
GND POWER on BOTTOM (solid shape): 150.49,141.51 150.49,135.49 150.19,135.18 149.83,135.18 149.55,135.46 149.55,141.23 149.96,141.63 150.37,141.63
GND POWER on BOTTOM (solid shape): 193.73,20.85 193.73,15.81 193.25,15.32 188.92,15.32 188.54,15.7 188.54,20.78 188.8,21.03 193.55,21.03
GND POWER on BOTTOM (solid shape): 69.24,126.47 69.24,125.61 69.13,125.5 65.52,125.5 65.37,125.65 65.37,126.82 65.52,126.97 68.74,126.97
GND POWER on BOTTOM (solid shape): 81.99,74.76 81.99,70.38 81.41,69.8 69.54,69.8 69.04,70.31 69.04,74.79 69.16,74.92 81.83,74.92
GND POWER on BOTTOM (solid shape): 150.67,124.18 150.67,122.96 150.54,122.84 149.86,122.84 149.68,123.02 149.68,124.41 149.81,124.54 150.32,124.54
GND POWER on BOTTOM (solid shape): 139.01,124.29 139.01,112.73 138.89,112.6 136.73,112.6 136.6,112.73 136.6,123.65 136.22,124.03 135.97,124.03 135.84,124.16 135.84,124.41 135.97,124.54 138.76,124.54
GND POWER on BOTTOM (solid shape): 18.46,129.21 18.46,125.15 17.22,123.9 17.22,121.62 16.84,121.24 14.05,121.24 13.92,121.36 13.92,125.3 13.91,125.31 13.91,129.1 14.17,129.37 18.31,129.37
GND POWER on BOTTOM (solid shape): 100.7,96.68 100.7,92.07 100.33,91.7 98.14,91.7 97.47,92.37 97.47,95.85 97.1,96.22 97.09,96.23 96.71,96.61 96.71,97.07 96.82,97.18 100.2,97.18
GND POWER on BOTTOM (solid shape): 118.06,142.57 124.64,142.57 127.43,139.78 127.43,135.56 127.15,135.28 124.43,135.28 123.52,134.37 119.48,134.37 117.45,136.4 117.45,136.96 116.66,137.75 116.03,137.75 115.9,137.87 115.9,143.08 116.15,143.34 117.3,143.34
GND POWER on BOTTOM (solid shape): 189.13,56.8 189.13,53.25 188.85,52.96 188.47,52.96 188.04,52.53 188.04,48.85 188.24,48.64 191.54,48.64 191.74,48.85 191.74,52.4 191.92,52.58 193.5,52.58 193.62,52.45 193.62,48.62 192.45,47.45 187.7,47.45 186.64,48.51 186.64,53.15 188.47,54.97 188.47,56.8 188.51,56.85 189.09,56.85
GND POWER on BOTTOM (solid shape): 153.46,124.67 154.25,124.67 154.73,125.15 155.6,125.15 155.74,125.01 155.74,124.41 155.26,123.93 155.26,113.34 154.99,113.07 154.42,113.07 153.92,112.58 153.08,112.58 152.98,112.68 152.98,115.14 152.86,115.27 152.86,115.95 152.09,116.72 152.09,125.02 152.22,125.15 152.98,125.15
GND POWER on BOTTOM (solid shape): 103.9,186.34 103.9,178.6 103.89,178.6 103.58,178.36 103.41,178 103.41,177.6 103.58,177.24 103.89,177 104.24,176.92 105.94,176.92 106.09,176.76 106.09,176.13 106.2,176.03 106.2,167.67 105.8,167.27 105.42,167.27 103.58,165.43 98.88,165.43 95.89,168.43 95.89,179.44 94.79,180.55 94.79,186.34 95.06,186.62 103.62,186.62
GND POWER on BOTTOM (solid shape): 131.9,124.79 132.07,124.79 132.09,124.77 132.85,124.77 132.88,124.79 132.92,124.79 133.15,125.02 134.34,125.02 134.44,124.92 134.44,124.41 133.84,123.82 133.84,113.1 133.68,112.93 132.87,112.93 132.69,113.11 132.69,113.85 132.41,114.13 129.87,114.13 129.74,114.25 129.74,114.89 130,115.14 130.38,115.14 131.27,116.03 131.27,123.14 131.01,123.4 131.01,125.17 131.14,125.3 131.39,125.3
GND POWER on BOTTOM (solid shape): 144.73,124.74 144.73,124.16 144.47,123.9 144.47,111.48 144.32,111.33 143.71,111.33 143.56,111.48 143.56,112.45 143.41,112.6 142.36,112.6 142.27,112.65 142.16,112.67 142.09,112.7 142.06,112.77 142.06,123.78 142.32,124.03 142.32,124.29 142.44,124.41 144.09,124.41 144.19,124.51 144.19,124.72 144.27,124.79 144.68,124.79
GND POWER on BOTTOM (solid shape): 124,185.49 124,178.6 123.99,178.6 123.68,178.36 123.51,178 123.51,177.6 123.68,177.24 123.99,177 124.34,176.92 125.5,176.92 125.81,176.61 125.81,175.14 123.82,173.15 117.75,173.15 116.36,174.55 116.36,176.79 116.48,176.92 117.82,176.92 118.17,177 118.48,177.24 118.65,177.6 118.65,178 118.48,178.36 118.17,178.6 118.16,178.6 118.16,185.49 118.44,185.77 123.72,185.77
GND POWER on BOTTOM (solid shape): 141.55,175.85 141.55,171.76 141.04,171.4 141.55,171.04 141.55,171.02 140.92,170.39 137.49,170.39 137.11,170.77 137.11,172.67 138.89,174.45 138.89,175.34 139.52,175.97 141.43,175.97
GND POWER on BOTTOM (solid shape): 81.45,90.03 81.65,89.83 82.1,89.83 82.3,90.03 82.3,90.43 82.78,90.43 82.86,90.39 82.88,90.31 83.26,89.85 83.61,90.33 83.61,90.37 83.62,90.41 83.66,90.43 84.09,90.43 84.15,90.38 84.15,89.51 84.14,89.5 84.14,89.35 84.02,89.23 81.05,89.23 80.9,89.38 80.9,90.33 81,90.43 81.45,90.43
GND POWER on BOTTOM (solid shape): 147.78,131.91 147.78,131.02 147.65,130.89 147.4,130.89 147.14,130.64 147.14,125.81 148.11,124.84 148.11,123.98 148.03,123.9 148.03,111.74 147.89,111.74 147.88,111.75 147.8,111.79 147.72,111.81 147.39,111.69 147.33,111.35 147.33,111.34 147.32,111.25 147.23,111.2 146.86,111.2 146.8,111.22 146.73,111.23 146.51,111.46 146.51,112.22 146.89,112.6 146.89,124.16 146.38,124.67 146.38,126.06 145.74,126.7 145.74,127.21 145.87,127.33 146.13,127.33 146.38,127.59 146.38,128.6 146.25,128.73 145.87,128.73 145.74,128.86 145.74,129.24 145.87,129.37 146.25,129.37 146.51,129.62 146.51,130.76 146.76,131.02 146.76,131.78 147.01,132.03 147.65,132.03
GND POWER on BOTTOM (solid shape): outline of 103 points within 0.46,77.93 11.45,89.36
GND POWER on BOTTOM (solid shape): outline of 114 points within 80.9,81.35 90.42,88
GND POWER on BOTTOM (solid shape): outline of 82 points within 85,87.71 88.34,105.97
GND POWER on BOTTOM (solid shape): 56.67,187.84 56.67,181.8 57.35,180.94 58.34,181.42 71.26,181.42 72.25,180.94 72.93,181.8 72.93,187.84 73.21,188.12 74.85,188.12 74.93,188.08 74.97,188 74.97,186 75.23,185.38 75.85,185.12 79.7,185.12 79.79,185.08 79.82,185 79.82,180.52 79.32,180.02 77.43,180.02 77.08,179.69 77.08,176.6 76.53,176.05 73.23,176.05 72.21,177.07 72.21,179.1 70.89,180.42 70.38,180.42 69.59,181.21 59.92,181.21 59.54,180.83 59.54,177.3 57.66,175.42 55.5,175.42 53.14,173.05 41.83,173.05 41.12,173.76 41.12,175.42 41.22,175.52 46.27,175.52 47.24,176.31 46.66,177.4 46.66,186.04 46.93,186.32 52.12,186.32 53.1,186.72 53.51,187.7 53.51,187.84 53.78,188.12 56.39,188.12
