# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Nets (continued)
N192948383: C3579.1 U97.24
N192948531: R3319.2 U97.4
N192948533: R3322.2 U97.3
N192948565: Q8.4 R3321.1
N192948575: R3327.1 U97.18
N192948802: C3557.2 R3299.1 U97.8
N192948836: C3543.1 R3312.1
N192950176: R3336.1 U97.17
N192950201: R3330.1 U97.25
N192950211: C3541.1 R3330.2
N193847777: D28.3 R3331.1
N193982561: R3335.1 U97.16
N194433908: D41.2 R495.2

Pads without a net: CN1 87 88 91 92 95 97 100 101 104 105 162 165; CN11 87 88 91 92 95 97 100 101 104 105 162 165; CN12 14 18 20 21 22 23; CN26 13 14; CN41 3 4; CN42 2 5; CNDEG2 1 6; CNEDP1 31 32; CNHDD1 16; CNKB1 25 26 27 28 37; CNSSD1 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; CNSSD2 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; CNWLAN1 8 12 20 58 60 62 66 68 70; CON3 A8 B8 S1 S2; G1 A17 A42 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA9 AA44 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AD1 AD2 AD4 AD5 AD6 AD7 AD8 AD9 AD45 AD46 AF2 AF3 AF4 AF6 AF7 AF8 AF9 AF49 AG1 AG2 AG4 AG5 AG6 AG7 AG8 AG9 AG52 AJ1 AJ3 AJ4 AJ5 AJ6 AJ7 AJ8 AK2 AK3 AK4 AK5 AK6 AK7 AK8 AK9 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 BA1 BA2 BA3 BA5 BA6 BA7 BA8 BA9 BB2 BB3 BB6 BB7 BB8 BD4 BD14 BE2 BE5 BE7 BE11 BE12 BE17 BE20 BE23 BF11 BF17 BF18 BF20 BF21 BF23 BF24 BG6 BG11 BG12 BG18 BG20 BG21 BG23 BG24 BH6 BH11 BH12 BH20 BH23 BJ1 BJ2 BJ3 BJ9 BJ11 BK9 BK11 BK12 BK14 BK15 BK17 BK18 BK20 BK21 BK44 BL9 BL11 BL12 BL14 BL15 BL17 BL18 BL20 BL21 BM8 BM9 BM11 BM12 BM14 BM15 BM17 BM18 BM20 BM21 C2 C3 D1 D2 D3 D17 D41 E1 E3 E29 F1 F2 F3 F4 F5 F9 F29 F41 G9 G14 G35 G41 H2 H3 H4 H5 H6 H7 H14 H24 H35 J2 J4 J5 J6 J7 J14 J23 J24 J35 J41 J46 J47 L1 L2 L3 L4 L5 L6 L7 L8 M1 M2 M3 M4 M5 M7 M8 M9 M44 M45 P1 P2 P3 P4 P5 P6 P7 P8 P9 R1 R2 R3 R4 R5 R6 R7 R8 R9 U1 U2 U3 U4 U5 U6 U8 V1 V2 V3 V4 V5 V6 V7 V8 V9 V44 V45 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y8; M1 1; M2 1; M3 1; M4 1; M5 1; M6 1; M7 1; M8 1; M41 A5 A10 V5 V10; M42 A5 A10 V5 V10; M43 A5 A10 V5 V10; M44 A5 A10 V5 V10; M45 A5 A10 V5 V10; M46 A5 A10 V5 V10; NOREF#4 1; U5 2; U7 18 20 23 24 29 48; U12 7; U17 7; U18 7; U19 1 7; U26 A27 A33 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AJ8 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AP14 AP29 AT3 AT5 AT7 AT11 AU13 AW7 AW8 AW9 AW10 AW11 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B2 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ28 BK28 BL31 BL34 BM31 BN22 BN23 BN27 BN28 BN33 BN35 BP1 BP22 BP23 BR1 BR2 BR27 BR31 BR35 BT2 BT27 BT30 C1 C30 C33 C34 C38 D1 D27 D34 E1 E2 E26 E27 E30 E33 E36 E37 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; U28 A17 A22 A25 AA1 AA45 AB48 AC2 AC3 AC6 AC7 AC9 AC11 AC39 AC41 AC43 AC44 AC48 AD47 AD48 AE9 AE11 AE39 AE43 AE44 AE47 AE48 AF47 AF48 AG45 AH14 AH15 AH40 AH46 AH47 AH48 AJ6 AJ7 AJ46 AJ47 AL9 AL10 AL13 AL15 AL35 AL48 AM7 AN4 AN10 AN13 AN18 AN35 AN37 AN40 AN46 AP2 AP3 AP9 AP21 AP24 AP29 AP47 AP48 AR2 AR3 AR8 AR13 AR18 AR42 AR48 AT5 AT6 AT10 AT49 AU4 AU24 AU26 AU47 AV6 AV7 AV13 AV16 AV18 AV21 AV34 AW2 AW3 AW13 AW15 AW18 AW21 AW26 AW32 B9 B14 B17 B18 B19 B21 B23 B24 B25 B26 B27 B41 BA20 BA24 BA26 BA30 BA33 BB16 BB20 BC1 BC17 BC33 BD8 BD12 BD16 BD17 BD21 BD29 BD30 BD34 BD38 BE8 BE9 BE12 BE14 BE15 BE17 BE18 BE19 BE29 BE33 BE34 BF8 BF9 BF10 BF14 BF15 BF17 BF18 BF19 BF29 BF31 BF32 BF33 BF35 BG8 C3 C9 C14 C18 C19 C20 C21 C23 C24 C26 C27 C41 D4 D20 D21 D29 E28 F16 F20 F24 F26 F46 G17 G20 G24 G26 G45 G46 G47 G48 G49 H2 H3 H47 H48 J15 J18 J21 J24 K16 K18 K21 K29 L24 L26 L41 L46 L47 L48 M26 M29 M40 M45 N18 N32 N47 N48 P9 P21 P24 P47 P48 R10 R13 R15 R18 R21 R24 R32 R44 R46 R47 T1 T2 T43 T45 T46 T47 U2 U3 U13 U35 U37 U40 U41 U47 U48 V2 V3 V47 W3 W4 W6 W7 W43 W44 W46 W47 Y2 Y3 Y4 Y14 Y15 Y35 Y36 Y40 Y41 Y46 Y47 Y48; U30 7; U97 14; U721 14 15 16; U1901 25; Y10 2 4

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 5381 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 409 vias
v3: diameter 0.711, hole 0.356, TOP to BOTTOM, 136 vias
v4: diameter 0.61, hole 0.305, TOP to BOTTOM, 31 vias
v5: diameter 0.813, hole 0.508, TOP to BOTTOM, 986 vias
v6: diameter 0.432, hole 0.254, TOP to BOTTOM, 1247 vias
v7: diameter 0.406, hole 0.254, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2VS_DDR_PG: length 119.2
  TOP w0.102: U25.12 185.54,106.59 v1(185.75,106.38)
  L3_IN1 w0.089: v1(183.29,102.59) 183.29,102.26 184.94,100.61 184.94,92.97 185.19,92.71 185.19,75.06 185.93,74.32 185.93,66.2 180.03,60.3 180.03,52.53 179.55,52.05 v1(179.55,51.9)
  L6_IN2 w0.089: v1(179.55,51.9) 179.55,48.86 181.67,46.75 181.67,44.17 179.8,42.31 179.8,33.25 175.53,28.98 168.87,28.98 167.42,30.43 156.92,30.43 155.78,31.58 155.14,31.58 154.51,32.21 154.51,32.72 155.5,33.72 v1(156.56,33.72)
  BOTTOM w0.102: v1(183.29,102.59) 183.29,104.24 184.48,105.44 184.48,106.63 184.99,107.14 ; 184.99,107.14 R151.1 ; 184.99,107.14 v1(185.75,106.38) ; v1(156.56,33.72) 157.3,32.97 157.3,31.83 158.02,31.12 U5.120
1.8V_MAIN_DISCHARGE: length 4.5
  TOP w0.254: R905.2 C1375.1 80.16,56.01 79.96,56.21 Q130.5 79.96,57.39 80.17,57.6 80.43,57.6 80.61,57.42 Q130.6
1V8_AON: length 432.1
  TOP w0.102: 92.86,72.63 R2924.1
  TOP w0.25: G1.BB14 88.9,89.63 v6(88.8,89.63) ; G1.BC14 v6(89.55,89.58)
  TOP w0.254: C432.1 R489.1 ; R489.1 55.65,158.75 54.94,159.46 Q114.5 54.94,160.23 v1(54.49,160.67) ; R489.1 v1(55.65,157.94) ; R756.2 107.01,84.92 107.34,85.25 v1(107.34,85.3) ; Q114.2 54.94,161.5 v1(55.45,160.99) 55.69,160.99 56.15,161.44 56.15,161.79 57.17,162.81 R493.1 R430.2 ; R850.1 v1(4.47,112.47)
  TOP w0.3: G1.BA10 89.09,86.44 v6(89.36,86.44)
  TOP w0.305: R439.1 92.66,75.54 v1(92.53,75.67) R845.1 ; R2808.1 91.67,75.64 v1(91.64,75.67) R2815.1
  TOP w0.381: R2810.1 R817.1 v1(95.45,73.49) ; v1(94.36,71.78) R2921.1 94.36,70.77 94.96,70.17 94.96,69.44 94.69,69.17 Q122.5 ; R438.1 93.55,73.98 94.82,72.71 v1(94.82,72.34) ; R441.1 88.47,76.13 v1(88.96,75.63) ; R440.1 v1(96.34,75.64) R2814.1 ; v1(91.26,69.17) Q122.2 92.91,69.17 93.29,69.55 93.29,70.51 R2848.1 ; R822.1 R861.1 97.23,75.52 v1(97.36,75.64) 97.23,75.77 R437.1 ; R2812.1 88.39,74.3 v1(88.98,74.88) 89.18,75.09 R2813.1 R2809.1 R2811.1 ; R2877.2 104.47,82.12 103.96,81.61 v1(101.93,81.61)
  TOP w0.508: v1(101.68,75.52) 101.42,75.26 R398.2 ; R819.1 101.42,80.47 v1(101.68,80.22) ; R823.1 v1(99.39,74.25) ; R2875.2 v1(99.39,73.36) ; R825.1 98.63,71.45 v1(99.01,71.83) ; R2849.1 R2848.1 ; R2849.1 92.86,72.63 ; R2849.1 93.55,71.83 v1(93.67,71.96) ; C1452.2 R2881.2 ; C1452.2 106.74,72.91 Q99.5 102.88,71.64 v1(102.31,72.22) ; C1452.2 106.73,73.05 U83.8 ; R790.1 v1(101.68,76.91) ; R436.1 v1(86.31,75.64) ; v1(102.18,79.07) 101.8,78.69 R815.1
  L3_IN1 w0.254: v1(91.64,75.67) 90.63,76.69 90.63,82.63 89.1,84.15 89.1,86.19 v6(89.36,86.44) 89.36,86.82 90.55,88.01 94.29,88.01 97.33,91.06 97.33,106.07 105.46,114.2 105.46,128.83 106.49,129.86 106.49,142.09 102.3,146.28 102.3,147.45 97.98,151.77 95.74,151.77 95.51,152 87.79,152 86.04,153.75 59.84,153.75 v1(55.65,157.94) 53.24,155.53 33.98,155.53 32.7,154.24 32.7,124.5 28.27,120.07 28.27,105.36 23.8,100.89 v1(18.62,100.89) 16.74,100.89 14.81,98.96 14.81,84.08 10.79,80.06 10.79,74.88 11.91,73.76 12.72,73.76 13.46,74.5 v1(14.93,74.5)
  L6_IN2 w0.508: v1(86.31,75.64) 86.31,75.29 86.71,74.88 v1(88.98,74.88)
  L8_IN3 w0.254: v1(14.93,74.5) 15.01,74.43 19.99,74.43 20.32,74.76 21.36,74.76 24.33,71.78 25.53,71.78 25.92,71.39 v1(25.92,71.22) ; v1(54.49,160.67) 55.13,160.67 v1(55.45,160.99)
  L8_IN3 w0.508: v1(143.5,53.29) 143.5,53.84 144.65,54.99 v1(150.32,54.99) 150.32,58.12 v1(149.83,58.6)
  BOTTOM w0.203: R956.1 25.68,70.67 25.92,70.91 v1(25.92,71.22) 25.89,71.22 25.53,71.59 R964.1
  BOTTOM w0.254: v1(4.47,112.47) 4.6,112.6 7.31,112.6 9.98,109.93 13.16,109.93 17.96,105.13 17.96,102.34 18.62,101.68 v1(18.62,100.89) ; v1(14.93,74.5) 15.7,73.74 R961.1
  BOTTOM w0.35: v6(88.8,89.63) 88.9,89.73 89.4,89.73 v6(89.55,89.58)
  BOTTOM w0.381: v1(107.34,85.3) 103.66,81.61 v1(101.93,81.61)
  BOTTOM w0.508: v1(102.31,72.22) 102.56,72.22 109.12,65.66 109.12,64.14 111.53,61.73 130.96,61.73 134.09,58.6 v1(149.83,58.6) ; R486.2 v1(150.32,54.99) ; v1(143.5,53.29) 143.5,52.36 144.3,51.57 R492.2 R483.2
  vias: v5(73.1,64.72) v5(73.1,63.71) v5(73.1,62.69)
1V8_MAIN: length 92
  TOP w0.3: v6(88.8,101.33) 88.9,101.33 G1.BB30
  TOP w0.508: Q78.G 108.15,66.31 v1(108.15,65.48) C872.2 ; B27.1 B34.1 82.17,76.61 v1(83.01,75.77)
  L8_IN3 w0.508: v1(151.64,55.32) 151.64,57.51 v1(151.31,57.84)
  BOTTOM w0.508: R501.2 v1(151.64,55.32) ; v1(151.31,57.84) 133.58,57.84 130.5,60.91 111.01,60.91 108.15,63.77 v1(108.15,65.48) 102.44,71.2 98.63,71.2 96.21,68.79 92.28,68.79 91.13,67.64 85.67,67.64 83.64,69.68 81.99,69.68 81.1,68.79 v5(80.09,68.79)
  vias: v5(79.07,68.79) v5(79.07,67.77) v5(80.09,67.77) v6(81.85,87.38) v6(81.9,88.13) v6(83.1,88.13) v6(83.15,87.38) v6(83.95,87.38) v6(84,88.13) v6(85.2,88.13) v6(85.25,87.38) v6(86.05,87.38) v6(86.1,88.14) v6(87.4,88.13) v6(87.4,87.44) v6(88.8,102.23) v6(88.8,100.13) v6(88.8,99.23) v6(88.8,98.03) v6(89.55,102.18) v6(89.55,101.38) v6(89.55,100.08) v6(89.55,99.28) v6(89.55,97.98) v6(90.25,101.38) v6(90.25,99.28)
3V3_1.2VS: length 2.9
  TOP w0.254: R179.1 C120.1 188.57,111.75 187.54,110.71 U25.3
+0.6V_DDR: length 147.8
  TOP w0.254: v1(187.65,114.25) 187.42,114.01 R35.1 C181.1 187.25,111.84 186.54,111.13 U25.5
  TOP w0.305: CN11.258 114.9,69.58 114.97,69.65 v1(115.4,69.65) ; v1(114.35,82.59) 114.9,82.04 CN1.258
  L3_IN1 w0.508: v1(169.76,49.38) 169.76,47.83 170.27,47.32 178,47.32 182.07,51.39 182.07,60.02 189.31,67.26 189.31,78.41 190.25,79.35 190.25,91.31 186.48,95.08 186.48,101.75 187.4,102.67 187.4,107.75 187.69,108.04 187.69,111.35 187.4,111.64 187.4,114 v1(187.65,114.25)
  BOTTOM w0.508: v1(115.4,69.65) 115.78,69.27 115.78,68.4 ; 122.63,65.61 130.38,65.61 132.66,63.33 151.84,63.33 165.68,49.48 169.65,49.48 v1(169.76,49.38)
  vias: v3(119.3,70.23)
+1.00V_CPU: length 273.2
  TOP w0.203: U26.G30 125.57,125.78 125.27,126.08 v1(125.27,126.1)
  TOP w0.254: v1(128.09,123.78) 128.09,123.9 127.66,124.34 127.29,124.34 127.09,124.54 126.59,124.54 126.22,124.91 U26.H29
  TOP w0.508: v1(100.66,25.86) 100.94,26.14 101.32,26.14 101.68,26.5 R291.2 R298.2 R292.2 ; v1(168.35,123.65) 168.43,123.73 R25.2 R198.2 168.5,125.38 178.21,125.38 185.93,133.1 186.92,133.1 187.38,133.56 190.24,133.56 C174.1 191.21,134.52 R28.2
  L6_IN2 w0.381: v1(128.09,123.78) 128.89,123.78 129.95,124.84 155.02,124.84 155.4,124.46 155.4,124.29 156.29,123.4 166.39,123.4
  L6_IN2 w0.508: v1(101.75,45.13) 101.75,39.52 96.98,34.75 96.98,27.77 97.74,27 99.95,27 100.66,26.29 v1(100.66,25.86) ; 166.39,123.4 168.1,123.4 v1(168.35,123.65)
  L8_IN3 w0.381: v1(125.27,126.1) 125.3,126.06 125.93,126.06 127.08,124.92 127.39,124.92 128.09,124.22 v1(128.09,123.78)
  L8_IN3 w0.508: v1(168.35,123.65) 168.35,120.48 171.14,117.68 171.14,109.05 172.41,107.78 172.41,104.85 178.27,99 180.55,99 184.18,95.37 184.18,67.67 180.03,63.53 180.03,56.34 177.84,54.14 146.49,54.14 144.65,52.3 131.67,52.3 130.25,50.88 v1(128.98,50.88)
  BOTTOM w0.508: v1(128.98,50.88) 125.53,54.33 105.31,54.33 104.1,53.13 102.3,53.13 100.46,51.29 100.46,49.09 101.75,47.8 v1(101.75,45.13)
  vias: v1(116.41,127.21) v1(116.41,126.57)
+1.0VA_PCH: length 84.3
  TOP w0.203: U28.AB28 v2(118.71,26.76) ; U28.AB28 v2(118.71,27.53) U28.AB27 ; U28.AB28 v2(119.49,27.53) U28.AB30 v2(119.49,26.76) ; U28.AB28 v2(119.49,26.76) ; v2(118.71,26.76) U28.AD28 ; v2(118.71,26.76) U28.AB27 ; v2(118.71,26.76) U28.AD27 ; U28.W22 v2(116.39,29.08) U28.W23 ; v2(116.39,26.76) U28.AB22 v2(116.39,27.53) ; v2(116.39,26.76) U28.AB23 ; v2(116.39,26.76) U28.AD23 v2(116.39,25.98) U28.AF23 v2(116.39,25.21) ; U28.AD28 v2(119.49,26.76) ; U28.AD28 v2(119.49,25.98) ; U28.AB23 v2(116.39,27.53) ; U28.AB23 v2(117.16,27.53) U28.AA23 v2(116.39,27.53) ; v2(113.44,26.38) 113.49,26.38 113.51,26.37 U28.AE17 ; v2(116.39,27.53) U28.AA22 ; v2(119.49,25.98) U28.AD30 v2(119.49,26.76) ; v2(119.49,25.98) U28.AF30 v2(119.49,25.21) ; U28.AG31 v2(120.26,25.21) ; U28.AF31 v2(120.26,25.98) ; U28.AD31 v2(120.26,26.76) ; U28.AB27 v2(117.94,26.76) U28.AD27 ; U28.AD27 v2(117.94,25.98) U28.AF27 v2(117.94,25.21) ; U28.W20 v2(114.84,28.3) U28.W19
  TOP w0.254: v2(114.84,29.08) U28.V19 ; v2(115.61,26.76) U28.AD20 ; v2(120.26,28.3) U28.W31
  TOP w0.305: U28.AB20 v2(114.84,26.76)
  TOP w0.508: R370.1 134.96,36.09 R372.1 v1(135.97,36.78) ; R3367.2 84.66,50.04 84.93,50.31 v1(84.93,50.4)
  L6_IN2 w0.508: v1(98.5,23.32) 98.75,23.07 101.8,23.07 102.4,23.66 v1(102.4,31.36) ; v1(135.97,36.78) 135.58,36.78 130,31.19 128.09,31.19 126.44,29.54 126.44,28.91 123.51,25.98 v2(120.26,25.98)
  L8_IN3 w0.508: v1(92.53,44.28) 95.53,44.28 96.6,43.21 96.6,39.45 v5(96.47,39.32)
  BOTTOM w0.508: v1(102.4,31.36) R375.1 ; v2(117.94,26.76) 117.24,26.76 C331.2 ; R378.1 105.1,37.8 104.6,38.31 v2(104.47,38.31) ; C329.2 120.42,28.15 v2(120.26,28.3) ; v1(84.93,50.4) 91.05,44.28 v1(92.53,44.28) ; v2(116.39,25.21) 116.39,24.86 116.77,24.48 C340.1 ; C222.1 120.98,26.37 120.59,26.76 v2(120.26,26.76)
  vias: v1(114.5,124.15) v1(114.78,127.97) v1(114.78,127.41) v1(115.06,124.16) v1(118.72,122.23) v1(119.28,123.62) v2(117.94,29.08) v2(118.71,29.08) v2(119.49,29.08) v2(120.26,29.08) v5(94.44,39.32) v5(94.44,38.31) v5(95.45,39.32) v5(95.48,38.3) v5(96.47,38.31)
+1.00VS_CPU: length 88.6
  TOP w0.305: v1(125.88,124.51) 126.26,124.13 U26.H28 U26.J28 127.21,123.85 v1(127.46,123.85)
  TOP w0.381: R33.2 185.95,135.92 186.33,135.54 186.33,134.34 v1(186.31,134.32) ; v1(125.88,125.33) 126.22,125.66 U26.H30
  TOP w0.508: v1(186.31,134.32) 185.37,134.32 183.84,132.79 183.26,132.79 176.66,126.19 172.21,126.19 170.81,127.59 v1(169.24,127.59) 169.06,127.59 R26.2 ; v1(192.86,138.25) 193.5,138.89 193.5,142.19 193.06,142.62 C654.2 R785.1 R750.1 R691.1
  L6_IN2 w0.305: v1(127.46,123.85) 127.46,123.88 128.12,124.54 128.93,124.54 129.69,125.3 155.2,125.3 155.42,125.09 156.76,125.09 156.89,125.22 166.11,125.22 168.48,127.59 v1(169.24,127.59)
  BOTTOM w0.381: C3643.1 R98.1
  BOTTOM w0.508: v1(192.86,138.25) 190.09,135.49 187.58,135.49 186.41,134.32 v1(186.31,134.32)
  vias: v1(116.48,124.36) v1(116.61,123.82)
+1.0VS_LAN: length 20.3
  TOP w0.203: U1901.22 95.04,48.7 95.53,48.21 95.96,48.21 96.16,48.01 C267.1 96.26,47.65 96.7,47.22 96.7,46.46 97.36,45.8 98.12,45.8 98.58,46.26 R213.2 ; C359.1 97.98,52.24 U1901.30 ; U1901.8 93.04,53.93 92.79,54.18 91.59,54.18 90.92,53.51 90.54,53.51 ; U1901.3 95.04,54.37 95.48,54.82 95.48,55.48 C264.1
  TOP w0.381: C359.1 98.14,52.47 97.76,52.85 v1(97.6,52.85) ; C264.1 95.02,55.32 v1(95.02,55.1) ; v1(91.9,54.82) 91.39,54.82 90.54,53.97 90.54,53.51 C263.1 ; L54.2 100.24,45.97 99.62,46.59 v1(99.39,46.59) 99.36,46.59 99.28,46.67 R213.2
  vias: v1(98.91,45.88) v1(99.14,45.35) v1(99.49,45.93)
+1.2VS: length 192.3
  TOP w0.203: v1(147.8,106.99) 147.48,107.32 U26.AR6 ; U26.AF5 140.12,106.96 v1(140.27,106.95) 139.9,107.32 U26.AF6 ; U26.Y12 135.13,111.23 v1(134.84,110.94)
  TOP w0.254: v1(132.72,106.99) 132.4,107.32 U26.T6 ; v1(118.82,90.66) 119.15,90.34 CN1.241 ; U25.6 186.04,110.92 v1(186,110.95) ; v1(140.27,106.95) 140.41,106.97 U26.AG5 ; CN11.178 134.9,69.73 v1(134.44,70.18) ; v1(139.39,110.92) 139.08,111.23 U26.AE12 ; v1(140.33,109.67) U26.AG9 ; v1(187.4,101.65) 187.02,102.03 R163.1 C154.1 ; L13.2 178.99,108.88 179.27,108.59 v1(179.27,108.54) ; U26.AL11 v1(143.07,110.94) U26.AJ12 ; v1(126.73,111) 126.92,111 U26.K12 127.29,111.37 127.84,111.37 U26.L12
  TOP w0.305: CN11.159 139.65,77.7 v1(139.81,77.86) ; v1(139.79,79.56) 139.66,79.56 139.39,79.83 CN1.160 ; v1(149.46,79.56) 149.32,79.56 148.9,79.99 CN1.130 ; 146.01,91.48 146.14,91.34 CN1.141 ; v1(141.29,77.86) 141.15,77.72 CN11.153 ; U26.AR12 147.45,111.49 147.84,111.49 U26.AT12 148.39,110.94 v1(148.56,110.94) ; v1(157.01,79.66) 157.01,79.63 157.39,80.02 CN1.96 ; CN11.135 147.65,77.49 147.12,78.01 146.46,78.01 146.14,77.7 ; CN1.12 178.4,79.95 v1(178.64,79.7) ; 146.14,77.7 v1(146.14,77.96) ; 146.14,77.7 CN11.141 ; v1(141.29,78.54) 141.72,78.54 142.65,77.61 CN11.147 ; v1(150.4,66.93) CN11.124 ; U26.AW6 149.93,107.32 v1(150.39,107.78) 150.72,107.45 U26.AY6 ; v1(143.19,79.61) 142.79,79.61 142.39,80.01 CN1.148 ; CN1.154 140.9,79.73 141.06,79.56 v1(141.27,79.56) ; CN1.124 150.39,79.73 150.52,79.6 v1(150.54,79.6) ; 153.65,90.8 153.64,90.81 ; 153.65,90.8 CN1.111 ; 153.65,90.8 153.65,90.83 C3465.2 ; C3464.2 173.3,90.44 173.14,90.28 CN1.33 ; v1(173.4,77.72) 173.15,77.46 CN11.33 ; v1(167.7,79.79) 167.9,79.99 CN1.54 ; CN11.75 162.65,77.39 v1(162.18,77.86) ; U26.AR6 U26.AP6 146.27,107.57 U26.AP7 ; v1(125.97,92.01) 127.1,92.01 127.63,91.47 C3466.2 128.99,90.99 129.64,90.33 CN1.199 ; 138.52,91.48 138.64,91.35 CN1.163 ; v1(148.02,79.58) 147.92,79.58 147.39,80.11 CN1.136 ; CN1.129 149.14,91.22 C3470.1 ; CN1.117 152.14,90.92 C3431.1 ; v1(149.5,78.25) 149.14,77.9 CN11.129 ; 126.08,106.98 v1(126.01,106.98) ; 126.08,106.98 126.09,106.98 U26.J5 126.81,107.06 127,107.06 U26.K6 ; 126.08,106.98 U26.J6 U26.K6 ; v1(151.97,79.69) 151.89,79.77 CN1.118 ; CN11.123 150.64,77.77 v1(150.54,77.88) ; CN11.96 157.4,67.15 157.39,67.15 v1(157.39,66.93) ; CN1.75 162.65,90.33 ; v1(178.24,66.88) 178.4,67.04 CN11.12 ; v1(140.84,91.34) 140.71,91.48 139.79,91.48 139.79,91.11 139.64,90.97 CN1.159 ; CN1.123 150.65,91.11 C373.1 ; CN11.130 v1(148.9,66.91) ; CN11.160 139.4,67.14 139.62,66.91 v1(139.66,66.91) ; CN11.117 152.14,77.74 151.98,77.9 v1(151.98,77.9) ; CN11.199 129.65,77.34 130.03,77.73 v1(130.11,77.73) ; CN11.148 v1(142.4,66.93) ; CN11.111 153.65,77.76 153.45,77.96 v1(153.43,77.96) ; v1(124.39,66.93) CN11.220 ; v1(147.41,66.86) 147.4,66.87 CN11.136 ; v1(145.9,66.89) CN11.142 ; CN1.112 153.39,79.67 153.43,79.63 v1(153.43,79.54) ; CN1.178 134.9,80.11 134.6,79.82 v1(133.92,79.82) ; U26.W6 134.91,107.32 v1(135.24,106.99) 135.31,106.99 U26.AA6 ; U26.K6 127.25,107.34 127.44,107.53 127.87,107.53 128.09,107.32 U26.L6 ; v1(139.79,78.57) 139.54,78.57 138.65,77.68 CN11.163 ; CN11.241 119.15,77.62 v1(119.2,77.68) ; v1(167.85,66.93) 167.9,66.97 CN11.54 ; v1(153.4,66.96) CN11.112 ; CN11.154 v1(140.9,66.93) ; CN1.142 145.9,79.8 v1(146.14,79.56) ; CN1.135 147.65,91.31 C380.1 ; CN1.220 v1(124.39,79.71) ; U26.R6 U26.T6 ; 142.64,90.76 CN1.147 ; CN1.153 141.15,90.59 C3427.1 ; v1(151.9,66.98) CN11.118
  TOP w0.381: C3464.2 172.64,91.44 v1(172.6,91.48) ; 162.65,90.33 162.65,91.43 C3463.2 164.06,91.44 v1(164.09,91.48)
  L8_IN3 w0.508: v1(176.53,111.41) 176.88,111.76 185.55,111.76 186,111.31 v1(186,110.95)
  BOTTOM w0.254: v1(179.27,108.54) 179.4,108.41 179.4,107.22 181.89,104.73 181.89,102.7 182.88,101.7 183.59,101.7 185.11,103.23 187.35,103.23 187.53,103.05 187.53,101.78 v1(187.4,101.65)
  BOTTOM w0.381: v1(168.86,73.62) 169.24,73.62 169.75,74.12 C3439.1 ; v1(170.65,73.72) 171.38,73.72 171.91,74.25 C387.1
  BOTTOM w0.508: v1(146.14,77.96) 146.39,77.71 C3438.1 ; v1(133.92,79.82) 134.31,80.21 R38.1 ; v1(141.29,77.86) 141.73,77.42 C388.1 ; 146.8,107.29 147.5,107.29 v1(147.8,106.99) ; C3422.1 141.43,79.72 v1(141.27,79.56) ; C135.1 140.16,79.93 v1(139.79,79.56) ; v1(150.54,77.88) 150.75,77.67 C3423.1 ; C3441.1 124.39,79.71 v1(124.39,79.71) ; R42.1 v1(133.81,66.75) ; C3416.1 124.01,75.52 v1(123.02,74.53) ; v1(134.84,110.94) 134.84,111.02 135.43,111.61 138.15,111.61 138.68,111.08 ; v1(153.43,77.96) 153.73,77.65 C3440.1 ; v1(172.54,111.46) 171.27,112.73 166.95,112.73 165.68,114 163.22,114 R197.2 ; v1(157.39,66.93) 157.39,66.5 157.08,66.2 R53.1 ; v1(148.02,79.58) 148.03,79.59 R206.2
  vias: v1(139.37,91.16) v1(142.53,91.38) v1(143.79,91.46) v1(145.32,91.2) v1(147.02,91.36) v1(148.14,66.86) v1(148.46,91.53) v1(149.65,91.5) v1(151.54,91.45) v1(153.47,91.34) v5(172.54,110.32) v5(172.54,109.3) v5(173.56,110.32) v5(173.56,109.3) v5(173.56,108.16) v5(173.56,107.14) v5(173.56,106) v5(174.57,110.32) v5(174.57,109.3) v5(174.57,108.16) v5(174.57,107.14) v5(174.57,106) v5(174.7,104.85) v5(175.72,106) v5(175.72,104.85) v5(176.86,106) v5(176.86,104.85)
+1.8VA: length 112.5
  TOP w0.381: v1(98.22,21.19) 98.14,21.11 98.14,20.45 99.34,19.26 R368.1
  L3_IN1 w0.508: v5(70.04,60.4) 70.04,54.88 72.75,52.17 77.75,52.17 81.25,48.67 84.94,48.67 85.45,48.16 85.45,32.66 v1(86.12,31.98) 86.12,30.16 85.29,29.33 85.29,12.35 v1(86.16,11.48)
  L6_IN2 w0.508: v1(86.12,31.98) 91.79,31.98 95.17,28.6 95.17,26.85 96.24,25.78 96.24,22.81 97.87,21.19 v1(98.22,21.19) 98.75,21.72 106.45,21.72 v1(107.39,20.78)
  L8_IN3 w0.305: v1(107.39,20.78) 107.47,20.78 107.5,20.75 110.31,20.75 110.5,20.93 113.36,20.93 113.94,20.35 113.94,20.31 114.76,19.5 v1(114.76,19.13)
  BOTTOM w0.305: R369.2 115.19,19.56 v1(114.76,19.13)
  BOTTOM w0.381: R355.1 107.95,20.21 R374.2 107.77,20.4 v1(107.39,20.78)
  BOTTOM w0.508: R356.1 88.8,8.54 88.34,8.08 86.44,8.08 85.67,8.84 85.67,11 v1(86.16,11.48)
  vias: v1(69.09,59.64) v1(73.35,60.4) v1(73.35,59.77) v1(76.99,59.9) v1(77.55,59.9) v5(69.13,61.42) v5(69.13,60.4) v5(70.04,61.42)
+1.8VA_PCH: length 2.7
  TOP w0.254: U28.AR15 v2(112.63,20.38) ; U28.BB11 v2(110.14,17.57) ; U28.AG20 114.85,24.44 v2(114.83,24.44) U28.AG19 ; U28.AN15 v2(112.63,21.47)
+2.5VS: length 136.1
  TOP w0.305: CN11.259 114.65,77.36 114.43,77.58 v1(114.21,77.58)
  L3_IN1 w1.016: 184.23,104.85 184.23,102.29 185.6,100.91 185.6,93.24 186.08,92.77 186.08,76.61 186.6,76.09 186.6,65.85 180.92,60.18 180.92,51.9 177.49,48.47 v5(172.49,48.47) v5(171.09,48.47)
  BOTTOM w1.016: v5(172.49,48.47) v5(171.09,48.47) 165.28,48.47 152.07,61.67 132.41,61.67 129.92,64.16 115.14,64.16 113.46,65.84 113.46,66.5 113.56,66.6
  vias: v1(114.03,88.44) v1(114.08,87.79) v1(114.22,78.19) v1(185.24,105.62) v1(185.88,105.62)
+3.3V: length 485.7
  TOP w0.203: 127.23,155.65 127.6,156.02 U4.20 ; 134.54,155.15 134.94,155.54 U6.20 ; C1193.1 118.49,155.58 118.86,155.95 U11.20 ; 142.42,155.5 142.75,155.5 143.12,155.87 U10.20 ; U15.20 162.11,150.43 161.97,150.29 161.14,150.29 C1197.1 ; C1196.1 152.21,150.41 U13.20
  TOP w0.254: R175.2 110.82,87.07 115.13,87.07 115.64,87.58 CN1.255
  TOP w0.305: R312.1 89.5,50.59 89.07,50.59 v1(88.98,50.5) ; C3847.1 8.03,65.28 7.43,65.87 U1.4 ; CN11.255 115.65,75.35 115.17,74.88 111.99,74.88 111.6,74.5 ; v1(180.42,42.07) R335.1
  TOP w0.381: R834.1 92.58,60.05 93.02,59.61 94.03,59.61 v1(94.06,59.64) R832.1 ; C1196.1 152.11,150.32 151.64,150.32 150.8,151.16 150.8,151.42 150.8,151.49 v1(150.8,151.49) ; R264.1 98.5,58.12 v1(97.61,57.23) 97.61,56.72 97.99,56.34 Q109.2 ; R3540.1 93.88,58.75 v1(93.8,58.83) ; R560.1 v1(187.02,152.99) ; 142.42,155.5 141.88,155.5 C1195.1 v1(141.25,155.55) ; v1(133.6,154.41) 133.88,154.69 133.88,155.04 C1194.1 133.98,155.15 134.54,155.15 ; C1197.1 161.01,150.42 160.48,150.42 v1(160.48,150.42) ; v1(126.08,155.04) 126.08,155.32 126.41,155.65 C1176.1 126.51,155.61 127.18,155.61 127.23,155.65 ; R3539.1 102.79,59.67 103.2,59.26 v1(103.2,59.03) ; R329.1 v1(142.32,6.94) ; R327.1 141.17,6.78 v1(141.3,6.91)
  TOP w0.508: v1(192.15,148.72) R254.2 R794.1 ; v1(12.27,62.56) 12.7,63 R795.2 ; R32.2 v1(191.46,140.67) ; R2925.1 92.86,66.55 v1(93.04,66.37) 93.62,66.37 R2850.1 ; Q165.5 7.3,112.46 v1(6.81,111.97) ; R460.1 155.98,12.6 156.49,12.09 ; C3847.1 8.03,64.52 v1(8.08,64.47) ; v1(144.73,5.54) 144.52,5.34 C46.2 143.2,4.78 142.88,4.45 CNDEG2.5 ; v1(155.4,40.85) 155.6,41.05 R342.1 ; C1193.1 117.47,155.58 v1(117.04,155.15) ; R472.1 153.03,12.6 152.35,13.29 v1(152.35,14.81) ; v1(24.59,115.65) 24.33,115.9 R972.1 ; 111.6,74.5 111.6,73.25 110.06,71.71 110.06,68.96 108.72,67.63 v1(108.09,67.63) ; Q96.5 74.62,51.84 R978.1 73.61,53.8 v1(73.74,53.93) ; v1(91.9,61.55) 92.28,61.17 R828.2 ; v1(81.48,59.75) 81.5,59.77 R3536.1 ; 156.49,12.09 156.62,12.09 v1(158.95,14.43) ; 156.49,12.09 R235.1 ; R1794.2 24.08,107.65 v1(23.7,108.03) ; v1(34.62,61.67) 34.62,58.63 34.62,58.25 v1(34.49,58.12) 34.49,57.47 AB2.2 ; R294.2 99.52,20.07 99.01,20.58 v1(99.01,20.7) ; R1795.2 R3537.1 v1(10.31,105.95) ; v1(101.93,56.98) 102.03,56.98 102.15,57.1 R188.2 R184.2 101.6,56.21 R266.2 101.37,56.34 Q109.5 ; v1(151.76,25.68) R116.2 153.41,25.68 153.87,25.23 R3290.1 ; R336.2 v1(134.19,33.23) ; R905.1 79.45,54.23 79.45,52.53 v1(79.83,52.15) 80.52,51.46 R365.2 ; v1(122.57,62.45) 120.26,62.45 118.87,63.83 112.41,63.83 111.07,62.5 111.07,60.53 108.3,57.76 108.3,57.76 106.63,56.09 105.1,56.09 v1(104.98,55.97) ; R169.2 108.1,78.39 107.97,78.26 v1(107.9,78.26) ; R175.2 108,84.25 v1(107.31,84.25) ; v1(100.61,15.22) 100.56,15.17 100.56,14.63 100.53,14.61 100.53,13.41 102.87,11.08 103.73,11.08 104.6,10.21 R3716.1 103.4,8.79 102.18,7.57 102.18,6.18 102.82,5.54 103.96,5.54 105.26,4.24 107.75,4.24 v1(108.15,4.65) ; v1(92.4,44.91) 92.84,44.91 R1921.1 ; Q37.G 53.08,171.52 R674.1 v1(52.27,170.26)
  L3_IN1 w0.508: v1(8.08,64.47) 9.4,64.47 11.3,62.56 v1(12.27,62.56) 12.65,62.94 14.17,62.94 15.16,61.95 15.16,54.54 17.37,52.33 25.3,52.33 26.03,53.06 29.44,53.06 v1(34.49,58.12) ; v1(122.57,62.45) 124.84,64.72 134.7,64.72 135.46,65.48 v1(135.46,66.75) ; v1(23.7,108.03) 20.9,110.82 16.59,110.82 11.51,105.74 10.51,105.74 v1(10.31,105.95) 10.31,108.46 v1(6.81,111.97)
  L6_IN2 w0.508: v1(56.34,159.97) 54.05,159.97 53.42,160.61 53.42,161.91 52.6,162.72 52.6,169.93 v1(52.27,170.26)
  L8_IN3 w0.508: v1(119.07,13.41) 119.07,13.37 119.58,12.86 v1(119.58,11.41) ; v1(53.54,62.31) 52.68,63.17 36.12,63.17 v1(34.62,61.67) ; v1(10.31,105.95) 10.31,105.82 9.95,105.46 9.95,102.72 11.38,101.3 11.38,94.69 9.7,93.02 9.7,79.25 8.19,77.74 8.19,74.18 7.44,73.43 7.44,71.96 8.08,71.33 v1(8.08,64.47) ; v1(91.9,61.55) 91.26,62.18 91.26,64.47 93.04,66.25 v1(93.04,66.37) ; v1(120.78,10.87) 120.78,13.47 120.78,13.56 v1(120.88,13.67) ; v1(192.15,148.72) 192.35,148.52 192.35,141.43 191.59,140.67 v1(191.46,140.67)
  BOTTOM w0.203: U5.11 v1(164.67,23.11)
  BOTTOM w0.254: 73.8,159.87 CNEDP1.35
  BOTTOM w0.305: R273.2 121.18,18.8 120.83,19.15 120.83,19.17 120.73,19.28 R341.1 ; 73.8,159.87 73.8,160.29 73.86,160.35 ; R173.2 137.57,75.99 136.76,75.19 136.76,71.53 136.99,71.3 136.99,69.05 135.46,67.52 v1(135.46,66.75)
  BOTTOM w0.381: v1(192.15,148.72) 192.61,148.72 192.99,149.1 192.99,150.57 190.31,153.26 189.57,153.26 189.31,152.99 v1(187.02,152.99) ; v1(135.46,66.75) 135.46,66.07 R227.2 ; R107.2 v1(129.11,21.54)
  BOTTOM w0.508: R343.1 121.64,22.84 v1(121.87,22.61) ; R236.2 v1(166.85,20.53) ; v1(94.06,59.64) 93.8,59.64 v1(91.9,61.55) ; R102.2 R92.2 133.04,22.3 133.55,22.81 v1(133.55,23.19) R146.2 R109.2 R100.2 R350.1 ; v1(79.83,52.15) 76.4,52.15 74.62,53.93 v1(73.74,53.93) ; C175.1 164.75,23.19 v1(164.67,23.11) ; R136.1 v1(119.58,11.41) ; v1(167.97,13.29) 167.72,13.03 167.72,12.4 167.21,11.89 R126.2 ; CNDEG1.S1 180.33,3.4 CNDEG1.1 180.33,5.75 178.45,7.64 177.94,7.64 176.35,9.22 176.35,12.37 v1(174.93,13.8) ; R273.2 v1(122.12,18.21) ; v1(122.57,62.45) 113.27,62.45 v1(108.09,67.63) 106.45,69.27 106.45,76.91 107.72,78.18 107.82,78.18 v1(107.9,78.26) 108.11,78.47 108.11,83.87 107.72,84.25 v1(107.31,84.25) ; R484.2 R485.2 R253.1 108.03,4.78 v1(108.15,4.65) ; 158.57,148.54 158.57,147.6 159.08,147.09 170.31,147.09 180.42,136.99 185.24,136.99 187.78,139.53 190.32,139.53 v1(191.46,140.67) ; v1(23.7,108.03) 23.06,108.66 23.06,114.13 v1(24.59,115.65) ; R3721.2 12.14,61.83 12.14,62.44 v1(12.27,62.56) ; v1(160.48,150.42) 160.48,149.81 160.73,149.56 R250.2
  vias: v1(57.23,159.97) v1(57.86,159.97) v1(83.13,158.45) v1(83.77,158.45) v1(84.4,158.45) v1(94.49,67.97) v1(94.49,67.39) v1(117.17,153.88) v1(117.3,154.51) v1(117.8,154.77) v1(141.05,29.16) v1(141.68,29.16) v1(142.44,29.16) v1(143.08,29.16) v1(145.67,13.24) v1(146.16,13.55) v1(146.63,13.85) v1(158.83,29.92) v1(162.51,28.65) v1(163.09,28.65) v1(163.65,28.65) v1(166.19,28.65) v1(166.83,28.65) v1(168,14.48) v1(167.99,13.9) v1(168.58,14.48) v1(168.6,13.87) v1(168.6,13.29) v1(179.15,29.29) v1(179.78,29.29) v1(180.42,29.29) v3(84.28,157.36)
+3.3V_CHGR_LED: length 4.5
  TOP w0.102: R653.1 175.21,164.75 R5.2 175.59,165.56 176.22,166.2 Q54.D
+3.3VA: length 366.7
  TOP w0.203: U3.35 187.9,148.56 188.34,149 v1(188.59,149)
  TOP w0.254: U28.AC36 v2(123.11,27.49) ; v2(115.92,21.77) 115.84,21.77 U28.AN21 ; U28.AP26 117.97,21.3 v2(117.67,21.6) U28.AN26 ; U28.V23 v2(117.16,29.08) ; U28.AE35 v2(122.35,25.24) ; U28.AC35 v2(122.35,27.49) ; U28.AN44 v2(126.85,21.6) ; U28.AE36 v2(123.11,25.24) ; U28.AT44 v2(126.85,20.16) ; U28.AN32 v2(121.36,21.97) ; U28.BB7 108.96,17.87 v2(109.02,17.92) U28.AY8 ; U28.AW9 v2(109.73,18.24) ; U28.BB14 v2(111.38,17.57)
  TOP w0.381: v1(90.83,47.15) 90.45,46.76 R931.2 ; R287.2 118.57,11.2 v1(118.72,11.05) ; R3329.1 v1(59.26,43.39) ; v1(67,37.29) 66.93,37.21 R3306.1
  TOP w0.508: R3822.1 184.76,115.3 185.3,115.84 v1(186.64,115.84) ; v1(181.56,138.13) R36.2 182.24,137.38 181.74,136.87 U23.5 ; R73.2 133.81,31.45 v1(134.19,31.83) 133.68,32.34 R76.2 ; 191.21,119.59 190.58,120.22 187.27,120.22 186.51,119.46 v1(186.51,118.95) ; 191.21,119.59 R3197.2 ; 191.21,119.59 190.58,118.95 190.58,117.3 189.99,116.72 R3198.2 ; Q5.S 116.15,11 v1(115.9,11.26) ; v1(137.44,19.41) 137.03,19 R60.2 ; Q155.S 43.7,37.99 v1(43.26,38.43) ; v1(182.57,156.34) 182.24,156.67 182.24,158.5 182.75,159.01 R216.2 ; R3323.1 73.48,43.39 v1(73.61,43.26) ; U20.8 133.55,29.78 C221.1 134.08,30.32 v1(134.82,31.07) 135.03,31.27 R59.2 ; R179.2 v1(189.49,113.43) ; R82.1 124.66,10.37 125.65,9.38 127.35,9.38 R144.2 127.38,9.91 v1(127.71,10.24) 127.58,10.37 R111.2 R288.1 ; R155.1 119.71,7.57 v1(119.94,7.8) ; R309.1 120.47,11.43 119.91,10.87 v1(119.88,10.87) ; v1(102.31,163.91) 102.06,163.66 R937.2 ; R623.1 115.01,168.61 v1(114.88,168.48) ; v1(182.07,165.31) 181.86,165.51 R3724.1 R245.1 180.67,166.5 180.16,167.01 Q54.S ; v1(148.72,19.15) 148.61,19.26 R171.2 ; R168.2 v1(143.59,28.4) ; C1508.1 175.21,12.69 174.7,12.18 v1(174.7,11.76) ; R3332.1 69.04,45.42 v1(68.66,45.04) ; R379.2 130.05,10.16 130,10.11 v1(130,10.09) 130.41,9.68 R145.2 ; v4(7.16,72.9) 7.16,72.57 v1(6.81,72.22) ; R164.2 v1(181.51,19.08) ; R3334.1 v1(71.2,43.39) ; R889.2 174.99,15.35 v1(174.95,15.32) ; R3514.1 R3512.1 v1(168.15,11.46) ; v1(134.52,9.15) R290.2
  L3_IN1 w0.508: 43.26,36.78 42.24,35.77 24.97,35.77 23.7,37.04 11.66,37.04 9.18,39.52 3.94,39.52 2.49,40.97 2.49,45.55 4.27,47.32 4.27,60.79 4.52,61.04 4.52,70.31 6.43,72.22 v1(6.81,72.22) ; v1(182.57,156.34) 182.75,156.16 185.75,156.16 187.96,153.95 187.96,150.24 188.59,149.61 v1(188.59,149) 188.49,148.9 188.04,148.9 187.53,148.39 187.53,141.94 186.77,141.18 183.72,141.18 181.56,139.02 v1(181.56,138.13) 181.56,136.73 186.51,131.78 v1(186.51,118.95) 186.51,115.97 v1(186.64,115.84) 187.72,115.84 189.49,114.07 v1(189.49,113.43)
  L6_IN2 w0.508: v1(182.07,165.31) 182.07,161.37 181.43,160.73 181.43,159.08 182.57,157.94 v1(182.57,156.34) ; v2(122.35,27.49) 122.38,27.52 122.38,29.42 122,29.8 117.55,29.8 117.16,29.41 v2(117.16,29.08)
  L8_IN3 w0.305: v2(122.35,25.24) 122.35,24.77 121.82,24.23 121.82,23.6 121.11,22.89 121.11,22.22 v2(121.36,21.97)
  BOTTOM w0.203: C147.1 146.18,18.62 146.49,18.31 U5.74
  BOTTOM w0.305: R103.1 142.7,23.19 142.44,23.45 v1(142.19,23.45) ; v1(6.81,72.22) 8.45,73.86 CN12.50 ; v1(142.95,21.8) R143.2 ; v2(122.35,25.24) 122.3,25.19 R81.1
  BOTTOM w0.381: v1(142.93,19.4) 143.17,19.17 144.16,19.17 144.68,18.65 C147.1 ; C326.2 109.17,17.77 v2(109.02,17.92) ; v1(85.62,50.57) 85.62,50.48 88.96,47.15 v1(90.83,47.15) ; v2(126.85,21.6) 126.56,21.31 126.17,21.31 126.09,21.24 R72.2
  BOTTOM w0.508: v2(123.11,27.49) 123.11,28.09 C327.2 ; v2(121.36,21.97) 121.38,22 R89.1 R88.1 ; v1(134.52,9.15) 139.42,14.05 R170.2 ; R118.2 v1(169.01,21.42) ; v1(129.36,25.1) 129.31,25.05 R86.1 R77.1 R79.1 ; C325.2 123.7,26.04 123.11,25.46 v2(123.11,25.24) ; R151.2 184.99,109.3 184.73,109.55 184.73,114.38 186.19,115.84 v1(186.64,115.84) ; U24.5 101.53,159.45 102.06,159.97 102.06,163.66 v1(102.31,163.91) 106.5,163.91 107.01,163.4 v1(107.01,163.15) ; R3313.1 44.45,39.12 v1(44.65,39.32) ; R482.2 v1(152.3,50.14) ; R80.1 131.55,16.21 v1(131.65,16.31) 131.65,17.22 131.01,17.86 R85.1 ; R909.2 102.98,5.46 R3240.1 ; R246.1 v1(161.87,9.48) ; v1(160.48,32.34) 160.48,32.08 160.22,31.83 R251.1 ; R475.2 v1(145.06,54.05) ; v1(172.16,157.31) 166.19,163.27 165.68,163.78 161.11,163.78 155.65,169.24 143.33,169.24 142.19,168.1 133.83,168.1 133.37,167.64 130.07,167.64 129.62,168.1 123.27,168.1 122.83,168.53 R687.1 122.5,167.34 122.12,166.96 120.28,166.96 Q55.S 118.96,167.41 R688.2 R3654.1 116.71,168.28 116.66,168.23 115.14,168.23 v1(114.88,168.48) 113.87,167.47 113.87,166.32 113.11,165.56 109.42,165.56 108.53,164.67 v1(108.53,163.66)
  vias: v1(78.69,44.78) v1(79.04,44.28) v1(79.31,44.8) v1(79.46,43.89) v1(79.7,44.4) v1(100.66,8.59) v1(100.66,7.95) v1(101.29,8.59) v1(101.29,7.95) v1(143.08,27.77) v1(143.84,27.77) v1(166.7,18.29) v1(166.7,17.73) v1(171.37,13.67) v1(171.93,13.67) v1(172.41,17.99) v1(172.41,17.35) v1(172.41,16.72) v1(172.44,14.3) v1(172.49,13.67) v1(173.05,17.99) v1(173.05,17.35) v1(173.05,16.72) v1(173,14.3) v1(173.05,13.72) v5(85.29,54.69) v5(86.31,54.69) v5(87.07,55.32) v5(184.35,19.51) v5(184.35,18.49) v5(184.35,17.48) v5(185.37,19.51) v5(185.37,18.49) v5(185.37,17.48) v5(186.38,18.49) v5(186.38,17.48)
+3.3VA_RTC: length 61.4
  TOP w0.508: D1.3 180.06,24.64 C254.1 178.89,24.62 177.98,24.62 R142.1 R138.1 R315.2 178.76,22.81 v1(178.89,22.94) ; v1(175.46,20.53) 177.44,20.53 177.95,21.03 R149.1 v1(178.87,21.39)
  L6_IN2 w0.508: v1(175.46,20.53) 175.46,21.42 174.38,22.5 162.45,22.5 161.75,21.8 160.98,21.8 159.71,20.53 154.76,20.53 154.51,20.27 152.87,20.27 151.22,18.62 150.32,18.62 148.16,16.46 148.16,14.43 145.12,11.39 133.29,11.39 v1(132.16,12.53) ; v1(178.89,22.94) 178.89,21.42 v1(178.87,21.39)
+3.3VDVDD: length 13.3
  TOP w0.203: v1(28.52,58.3) 28.52,58.12 27.97,57.57 U7.1 ; v1(27.25,60.79) 27,60.79 26.98,60.77 U7.9
  TOP w0.508: AB2.1 31.44,55.71 31.44,57.17 C1235.1 31.42,58.26 C180.1 31.36,58.54 v1(31.83,59.01)
  L8_IN3 w0.508: 29.03,59.01 28.52,58.5 v1(28.52,58.3) ; 29.03,59.01 27.25,60.78 v1(27.25,60.79) ; 29.03,59.01 v1(31.83,59.01)
+3.3VS: length 95.4
  TOP w0.305: R487.2 125.6,5.46 125.55,5.41 v1(125.55,5.39) ; Q60.5 131.65,7.45 133.17,8.97 v1(133.17,10.11) ; v1(127.23,7.55) 127.33,7.45 Q60.2
  TOP w0.508: R764.2 105.87,60.43 v1(104.47,59.03) ; v4(102.95,6.73) 103.25,6.43 v1(104.72,6.43) ; v1(124.92,8.33) 125.04,8.21 R488.2 ; v1(122.25,11.13) 122.38,11.26 R321.2 ; Q105.G 94.04,21.24 R435.2 92.91,21.92 93.42,22.43 96.42,22.43 v1(97.23,23.24)
  L6_IN2 w0.508: v1(100.95,45.04) 100.95,40.5 96.21,35.77 96.21,27.23 97.23,26.22 v1(97.23,23.24)
  L8_IN3 w0.508: v1(97.23,23.24) 97.23,21.26 98.65,19.84 102.39,19.84 103.46,20.91 105.46,20.91 105.97,20.4 105.97,17 104.88,15.91 v1(104.88,14.4) ; v1(104.47,59.03) 104.47,59.01 103.45,57.99 101.04,57.99 100.15,57.1 100.15,55.3 99.41,54.56 99.41,52.1 100.56,50.96 100.56,48.59 100.95,48.21 v1(100.95,45.04)
  BOTTOM w0.508: v1(104.72,6.43) 104.6,6.56 104.6,8.72 105.36,9.48 106.75,9.48 108.41,11.13 108.41,12.7 107.29,13.82 105.4,13.82 104.88,14.34 v1(104.88,14.4)
  vias: v1(104.85,5.79) v1(167.97,18.49) v1(167.97,17.86) v1(167.97,17.22) v1(168.6,18.49) v1(168.6,17.86) v1(168.6,17.22)
+3.3VS_LAN: length 27.2
  TOP w0.203: C252.1 90.74,52.24 U1901.11 ; C246.1 97.51,54.31 96.9,53.7 96.9,53.24 96.7,53.04 U1901.32 ; C332.1 97.03,47.65 96.09,48.59 95.58,48.59 95.44,48.74 U1901.23
  TOP w0.381: R1907.1 89.53,51.51 v1(89.97,51.95) 90.45,52.43 C252.1 ; C246.1 98.04,54.82 v1(97.45,55.41) ; v1(97.87,47.32) 97.56,47.32 C332.1 ; v1(94.69,45.04) 94.77,45.04 95.07,44.73 R1920.1 95.33,45.62 R1908.1 95.2,45.75 R434.1
  L3_IN1 w0.508: v1(97.87,47.32) 95.83,47.32 94.69,46.18 v1(94.69,45.04)
  BOTTOM w0.508: v1(97.45,55.41) 98.37,54.49 98.37,52.63 97.87,52.12 v1(97.87,47.32)
  vias: v1(88.21,51.9) v1(88.85,51.9)
+5V: length 367.4
  TOP w0.203: U7.38 21.52,56.37 20.73,55.58 ; C183.1 18.97,63.05 20.05,61.97 U7.25
  TOP w0.508: v1(21.67,53.42) 21.67,53.43 C143.2 20.73,54.37 AC3.1 20.73,55.58 ; 58.37,169.75 58.37,168.35 D41.3 ; R970.2 21.55,121.13 v1(22.05,121.62) ; v1(19.63,63.71) 19.15,64.19 C199.2 18.71,63.08 C183.1 ; v1(57.86,161.24) 58.48,161.24 B12.1 ; v1(27.51,54.31) 28.57,54.31 29.17,54.92 AB6.2 ; R837.2 v1(10.36,96.35)
  L3_IN1 w0.508: 40.08,158.58 35.89,158.58 33.48,160.99 33.48,163.91 31.57,165.81 27.13,165.81 24.84,163.53 16.2,163.53 14.68,162 5.16,162 3.76,160.61 3.76,153.24 6.04,150.96 6.04,142.45 3.5,139.91 3.5,128.35 7.5,124.35 7.5,122.38 8.27,121.62 ; v1(6.3,110.32) 5.79,110.82 5.79,113.49 7.5,115.2 7.5,120.86 8.27,121.62 ; v1(107.14,4.85) 107.14,4.4 108.03,3.51 110.44,3.51 111.07,4.14 148.42,4.14 149.36,3.19 153.94,3.19 155.78,1.35 165.3,1.35 172.8,8.84 172.8,11.64 174.07,12.91 174.07,17.1 176.59,19.63 176.59,30.68 178.7,32.79 178.7,34.29 177.61,35.38 177.61,40.99 174.67,43.92 v1(174.67,46.39) ; 8.27,121.62 11.63,121.62 14.43,118.82 19.25,118.82 v1(22.05,121.62) ; v1(19.63,63.71) 19.51,63.71 18.62,62.82 18.62,54.92 20.12,53.42 v1(21.67,53.42) 22.55,54.31 v1(27.51,54.31)
  L6_IN2 w0.508: v1(6.3,110.32) 7.19,109.43 7.19,106.89 9.35,104.73 9.35,99.14 10.36,98.12 v1(10.36,96.35) 11.89,94.82 11.89,89.87 10.36,88.34 10.36,81.74 8.97,80.34 8.97,74.35 10.08,73.23 v1(10.46,73.23) 10.51,73.18 10.51,71.55 10.94,71.12 10.94,70.37 11.61,69.7 11.61,69.32 12.39,68.53 14.05,68.53 14.93,67.64 16.33,67.64 19.63,64.34 v1(19.63,63.71)
  BOTTOM w0.305: R1010.1 180.77,75.39
  BOTTOM w0.508: C278.1 v1(22.17,137.49) ; R3523.1 v1(107.14,4.85) ; 178.76,60.28 179.02,60.02 179.02,55.32 174.67,50.98 v1(174.67,46.39) ; 21.82,140.01 21.82,142.29 18.36,145.75 18.36,146.5 R280.2 ; v1(155.9,172.93) 155.9,175.06 153.19,177.78 R632.1 R793.1 ; R969.1 15.75,75.09 14.68,76.15 12.65,76.15 10.46,73.97 v1(10.46,73.23)
  BOTTOM w0.635: C278.1 22.86,138.08 22.81,138.13 v1(22.81,138.2) 22.81,139.02 21.82,140.01 U14.2
  vias: v1(57.23,161.32) v1(57.61,161.8) v1(58.11,166.96) v1(59.38,170.13) v1(59.38,169.5) v1(60.02,169.5) v1(77.21,160.89) v1(77.42,161.5) v1(77.8,160.86) v1(80.34,164.67) v1(80.34,164.04) v1(80.97,164.67) v1(80.97,164.04) v1(92.54,167.11) v1(92.55,166.49) v1(176.22,61.32) v1(176.22,60.71) v1(176.81,61.32) v1(176.81,60.71) v1(177.37,61.32) v1(177.37,60.71) v1(190.07,158.96) v1(190.19,159.59) v1(190.58,154.26) v1(190.97,153.86) v3(80.67,165.36)
+5V_3.3V_LCD: length 5.1
  TOP w0.254: R912.1 68.22,162.82 67.64,163.4 65.1,163.4 Q101.D
  vias: v1(64.21,160.73) v1(64.21,160.1) v1(64.77,160.73) v1(64.79,160.1) v3(64.57,159.24)
+5V_AMP: length 10.9
  TOP w0.203: 21.82,54.77 21.54,55.04 21.54,55.86 21.92,56.24 U7.39 ; U7.46 24.72,56.26 25.3,55.68
  TOP w0.508: 25.7,55.09 25.17,54.55 AC9.1 23.61,54.54 AC8.1 22.37,54.7 AC5.1 21.94,54.64 21.82,54.77 ; 25.7,55.09 25.7,55.28 25.3,55.68 ; 25.7,55.09 AC4.1 27.76,55.09 AB6.1
+5V_HDD: length 2.5
  BOTTOM w0.508: R510.2 186.13,73.59 Q106.D
  vias: v3(184.68,82.83)
+5V_TYPEC: length 4.1
  TOP w0.305: CON3.B4 149.8,182.84 150.11,182.53 v1(150.11,182.35) 150.11,182.32 150.06,182.27 CON3.A9 ; CON3.A4 152.55,182.24 v1(152.45,182.35) 152.45,182.35 152.45,182.5 152.81,182.85 CON3.B9
  BOTTOM w0.102: v3(150.11,181.51) v1(150.11,182.35)
  vias: v1(143.2,172.04) v1(143.79,172.04) v1(145.36,176.74) v1(146,176.74)
+5VA: length 149.4
  TOP w0.203: U107.4 v1(75.01,59.52)
  TOP w0.305: v1(58.93,61.67) 59.1,61.85 C311.1 59.74,61.67 U19.8 ; CN42.1 v1(176.92,7.7) ; v1(105.74,162.13) 105.43,161.83 R941.2
  TOP w0.381: C3631.2 172.31,15.62 v1(172.41,15.52) ; v1(88.72,48.21) 88.72,48.11 88.34,47.73 R87.2 ; C3635.2 75.13,59.39 v1(75.01,59.52) ; R70.2 v1(97.87,164.54)
  TOP w0.508: C3634.2 113,125.61 112.67,125.94 v1(112.39,125.94) ; v4(176.48,9.73) 176.48,8.14 v1(176.92,7.7) ; R881.2 v1(177.62,17.86) 177.62,17.99 177.11,18.49 175.72,18.49 174.57,17.35 174.57,16.15 173.54,15.12 172.82,15.12 v1(172.41,15.52) ; R924.2 v1(93.12,42.88) ; v1(60.7,56.42) C129.1 C128.1 58.88,56.54 U2.5 ; C3650.1 194.51,97.11 v1(194.92,96.7) ; v1(187.76,97.82) 187.45,98.12 R3381.2 ; v1(192.4,97.89) 191.97,98.33 R225.2
  L3_IN1 w0.305: v1(176.92,7.7) 176.92,7.9 176.1,8.72 176.1,13.67 176.99,14.56 176.99,17.22 v1(177.62,17.86)
  L3_IN1 w0.381: v1(97.87,164.54) 99.39,164.54 99.77,164.16 99.77,163.66 100.15,163.27 104.72,163.27 105.74,162.26 v1(105.74,162.13) ; v1(71.65,54.13) 72.34,54.82 72.34,54.94 75.01,57.61 v1(75.01,59.52)
  L3_IN1 w0.508: v1(105.74,162.13) 107.14,162.13 107.77,162.77 107.77,163.78 109.55,165.56 113.89,165.56 114.68,166.35 ; v1(172.41,15.52) 172.21,15.52 171.78,15.95 171.78,18.37 175.82,22.41 175.82,31.34 176.98,32.5 176.98,39.71 176.48,40.21 168.86,47.83 168.86,53.67 v1(171.02,55.83)
  L8_IN3 w0.381: v1(87.65,45.98) 88.72,47.04 v1(88.72,48.21)
  BOTTOM w0.203: U105.4 112.57,125.76 v1(112.39,125.94) ; U106.4 172.22,15.64 172.29,15.57 172.36,15.57 v1(172.41,15.52) ; v1(172.57,56.47) 172.67,56.57 U104.4
  BOTTOM w0.508: v1(187.76,97.82) 187.76,98.4 188.26,98.91 189.2,98.91 189.56,98.55 189.56,98.3 189.96,97.89 v1(192.4,97.89) 193.47,97.89 194.66,96.7 v1(194.92,96.7) 194.92,94.34 193.12,92.54 193.12,81.36 v1(190.19,78.44) ; v1(177.62,17.86) 178.13,17.35 R68.2
  vias: v1(56.72,59.67) v1(56.72,59.03) v1(56.72,58.4) v1(56.72,57.76) v1(57.35,59.67) v1(57.35,59.03) v1(57.35,58.4) v1(57.35,57.76) v1(108.28,52.78) v1(108.28,52.02) v1(108.53,50.88) v1(108.91,52.78) v1(108.91,52.15) v1(109.17,50.88) v1(115.42,170.26) v1(116.1,169.88) v1(116.66,169.88) v1(171.02,57.61) v1(171.02,56.98) v1(171.02,56.42) v1(171.65,56.42) v1(171.65,55.83) v1(173.68,56.47) v1(173.68,55.91) v1(173.68,55.35) v1(173.68,54.79) v1(174.32,55.4) v1(174.32,54.79)
+5VS: length 264
  TOP w0.508: R509.1 71.2,163.58 68.54,163.58 v1(68.46,163.66) Q27.S ; v1(154,4.83) 154,4.52 152.09,2.62 146.38,2.62 145.87,3.13 145.87,5.29 144.98,6.18 v1(144.73,6.18) ; R222.2 180.94,163.85 Q50.S v1(179.34,163.85)
  L3_IN1 w0.508: v1(68.46,163.66) 72.21,163.66 73.89,165.33 94.73,165.33 95.2,165.8 104.7,165.8 v1(105.1,166.2)
  L6_IN2 w0.508: v1(10.77,63.96) 9.66,63.96 8.84,64.79 8.84,72.72 7.95,73.61 7.95,80.98 9.3,82.32 9.3,94.11 7.06,96.35 7.06,100.21 5.41,101.86 5.41,105.62 v1(5.28,105.74)
  L8_IN3 w0.508: v1(5.28,105.74) 4.71,106.31 4.71,111.52 5.15,111.97 5.15,113.49 3.89,114.76 3.89,118.95 5.66,120.73 5.66,125.05 3.25,127.46 3.25,139.78 4.39,140.92 5.97,140.92 7.49,142.45 7.49,143.46 6.81,144.15 6.81,150.7 4.01,153.5 4.01,160.35 5.41,161.75 16.47,161.75 v1(18.87,159.35) 18.87,160.99 20.01,162.13 23.95,162.13 31.44,169.62 46.18,169.62 52.91,162.89 52.91,160.99 54.56,159.34 58.35,159.34 61.89,162.87 61.91,162.87 63.19,164.16 66.62,164.16 67.13,163.66 v1(68.46,163.66) ; 154,2.49 v1(154,4.83)
  BOTTOM w0.508: R586.1 18.95,157.03 19.18,157.25 19.18,159.04 v1(18.87,159.35) ; v1(110.44,6.43) 110.87,6 R662.1 ; v1(179.34,163.85) 179.34,163.72 178.64,163.02 178.64,158.19 176.99,156.54 v1(172.8,156.54) ; R3517.1 144.02,6.18 v1(144.73,6.18) ; v1(154,4.83) 154,4.85 154.51,5.36 R3520.1
  vias: v1(11.38,64.06) v1(11.38,63.45) v1(12.01,64.47) v1(12.01,63.91) v1(12.01,63.33) v1(94.26,5.41) v1(94.89,5.41) v1(95.53,5.41) v1(105.74,166.83) v1(105.74,166.2) v1(110.18,7.12) v1(110.74,7.12) v1(111.33,7.14) v1(111.33,6.58) v1(115.26,5.92) v1(115.26,5.29) v1(115.82,5.29) v1(115.9,5.9) v1(119.91,2.62) v1(119.91,1.98) v1(120.47,2.62) v1(120.47,1.98) v1(121.03,2.62) v1(121.03,1.98) v1(121.61,2.62) v1(121.61,1.98) v1(135.15,169.52) v1(135.15,168.96) v1(135.71,169.52) v1(135.71,168.96) v1(136.35,168.86) v1(136.98,168.86) v1(161.11,6.3) v1(161.11,5.67) v1(169.49,61.17) v1(169.49,60.53) v1(170.13,61.17) v1(170.13,60.53) v1(170.76,61.17) v1(170.76,60.53) v4(93.6,5.46) v5(188.67,50.32) v5(188.67,49.41) v5(189.64,50.3) v5(189.64,49.38) v5(190.63,50.35) v5(190.58,49.36)
+VCCA_XTAL_1P05: length 5.1
  TOP w0.254: v1(107.5,31.92) 107.46,31.92 U28.P3 106.84,31.29 U28.P2
  BOTTOM w0.254: v1(107.5,31.92) 107.26,32.16 104.29,32.16 104.09,31.96 R375.2
+VCCAZPLL_1P05: length 3.6
  TOP w0.254: v1(104.41,37.61) 105.69,36.33 U28.D1 105.87,36.2 105.87,35.96 U28.E1
  BOTTOM w0.203: v1(104.41,37.61) 104.41,37.35 104.93,36.83 R378.2
+VCCCORE: length 2.1
  TOP w0.203: U26.V13 133.6,111.88 v1(133.93,112.2)
  TOP w0.254: U26.W13 v1(133.93,112.2)
  BOTTOM w0.508: v1(142.59,133.66) 142.34,133.4 R49.2
  vias: v1(119.96,143.21) v1(120.6,143.21) v1(121.23,143.21) v1(121.87,143.21) v1(122.5,143.21) v1(127.58,113.11) v1(128.42,112.22) v1(128.6,112.98) v1(129.43,112.89) v1(129.37,112.2) v1(130.15,130.36) v1(130.17,131.02) v1(130.2,129.7) v1(130.17,129.06) v1(130.25,112.86) v1(130.27,112.2) v1(130.38,143.84) v1(131.01,143.84) v1(130.96,127.11) v1(130.98,126.45) v1(131.18,112.2) v1(131.65,143.84) v1(131.75,129.7) v1(131.75,128.43) v1(131.75,127.1) v1(131.75,125.81) v1(131.75,131.01) v1(131.75,130.36) v1(131.75,129.06) v1(131.75,126.46) v1(132.28,143.84) v1(132.92,143.84) v1(133.32,131.01) v1(133.32,130.36) v1(133.35,129.7) v1(133.32,129.06) v1(133.35,128.37) v1(133.32,127.1) v1(133.32,126.46) v1(133.32,125.81) v1(133.55,143.84) v1(134.11,131.01) v1(134.11,130.36) v1(134.11,129.71) v1(134.11,129.06) v1(134.11,128.41) v1(134.14,126.47) v1(134.11,125.82) v1(134.19,143.84) v1(135.28,113.67) v1(135.69,131.01) v1(135.71,130.36) v1(135.69,129.71) v1(135.69,129.06) v1(135.69,128.41) v1(135.69,127.11) v1(135.69,126.44) v1(135.84,113.69) v1(136.47,130.36) v1(136.47,129.7) v1(136.47,129.06) v1(136.47,128.4) v1(136.47,127.08) v1(136.47,126.46) v1(136.49,125.82) v1(136.67,112.23) v1(137.58,112.23) v1(138.05,129.06) v1(138.05,128.43) v1(138,127.08) v1(138.05,126.46) v1(138.01,125.87) v1(138.51,112.22) v1(138.84,131.01) v1(138.83,130.38) v1(138.84,129.71) v1(138.88,128.99) v1(139.39,112.22) v1(139.6,143.84) v1(139.6,131.01) v1(139.6,130.38) v1(139.6,129.71) v1(139.61,129.12) v1(139.65,127.08) v1(139.62,126.46) v1(139.65,125.81) v1(139.65,124.26) v1(140.16,143.84) v1(140.38,130.36) v1(140.38,129.75) v1(140.41,129.11) v1(140.41,128.48) v1(140.41,127.08) v1(140.41,126.44) v1(140.41,125.81) v1(140.54,142.7) v1(140.46,113.67) v1(140.71,143.84) v1(140.66,141.68) v1(140.66,140.67) v1(140.66,139.65) v1(141.05,142.19) v1(141.05,141.18) v1(141.05,140.16) v1(141.05,113.72) v1(141.17,143.21) v1(141.17,139.27) v1(141.17,126.44) v1(141.22,112.22) v1(141.27,143.84) v1(141.71,143.01) v1(141.83,143.84) v1(141.81,139.14) v1(141.93,126.44) v1(141.93,124.29) v1(141.99,127.11) v1(141.99,125.82) v1(142.15,112.28) v1(142.39,143.82) v1(142.39,143.06) v1(142.77,129.06) v1(142.77,126.46) v1(143.05,143.08) v1(143.08,112.19) v1(143.56,129.71) v1(143.56,129.09) v1(143.56,128.41) v1(143.56,127.11) v1(143.59,126.44) v1(143.71,143.06) v1(144.91,112.19) v1(145.14,129.71) v1(145.14,128.41) v1(145.13,127.77) v1(145.14,125.82) v1(145.82,113.67) v1(145.79,112.19) v1(145.92,130.38) v1(145.91,129.75) v1(145.92,128.4) v1(145.92,127.77) v1(145.95,125.81) v1(147.14,143.84) v1(147.27,142.95) v3(133.53,131.78) v5(123.24,143.59) v5(124.15,143.59) v5(125.17,143.59) v5(125.93,142.57) v5(126.95,142.57) v5(127.96,142.57) v5(128.85,143.03) v5(128.85,142.01) v5(128.85,140.03) v5(128.96,141.05) v5(129.87,143.03) v5(129.87,142.01) v5(129.87,141) v5(129.87,139.98) v5(130.12,139.02) v5(130.12,138.08) v5(130.12,137.06) v5(130.12,136.05) v5(130.12,135.03) v5(131.9,143.03) v5(131.9,142.01) v5(131.9,141) v5(131.9,139.98) v5(131.9,138.97) v5(131.9,137.95) v5(131.95,136.99) v5(131.95,135.97) v5(131.95,134.95) v5(133.93,143.03) v5(133.93,142.01) v5(133.93,141) v5(133.93,139.98) v5(133.93,138.97) v5(133.93,137.95) v5(133.93,136.99) v5(133.93,135.97) v5(133.93,134.95) v5(135.97,143.06) v5(135.97,142.14) v5(135.97,141.13) v5(135.97,140.11) v5(135.97,138.97) v5(135.97,137.95) v5(135.97,136.93) v5(135.97,135.92) v5(135.97,134.9) v5(137.92,143.06) v5(138,142.14) v5(138,141.13) v5(138,140.11) v5(138,138.97) v5(138,137.95) v5(138.05,136.94) v5(138.05,135.92) v5(139.9,143.08) v5(139.95,142.07) v5(139.95,141.05) v5(139.95,140.03) v5(139.95,138.89) v5(139.95,137.87) v5(139.95,136.86) v5(141.55,138) v5(142.57,139.02) v5(142.57,137.95) v5(143.59,138.97) v5(143.64,138) v5(143.59,136.99) v5(144.47,143.08) v5(144.6,138.97) v5(144.6,137.37) v5(144.6,136.35) v5(145.49,143.08) v5(145.62,138.97) v5(145.62,137.32) v5(145.62,136.3) v5(146.51,143.08) v5(147.9,143.59)
+VCCGT: length 57
  TOP w0.203: U26.BB32 152.55,126.79 v1(152.22,126.46) 152.54,126.14 U26.BB31 ; U26.BA36 151.89,129.39 v1(152.22,129.06) ; U26.BC31 153.72,126.46 v1(153.8,126.46) 154.13,126.79 U26.BD32 ; U26.BD36 154.13,129.39 v1(153.8,129.06) 154.12,128.74 U26.BD35 ; U26.BA32 151.76,126.79 v1(151.43,127.11) 151.76,127.44 U26.BA33 ; U26.BA34 151.76,128.09 151.43,128.41 151.76,128.74 U26.BA35 ; U26.AV31 149.39,126.14 v1(149.07,126.46) 149.4,126.79 U26.AV32 ; U26.BD34 154.13,128.09 v1(153.8,127.76) 154.12,127.44 U26.BD33 ; U26.BC37 153.34,130.04 v1(153.01,129.71) 153.33,129.39 U26.BC36 ; U26.BE34 154.91,128.09 v1(154.58,128.41) 154.91,128.74 U26.BE35 ; U26.AW32 150.18,126.79 v1(149.86,127.11) 150.19,127.44 U26.AW33 ; U26.AY36 150.98,129.39 v1(150.65,129.06) 150.97,128.74 U26.AY35 ; U26.BF35 155.69,128.74 v1(155.37,129.06) 155.7,129.39 U26.BF36 ; U26.BB35 152.54,128.74 v1(152.22,129.06) ; U26.BF37 155.69,130.04 v1(155.37,130.36) 155.7,130.69 U26.BF38 ; v1(152.22,129.06) 152.55,129.39 U26.BB36 ; U26.BB38 152.55,130.69 v1(152.22,130.36) 152.54,130.04 U26.BB37 ; U26.BC38 153.31,130.69 v1(153,130.38) ; U26.AY31 150.97,126.14 v1(150.65,126.46) 150.98,126.79 U26.AY32 ; U26.AW34 150.18,128.09 v1(149.86,128.41) 150.19,128.74 U26.AW35 ; U26.BH38 157.28,130.69 v1(156.95,130.36) 157.27,130.04 U26.BH37 ; U26.BB34 152.55,128.09 v1(152.22,127.76) 152.54,127.44 U26.BB33 ; U26.AV35 149.39,128.74 v1(149.07,129.06) ; U26.BE32 154.91,126.79 v1(154.58,127.11) 154.91,127.44 U26.BE33 ; U26.BG34 156.48,128.09 v1(156.16,128.41) 156.49,128.74 U26.BG35
  TOP w0.254: U26.BH38 157.35,130.69 ; v1(155.85,112.22) 155.55,112.53 U26.BF14 ; U26.BG32 v1(156.95,126.46) U26.BG31 ; U26.BL26 159.04,122.24 v1(158.74,121.94) 159.04,121.63 U26.BL25 ; U26.BH36 157.28,129.39 v1(156.95,129.06) ; U26.BH34 157.27,128.09 v1(156.95,128.41) 157.01,128.41 U26.BH35 ; U26.BL24 159.04,120.69 v1(158.72,120.37) 158.39,120.71 U26.BK24 ; U26.BL23 159.04,119.9 v1(158.72,119.59)
  TOP w0.305: U26.BC35 153.48,128.74 v1(153.8,129.06) ; v1(156.95,125.82) 156.57,125.44 U26.BG30 ; v1(154.5,131.13) 154.94,130.69 U26.BE38 ; U26.BN38 160.33,130.63 U26.BN37 ; U26.BB13 152.77,111.88 v1(153.11,112.22) 152.8,112.53 U26.BB14 ; v1(159.35,114.06) 159.04,113.75 U26.BL15 ; U26.BL36 158.91,129.4 158.57,129.75 v1(158.52,129.75) 158.82,130.04 U26.BL37 ; v1(148.56,112.25) 148.38,112.25 U26.AT14 ; U26.BF30 155.8,125.44 v1(156.17,125.82) ; U26.BJ37 158.13,130.64 U26.BJ38 v1(158.08,131.26) ; U26.BK21 158.39,118.31 v1(158.71,118) ; U26.BT37 162.29,130.29 162.89,130.89 v1(163.02,130.89) ; U26.BT37 v1(163.02,130.1) ; U26.BT37 162.16,129.97 U26.BR37 161.38,129.75 U26.BP37 160.64,130.03 U26.BN37 ; U26.BH33 157.26,127.44 v1(156.93,127.11) 156.61,127.44 U26.BG33 ; v1(156.17,126.48) 155.86,126.79 U26.BF32 ; U26.BA14 151.91,112.53 v1(152.22,112.22) 152.1,112.22 U26.BA13 ; U26.BE31 155.07,126.14 v1(155.4,126.47) 155.44,126.47 U26.BF31 ; U26.AW14 150.06,112.53 v1(150.39,112.19) ; v1(155.85,112.22) 155.51,111.88 U26.BF13 ; U26.BN37 160.32,130.04 U26.BM37 ; U26.AU14 149.12,112.53 v1(149.45,112.19) ; v1(160.86,129.11) 160.73,129.11 160.46,129.38 U26.BN36 160.29,129.39 U26.BM36 ; U26.BE36 154.89,129.39 v1(154.58,129.7) 154.93,130.04 U26.BE37 ; U26.BG36 156.62,129.39 v1(156.95,129.06) ; v1(154.04,112.2) 154.37,112.53 U26.BD14 154.58,112.53 v1(154.93,112.18) 154.63,111.88 U26.BD13
  BOTTOM w0.381: 148.59,132.17 148.22,132.54 147.8,132.54 146.66,133.68 145.03,133.68 R50.2
  vias: v1(147.5,130.36) v1(147.5,129.06) v1(147.5,127.76) v1(147.5,126.46) v1(148.28,129.71) v1(148.28,125.82) v1(149.85,129.7) v1(149.85,129.09) v1(149.86,127.74) v1(150.66,125.82) v1(151.43,125.82) v1(152.22,125.81) v1(153.8,125.82) v1(156.16,124.41) v1(158.72,122.71) v1(159.35,114.84) v1(160.6,131.24) v5(151.84,142.29) v5(151.81,141.38) v5(151.84,140.47) v5(153.75,142.32) v5(153.72,141.4) v5(153.72,140.47) v5(153.72,139.53) v5(154.2,138.51) v5(154.23,137.54) v5(154.23,136.58) v5(154.23,135.56) v5(154.23,134.55) v5(156.08,138.51) v5(156.11,137.54) v5(156.11,136.58) v5(156.11,135.56) v5(156.11,134.55) v5(157.05,121.11) v5(157.05,120.09) v5(157.05,118.44) v5(157.05,117.05) v5(157.05,115.65) v5(157.05,114.25) v5(157.12,122.13) v5(158.04,138.53) v5(158.06,137.57) v5(158.06,136.6) v5(158.06,135.59) v5(158.06,134.57) v5(158.39,139.53) v5(159.05,143.21) v5(159.05,142.27) v5(159.33,141.35) v5(159.31,140.44) v5(159.31,139.53) v5(159.94,138.53) v5(159.94,137.52) v5(159.94,136.55) v5(159.94,135.54) v5(159.94,134.52) v5(160.96,143.21) v5(160.96,142.27) v5(161.19,141.35) v5(161.16,140.44) v5(161.16,139.53)
