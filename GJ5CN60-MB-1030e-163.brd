# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D60: length 33.2
  TOP w0.165: v6(83.95,113.98) G1.AR48 ; M42.N4 v1(92.9,142.03)
  L8_IN3 w0.135: v6(83.95,113.98) 83.95,114.39 84.14,114.58 84.14,115.34 83.99,115.49 83.99,116.58 84.8,117.39 84.8,119.58 89.79,124.57 89.79,138.04 90.79,139.04 90.79,140.12 91.68,141.02 91.68,141.47 91.85,141.63 92.39,141.63 92.79,142.03 v1(92.9,142.03)
FBA_D61: length 37.4
  TOP w0.165: M42.N2 v1(93.7,142.03)
  TOP w0.17: v6(83.15,112.68) G1.AN47
  L8_IN3 w0.102: v6(83.15,112.68) 82.87,112.96 82.87,113.72 82.77,113.82 82.77,114.89 82.83,114.96 82.83,115.06
  L8_IN3 w0.135: v1(93.7,142.03) 93.3,142.43 92.41,142.43 92.08,142.76 91.45,142.76 90.29,141.59 90.29,139.61 89.18,138.5 89.18,124.98 83.48,119.29 83.48,115.85 83.12,115.49 83.12,115.34 82.83,115.06
FBA_D62: length 32.3
  TOP w0.165: M42.M4 v1(92.1,141.23) ; v6(83.95,113.28) G1.AR47
  L8_IN3 w0.135: v6(83.95,113.28) 84.48,113.81 84.48,115.73 85.38,116.64 85.38,118.26 85.92,118.8 85.92,119.74 90.39,124.21 90.39,137.85 91.29,138.74 91.29,139.62 92.1,140.43 v1(92.1,141.23)
FBA_D63: length 34.8
  TOP w0.165: v6(83.95,112.58) 84.04,112.49 G1.AR46 ; M42.M2 94.1,141.62 94.48,141.23 v1(94.5,141.23)
  L8_IN3 w0.135: v1(94.5,141.23) 94.41,141.23 93.21,140.03 92.45,140.03 91.83,139.41 91.83,138.45 91.06,137.68 91.06,124.01 86.53,119.48 86.53,118.7 85.77,117.95 85.77,116.47 84.82,115.52 84.82,113.01 84.4,112.58 v6(83.95,112.58)
FBA_DBI0: length 25.1
  TOP w0.165: M41.P2 v1(66.7,134.83) ; G1.U47 v6(71.35,113.28)
  L6_IN2 w0.14: v1(66.7,134.83) 66.3,134.43 66.3,130.9 68.05,129.15 68.05,125.6 69.88,123.77 71.3,122.35 71.3,116.34 71.64,115.99 71.64,113.53 71.4,113.28 v6(71.35,113.28)
FBA_DBI1: length 25.3
  TOP w0.1: G1.Y48 73.75,113.96 73.44,114.26 73.44,114.64 73.24,114.84 v6(73.24,114.87)
  TOP w0.165: M41.P13 v1(75.5,134.83)
  L6_IN2 w0.14: v6(73.24,114.87) 73.38,115 73.38,116.04 73.8,116.46 73.8,124.73 72.37,126.16 72.37,133.91 72.89,134.43 75.1,134.43 v1(75.5,134.83)
FBA_DBI2: length 38.2
  TOP w0.165: M41.D13 v1(74.7,143.63)
  TOP w0.17: G1.AG47 v6(78.95,113.28)
  L6_IN2 w0.14: v6(78.95,113.28) 78.54,113.68 78.54,115.45 79.25,116.15 79.25,121.72 79.9,122.37 79.9,142.13 77.94,144.08 77.94,144.74 77.8,144.88 76.76,144.88 76.71,144.83 75.3,144.83 75.1,144.63 75.1,144.03 v1(74.7,143.63)
FBA_DBI3: length 41.3
  TOP w0.1: G1.AC48 75.85,113.92 75.52,114.25 75.52,114.71 v6(75.45,114.78)
  TOP w0.165: M41.D2 v1(65.9,142.83)
  L6_IN2 w0.076: 66.29,143.85 66.29,143.22
  L6_IN2 w0.14: 66.29,143.22 v1(65.9,142.83) ; v6(75.45,114.78) 75.45,128.2 76.98,129.73 76.98,138.01 75.76,139.23 72.8,139.23 72.43,139.6 71.33,139.6 69.3,141.63 68.13,141.63 67.9,141.86 67.9,143.81 67.68,144.03 66.47,144.03 66.29,143.85
FBA_DBI4: length 24.3
  TOP w0.165: G1.BB51 v6(88.85,116.08) ; M42.D2 v1(94.5,134.83)
  L6_IN2 w0.14: v6(88.85,116.08) 89.14,115.79 91.44,115.79 94.91,119.27 94.91,134.42 v1(94.5,134.83)
FBA_DBI5: length 27.8
  TOP w0.11: G1.AV50 86,115.43 86,115.93 85.79,116.14 85.79,116.19 85.78,116.19 85.78,116.87 86.95,118.03 88.1,118.03 88.43,118.36 90.01,118.36 v6(90.4,118.75)
  TOP w0.165: M42.D13 v1(84.9,134.83)
  L6_IN2 w0.14: v1(84.9,134.83) 85.3,134.43 87.8,134.43 88.98,133.25 88.98,120.9 89.99,119.89 89.99,119.15 v6(90.4,118.75)
FBA_DBI6: length 34.3
  TOP w0.165: v6(81.75,114.78) 81.8,114.73 81.8,114.26 81.86,114.19 81.86,114.19 82.15,113.9 G1.AM48 ; M42.P13 85.27,143.23 84.9,143.6 v1(84.9,143.63)
  L6_IN2 w0.14: v1(84.9,143.63) 84.5,144.03 83.15,144.03 81.22,142.1 81.22,116.93 82.09,116.06 82.09,115.12 v6(81.75,114.78)
FBA_DBI7: length 37.6
  TOP w0.11: v6(85.23,118.76) 85.23,117.9 84.53,117.2 84.53,116.68 84.6,116.61 84.6,115.1 84.6,115.1 84.6,114.73 G1.AR49
  TOP w0.17: M42.P2 v1(94.5,142.83)
  L6_IN2 w0.14: v6(85.23,118.76) 84.77,119.21 84.77,119.7 84.35,120.12 84.35,138.12 84.67,138.43 89.06,138.43 91.66,141.03 91.66,141.37 91.92,141.63 93.06,141.63 93.06,141.63 93.29,141.86 93.3,141.87 93.3,142.21 93.52,142.43 94.1,142.43 v1(94.5,142.83)
FBA_DEBUG0: length 9.2
  TOP w0.1: G1.Y50 73.75,115.31 73.4,115.66 73.4,115.93 73.19,116.14 73.19,116.69 73.33,116.82 73.33,120.94 72.51,121.75 v1(72.46,121.75)
  BOTTOM w0.102: R887.2 72.59,121.62 v1(72.46,121.75) 72.44,121.77 v3(72.44,122.56)
FBA_DEBUG1: length 7.1
  TOP w0.1: v6(84.16,119.31) 83.63,118.78 83.63,116.25 83.91,115.97 83.91,115.62 84.25,115.28 G1.AR50
  BOTTOM w0.127: v6(84.16,119.31) 83.6,119.88 83.6,119.89 ; R888.2 83.6,121.49 83.6,119.89 ; 83.6,119.89 v3(83.62,119.87)
FBA_EDC0: length 24.8
  TOP w0.165: M41.R2 66.3,134.43 v1(65.89,134.03) ; v6(70.55,113.98) G1.R48
  L6_IN2 w0.14: v1(65.89,134.03) 65.5,133.63 64.91,133.63 64.69,133.41 64.69,131.02 67.4,128.31 67.4,125.21 70.77,121.84 70.77,115.9 70.15,115.28 70.15,114.38 v6(70.55,113.98)
FBA_EDC1: length 22.8
  TOP w0.1: v6(72.65,114) 72.68,114 72.67,113.99 72.65,113.99 G1.V48
  TOP w0.165: M41.R13 v1(74.7,134.03)
  L6_IN2 w0.14: v6(72.65,114) 73,114.35 73.5,114.35 73.91,114.76 73.91,115.74 74.3,116.13 74.3,125.45 73.6,126.15 73.6,132.24 74.3,132.94 74.3,133.63 v1(74.7,134.03)
FBA_EDC2: length 37.4
  TOP w0.11: G1.AF44 v6(77.65,111.18)
  TOP w0.165: M41.C13 v1(75.5,144.43)
  L6_IN2 w0.14: v6(77.65,111.18) 78.08,111.62 78.08,115.69 77.85,115.93 77.85,122.27 79.31,123.73 79.31,141.87 77.19,144 77.13,144 77.13,144 76.78,144 76.77,144 75.93,144 v1(75.5,144.43)
FBA_EDC3: length 38.3
  TOP w0.1: G1.AA48 74.76,113.99 v6(74.8,113.99)
  TOP w0.165: M41.C2 66.69,143.64 v1(66.69,143.62)
  L6_IN2 w0.14: v6(74.8,113.99) 74.36,114.43 74.36,115.45 74.89,115.98 74.89,130.98 75.9,131.99 75.9,137.39 75.89,137.39 75.66,137.63 75.66,137.63 71.02,137.63 67.9,140.75 67.9,141.42 67.69,141.63 67.3,141.63 67.1,141.83 67.1,143.22 v1(66.69,143.62)
FBA_EDC4: length 21.8
  TOP w0.136: G1.BB52 89.28,116.61 89.49,116.61 89.49,116.61 89.9,116.61 v6(89.95,116.66)
  TOP w0.165: v1(93.7,134.03) M42.C2
  L6_IN2 w0.14: v1(93.7,134.03) 93.3,133.63 93.3,121.46 93.84,120.91 93.84,119.26 91.02,116.44 90.16,116.44 v6(89.95,116.66)
FBA_EDC5: length 25.2
  TOP w0.11: G1.AT50 84.95,115.23 85.3,115.58 85.3,115.98 85.35,116.03 85.35,117.22 86.84,118.72 87.46,118.72 87.65,118.91 87.93,119.19 89.02,119.19 v6(89.25,118.96)
  TOP w0.165: M42.C13 v1(85.7,134.03)
  L6_IN2 w0.14: v1(85.7,134.03) 86.1,133.63 87.76,133.63 88.05,133.34 88.05,120.16 v6(89.25,118.96)
FBA_EDC6: length 36
  TOP w0.165: M42.R13 v1(85.7,144.43) ; G1.AK48 81.08,114.02 v6(81.09,114.02)
  L6_IN2 w0.14: v6(81.09,114.02) 81.08,114.02 81.06,114.02 80.75,114.34 80.75,121.05 80.53,121.26 80.53,142.36 83,144.83 85.3,144.83 v1(85.7,144.43)
FBA_EDC7: length 37.5
  TOP w0.11: v6(84.23,118.18) 83.89,117.83 83.89,116.37 84.25,116.01 G1.AR51
  TOP w0.165: M42.R2 v1(93.7,143.63)
  L6_IN2 w0.14: v6(84.23,118.18) 84.18,118.18 82.85,119.52 82.85,135.4 83.2,135.75 83.2,138.31 83.79,138.9 84.35,138.9 84.68,139.23 87.42,139.23 87.84,139.65 88.57,139.65 89.92,141 89.92,142.05 90.62,142.75 92.12,142.75 92.6,143.23 93.3,143.23 v1(93.7,143.63)
FBA_VREFC: length 9
  TOP w0.381: M41.J14 76.81,139.23 77.28,139.7 R2691.1
  TOP w0.4: M42.J14 84.49,139.23 82.46,139.23 C880.2 C874.2 R2693.1 R2692.2 R2691.1
FBA_WCK01_N: length 29.9
  TOP w0.127: M41.P5 v1(68.3,134.83) ; G1.U44 v6(71.35,110.58)
  L6_IN2 w0.094: v1(68.3,134.83) 68.3,134.83 68.51,134.62 69.28,134.62 70.78,133.12 70.78,132.7 70.57,132.49 70.4,132.49 70.31,132.4 70.31,132.21 70.4,132.12 70.57,132.12 70.78,131.91 70.78,131.56 70.57,131.36 70.4,131.36 70.31,131.26 70.31,131.08 70.4,130.98 70.57,130.98 70.78,130.78 70.78,125.74 73.28,123.24 73.28,116.8 72.2,115.72 72.2,111.16 71.96,110.92 71.68,110.92 71.35,110.58 v6(71.35,110.58)
FBA_WCK01_P: length 30
  TOP w0.127: v6(71.35,111.28) G1.U45 ; v1(67.5,134.83) 67.5,134.83 67.9,135.23 M41.P4
  L6_IN2 w0.094: v1(67.5,134.83) 67.52,134.77 68.11,134.43 69.2,134.43 70.59,133.04 70.59,132.78 70.49,132.68 70.32,132.68 70.12,132.48 70.12,132.13 70.32,131.92 70.49,131.92 70.59,131.83 70.59,131.64 70.49,131.55 70.32,131.55 70.12,131.34 70.12,131 70.32,130.79 70.49,130.79 70.59,130.7 70.59,125.66 73.09,123.16 73.09,116.88 72.01,115.8 72.01,111.24 71.88,111.11 71.52,111.11 v6(71.35,111.28)
FBA_WCK23_N: length 41.2
  TOP w0.127: G1.AC44 v6(75.55,110.58) ; v1(69.13,142.89) 69.05,142.89 68.71,143.23 M41.D5
  L6_IN2 w0.094: v1(69.13,142.89) 69.13,142.8 69.18,142.75 69.28,142.64 69.77,142.64 71.91,140.5 75.67,140.5 76.45,139.72 76.86,139.72 78.56,138.02 78.56,125.1 76.29,122.83 76.29,111.34 75.55,110.59 v6(75.55,110.58)
FBA_WCK23_P: length 41.3
  TOP w0.127: v1(68.3,142.83) M41.D4 ; G1.AC45 v6(75.55,111.28)
  L6_IN2 w0.094: v6(75.55,111.28) 75.69,111.14 75.82,111.14 76.1,111.42 76.1,122.91 78.37,125.18 78.37,137.94 76.78,139.53 76.37,139.53 75.59,140.31 71.83,140.31 69.69,142.45 68.67,142.45 v1(68.3,142.83)
FBA_WCK45_N: length 33.4
  TOP w0.127: M42.D5 91.88,135.05 91.98,135.05 92.1,135.16 v1(92.1,135.63) ; v6(86.05,111.98) 86.05,112.12 86.2,112.28 G1.AV46
  L6_IN2 w0.094: v1(92.1,135.63) 91.89,135.84 91.51,135.84 91.04,135.36 91.04,123.33 90.83,123.13 90.45,123.13 90.36,123.03 90.36,122.85 90.45,122.75 90.83,122.75 91.04,122.55 91.04,122.2 90.83,121.99 90.45,121.99 90.36,121.9 90.36,121.71 90.45,121.62 90.83,121.62 91.04,121.41 91.04,121.07 90.83,120.86 90.45,120.86 90.36,120.77 90.36,120.58 90.45,120.49 90.83,120.49 91.04,120.28 91.04,118.04 90.58,117.59 87.37,117.59 86.81,117.03 86.81,112.89 86.43,112.51 86.43,112.05 86.36,111.98 v6(86.05,111.98)
FBA_WCK45_P: length 33.3
  TOP w0.127: v6(86.05,112.68) G1.AV47 ; v1(92.9,135.63) M42.D4
  L6_IN2 w0.094: v6(86.05,112.68) 86.33,112.68 86.62,112.97 86.62,117.11 87.29,117.78 90.5,117.78 90.85,118.12 90.85,120.2 90.75,120.29 90.37,120.29 90.17,120.5 90.17,120.85 90.37,121.05 90.75,121.05 90.85,121.15 90.85,121.33 90.75,121.43 90.37,121.43 90.17,121.63 90.17,121.98 90.37,122.18 90.75,122.18 90.85,122.28 90.85,122.47 90.75,122.56 90.37,122.56 90.17,122.77 90.17,123.11 90.37,123.32 90.75,123.32 90.85,123.41 90.85,135.44 91.43,136.03 92.5,136.03 v1(92.9,135.63)
FBA_WCK67_N: length 43.4
  TOP w0.127: M42.P5 91.56,143.09 91.39,143.09 91.3,143.18 v1(91.3,143.6) ; v6(83.95,110.58) 84.15,110.58 84.25,110.68 G1.AR44
  L6_IN2 w0.094: v1(91.3,143.6) 91.07,143.83 90.19,143.83 89.28,142.92 89.28,141.33 88.36,140.41 85.13,140.41 84.21,139.48 82.77,139.48 82.11,138.82 82.11,117.97 84.66,115.42 84.66,115.36 84.66,115.36 84.66,111.35 84.21,110.9 84.13,110.9 83.95,110.71 v6(83.95,110.58)
FBA_WCK67_P: length 43.5
  TOP w0.127: M42.P4 92.48,143.23 v1(92.1,143.62) ; G1.AR45 v6(83.95,111.28)
  L6_IN2 w0.094: v1(92.1,143.62) 91.69,144.02 90.11,144.02 89.09,143 89.09,141.41 88.28,140.6 85.05,140.6 84.13,139.67 82.69,139.67 81.92,138.9 81.92,117.89 84.47,115.34 84.47,115.28 84.47,115.28 84.47,111.43 84.28,111.24 83.99,111.24 v6(83.95,111.28)
FBA_ZQ0: length 5.6
  TOP w0.125: M41.J13 v1(75.5,138.83)
  BOTTOM w0.117: R2685.1 79.65,139.22 79.35,139.53 v3(77.11,139.53) 76.19,139.53 v1(75.5,138.83)
FBA_ZQ2: length 5
  TOP w0.125: M42.J13 85.3,139.22 84.91,138.83 v1(84.9,138.83)
  BOTTOM w0.117: v1(84.9,138.83) 83.5,138.83 v3(82.93,139.4) 82.8,139.53 81.36,139.53 81.02,139.2 R2686.1
FBB_CLK0_N: length 41.6
  TOP w0.127: G1.G42 v6(64.95,109.78) ; v1(38.15,116.96) 38.15,116.96 37.75,116.56 M43.J11
  L3_IN1 w0.102: 49.16,121.66 49.19,121.66 49.19,121.66 49.25,121.66 49.5,121.4 49.5,121.1 49.12,120.72 49.12,120.55 49.24,120.43 49.41,120.43 49.79,120.81 50.1,120.81 50.36,120.55 50.36,120.25 49.84,119.73 49.84,119.56 49.95,119.44 50.12,119.44 50.64,119.96 50.95,119.96 61.51,109.4
  L3_IN1 w0.109: 49.16,121.66 40.74,121.66 40.38,121.3 40.38,121.2 40.09,120.91 v1(39.8,120.91) 40,120.71 40,120.54 39.64,120.18 39.35,120.18 38.44,119.28 38.44,118.98 37.75,118.29 37.75,117.36 v1(38.15,116.96) ; v6(64.95,109.78) 64.95,109.53 64.81,109.4 61.51,109.4
  BOTTOM w0.127: 40.08,121.67 40.33,121.42 40.33,121.04 40.19,120.91 v1(39.8,120.91)
FBB_CLK0_P: length 41.7
  TOP w0.127: v1(38.15,117.76) 38.15,117.64 37.87,117.36 M43.J12 ; G1.H42 65.35,109.48 65.65,109.78 v6(65.65,109.78)
  L3_IN1 w0.102: 49.16,121.46 49.17,121.46 49.31,121.32 49.31,121.18 48.93,120.8 48.93,120.47 49.16,120.23 49.49,120.23 49.87,120.61 50.02,120.61 50.16,120.47 50.16,120.33 49.64,119.81 49.64,119.48 49.87,119.24 50.2,119.24 50.72,119.76 50.87,119.76 61.42,109.2 61.48,109.2 61.48,109.2 61.51,109.2
  L3_IN1 w0.109: 61.51,109.2 64.9,109.2 65.48,109.78 v6(65.65,109.78) ; 49.16,121.46 40.83,121.46 40.58,121.21 40.58,121.12 40.79,120.91 v1(41.1,120.91) 40.74,120.55 40.29,120.55 39.72,119.98 39.43,119.98 38.64,119.19 38.64,118.9 37.96,118.21 37.96,117.96 v1(38.15,117.76)
  BOTTOM w0.127: R2737.2 40.89,121.67 40.57,121.35 40.57,121.05 40.71,120.91 v1(41.1,120.91)
FBB_CLK1_N: length 41.6
  TOP w0.127: v1(51.5,138.83) M44.J11 ; G1.E47 62.93,112.98 62.87,112.92 62.87,112.67 v6(62.98,112.56)
  L8_IN3 w0.109: v6(62.98,112.56) 62.75,112.79 62.47,112.79 62.06,113.2 60.64,113.2 59.27,114.57 59.27,116.1 46.76,128.6 46.76,136.63 47.56,137.43 v1(47.75,137.43) 47.94,137.23 48.12,137.23 48.24,137.35 48.24,138.79 48.87,139.42 50.27,139.42 50.47,139.22 51.1,139.22 v1(51.5,138.83)
  BOTTOM w0.122: v1(47.75,137.43) 47.2,136.89 46.99,136.89 R2740.2
FBB_CLK1_P: length 41.9
  TOP w0.127: v1(50.7,138.83) 51.01,138.83 51.09,138.92 51.09,139.23 M44.J12 ; v6(63.65,112.68) G1.F47
  L8_IN3 w0.109: v6(63.65,112.68) 63.34,112.99 62.55,112.99 62.14,113.4 60.73,113.4 59.47,114.66 59.47,116.18 46.97,128.68 46.97,136.55 47.27,136.85 47.62,136.85 47.75,136.72 v1(47.75,136.13) 48.44,136.82 48.44,138.7 48.95,139.22 50.19,139.22 50.39,139.02 50.49,139.02 50.68,138.83 v1(50.7,138.83)
  BOTTOM w0.122: v1(47.75,136.13) 47.75,136.5 47.6,136.65 47.19,136.65 R2739.2
FBB_CMD0: length 29.2
  TOP w0.127: G1.B35 61,104.58 60.65,104.23 56.42,104.23 56.19,104 50.9,104 49.02,105.88 38.13,105.88 36.55,107.46 36.55,107.76 36.46,107.85 36.46,108.17 36.55,108.26 36.55,109.76 M43.G3
FBB_CMD1: length 30.5
  TOP w0.127: G1.A35 51.54,104.58 51.15,104.58 49.27,106.46 38.6,106.46 37.67,107.39 37.67,107.39 37.3,107.76 37.3,108.2 37.35,108.25 v1(37.35,109.76)
  TOP w0.136: M43.J3 v1(37.35,109.76)
  BOTTOM w0.127: R898.2 36.47,106.89 36.47,107.83 36.42,107.88 v3(36.42,108.72) 37.35,109.64 v1(37.35,109.76)
FBB_CMD2: length 30.4
  TOP w0.127: G1.D35 62.2,104.93 51.62,104.93 49.51,107.05 39.03,107.05 38.25,107.83 38.25,108.06 38.15,108.16 v1(38.15,108.96)
  TOP w0.136: v1(38.15,108.96) M43.J2
  BOTTOM w0.076: v1(38.15,108.96) 38.77,108.96 v3(38.84,108.89)
  BOTTOM w0.127: v1(38.15,108.96) 38.25,108.86 38.25,107.48 38.15,107.38 38.1,107.33 R903.1
FBB_CMD3: length 24.7
  TOP w0.127: M43.L3 38.95,109.76 38.95,108.36 39.68,107.63 49.75,107.63 52.1,105.28 G1.A36
FBB_CMD4: length 26
  TOP w0.127: G1.B36 60.95,105.28 60.63,105.6 53.02,105.6 48.55,110.06 45.8,110.06 45.3,110.56 45.3,111.16 44.31,112.15 38.94,112.15 M43.K5
FBB_CMD5: length 28
  TOP w0.127: M43.K4 38.15,111.36 38.15,111.91 38.66,112.42 44.47,112.42 46.2,110.7 48.74,110.7 53.42,106.02 57.97,106.02 58.14,105.85 60.73,105.85 60.95,105.63 61.26,105.63 61.61,105.28 G1.C36
FBB_CMD6: length 27.6
  TOP w0.127: G1.C38 61.5,106.33 61,106.33 60.77,106.11 58.3,106.11 57.96,106.44 53.82,106.44 48.93,111.34 46.14,111.34 44.79,112.69 38.33,112.69 37.75,112.11 M43.J5
FBB_CMD7: length 28.5
  TOP w0.127: M43.J4 37.35,111.36 37.35,112.41 37.9,112.96 45.24,112.96 46.04,112.15 48.94,112.15 54.3,106.79 58.03,106.79 58.46,106.36 60.68,106.36 61,106.68 G1.B38
FBB_CMD8: length 27.2
  TOP w0.127: M43.H5 36.95,112.46 37.75,113.26 45.66,113.26 46.18,112.74 49.18,112.74 54.76,107.16 58.14,107.16 58.62,106.68 G1.A38
FBB_CMD9: length 31
  TOP w0.127: M43.H4 36.55,111.36 36.55,112.56 37.55,113.56 46.04,113.56 46.23,113.37 49.37,113.37 55.24,107.5 58.38,107.5 58.84,107.03 62.2,107.03 G1.D38
FBB_CMD10: length 29.9
  TOP w0.127: G1.A39 58.95,107.38 58.44,107.89 55.68,107.89 49.49,114.08 46.4,114.08 46.17,113.86 37.5,113.86 36.55,114.81 36.55,117.02 36.21,117.36 M43.G12
FBB_CMD11: length 28.6
  TOP w0.127: G1.B39 60.95,107.38 60.62,107.71 59.26,107.71 58.77,108.19 56.89,108.19 56.76,108.32 56.08,108.32 49.73,114.67 46.37,114.67 45.86,114.16 37.7,114.16 36.95,114.91 M43.H10
FBB_CMD12: length 30
  TOP w0.127: M43.H11 37.35,116.16 37.35,115.01 37.9,114.46 45.55,114.46 46.34,115.25 49.97,115.25 56.55,108.67 56.85,108.67 57.03,108.49 59.24,108.49 59.77,107.96 60.72,107.96 60.95,107.73 61.35,107.73 61.7,107.38 G1.C39
FBB_CMD13: length 30.6
  TOP w0.127: G1.C41 61.5,108.43 61,108.43 60.77,108.2 60.01,108.2 59.46,108.75 57.27,108.75 56.95,109.08 56.75,109.08 52.52,113.31 52.52,115.58 52.26,115.83 46.33,115.83 45.25,114.76 38.55,114.76 38.25,115.06 38.25,115.41 38.15,115.51 38.15,116.16 M43.K11
FBB_CMD14: length 28.6
  TOP w0.127: M43.K10 38.55,115.36 38.85,115.06 44.9,115.06 46.26,116.42 52.59,116.42 53.23,115.78 53.23,113.29 57.47,109.05 59.6,109.05 60.21,108.44 60.62,108.44 60.96,108.78 G1.B41
FBB_CMD15: length 29.2
  TOP w0.127: G1.A41 59.84,109.38 57.61,109.38 53.81,113.19 53.81,115.94 52.75,117 46.17,117 44.79,115.62 44.53,115.36 39.2,115.36 38.95,115.61 38.95,116.96 M43.L12
FBB_CMD16: length 32.3
  TOP w0.127: M44.L3 58.7,140.43 60.1,140.43 60.18,140.51 61.11,140.51 62.24,139.37 62.24,139.14 62.33,139.06 62.33,131.34 60.78,129.79 60.78,118.44 59.45,117.1 59.45,114.99 59.86,114.58 60.1,114.58 60.25,114.73 60.8,114.73 G1.B49
FBB_CMD17: length 36.1
  TOP w0.127: G1.A49 60.2,114.13 59.76,114.13 59.17,114.72 59.17,117.73 60.15,118.71 60.15,129.98 61.75,131.58 61.75,138.81 60.93,139.63 v1(58.7,139.63)
  TOP w0.136: M44.J3 58.56,139.49 v1(58.7,139.63)
  BOTTOM w0.127: v1(58.7,139.63) 59.3,139.63 60.2,140.53 62.42,140.53 62.81,140.92 R904.2
FBB_CMD18: length 32.5
  TOP w0.127: G1.A48 60.3,113.83 59.62,113.83 58.84,114.61 58.84,118.27 59.51,118.94 59.51,130.17 61.16,131.82 61.16,138.26 60.69,138.73 60.4,138.73 60.3,138.83 v1(59.52,138.83)
  TOP w0.136: M44.J2 59.5,138.83 v1(59.52,138.83)
  BOTTOM w0.127: R906.1 62.05,138.12 61.41,138.76 59.58,138.76 v1(59.52,138.83)
FBB_CMD19: length 31.3
  TOP w0.127: G1.D47 62.2,113.33 59.64,113.33 58.57,114.4 58.57,119.34 58.86,119.64 58.86,130.35 60.69,132.17 60.69,137.44 60.1,138.03 58.7,138.03 M44.G3
FBB_CMD20: length 27.9
  TOP w0.127: G1.A47 59.47,112.98 58.28,114.17 58.28,130.72 56.32,132.69 56.32,138.05 M44.H5
FBB_CMD21: length 30.8
  TOP w0.127: M44.H4 57.1,138.83 56.55,138.83 56.05,138.33 56.05,132.07 57.69,130.42 57.69,118.86 57.98,118.58 57.98,114.04 59.39,112.63 60.65,112.63 61,112.98 G1.B47
FBB_CMD22: length 31.8
  TOP w0.127: M44.J5 56.3,139.23 55.75,138.68 55.75,131.44 57.11,130.08 57.11,118.94 57.73,118.32 57.73,113.91 59.26,112.38 60.74,112.38 61,112.63 61.5,112.63 G1.C47
FBB_CMD23: length 34
  TOP w0.127: G1.C45 61.7,111.58 61.35,111.93 60.95,111.93 60.75,112.13 60.68,112.13 60.68,112.13 60.02,112.13 60.01,112.13 59.09,112.13 57.48,113.74 57.48,118.11 56.21,119.38 56.21,130.13 55.45,130.89 55.45,139.23 55.85,139.63 57.1,139.63 M44.J4
FBB_CMD24: length 33.5
  TOP w0.127: G1.B45 60.95,111.58 60.63,111.9 60.07,111.9 60.01,111.84 58.87,111.84 57.2,113.51 57.2,117.94 55.57,119.57 55.57,129.87 55.15,130.3 55.15,139.73 55.45,140.03 M44.K5
FBB_CMD25: length 34.7
  TOP w0.127: M44.K4 57.1,140.43 55.45,140.43 54.85,139.83 54.85,119.78 56.92,117.7 56.92,113.35 58.69,111.58 G1.A45
FBB_CMD26: length 38.4
  TOP w0.127: G1.D44 62.2,111.23 58.57,111.23 56.62,113.18 56.62,117.43 54.18,119.87 54.18,130.35 54.55,130.72 54.55,139.48 53.6,140.43 51.5,140.43 M44.L12
FBB_CMD27: length 34.7
  TOP w0.127: M44.K10 53.5,140.03 54.25,139.28 54.25,131.15 53.36,130.27 53.36,120.15 56.16,117.35 56.16,113.16 58.44,110.88 G1.A44
FBB_CMD28: length 36.7
  TOP w0.127: M44.K11 52.32,139.61 53.51,139.61 53.94,139.18 53.94,131.46 52.78,130.3 52.78,120.09 55.71,117.17 55.71,113.23 58.35,110.58 59.79,110.58 59.82,110.55 60.67,110.55 61,110.88 G1.B44
FBB_CMD29: length 37.3
  TOP w0.127: M44.H11 52.3,138.83 52.9,138.83 53,138.73 53.4,138.73 53.65,138.48 53.65,131.77 52.19,130.31 52.19,120.05 55.16,117.08 55.16,113.22 58.05,110.33 59.75,110.33 59.79,110.3 60.76,110.3 61,110.53 61.5,110.53 G1.C44
FBB_CMD30: length 36.4
  TOP w0.127: M44.H10 53.04,138.43 53.37,138.1 53.37,132.08 51.58,130.29 51.58,119.9 54.83,116.65 54.83,113.11 57.91,110.03 59.9,110.03 59.94,110.07 60.71,110.07 60.95,109.83 61.35,109.83 61.7,109.48 G1.C42
FBB_CMD31: length 37.6
  TOP w0.127: M44.G12 51.5,138.03 52.85,138.03 53.1,137.78 53.1,132.43 50.92,130.25 50.92,119.67 54.45,116.14 54.45,113.06 57.8,109.7 60.11,109.7 60.24,109.83 60.6,109.83 60.95,109.48 G1.B42
FBB_D0: length 25.2
  TOP w0.165: v1(44.7,111.01) 44.65,110.96 M43.V4 ; G1.H32 v6(65.05,102.18)
  L3_IN1 w0.135: v1(44.7,111.01) 44.93,111.24 46.23,111.24 49.96,107.51 56.81,107.51 59.81,104.51 60.34,104.51 61.75,103.1 62.08,103.1 62.08,103.09 62.41,103.09 62.42,103.1 64.13,103.1 v6(65.05,102.18)
FBB_D1: length 21.6
  TOP w0.1: 59.3,102.83 62.2,102.83
  TOP w0.102: v6(58.9,102.43) 59.3,102.83 ; 62.2,102.83 G1.D32
  TOP w0.165: M43.V2 v1(44.55,108.96)
  L3_IN1 w0.135: v6(58.9,102.43) 58.74,102.59 58.74,102.6 58.52,102.82 58.51,102.82 58.5,102.83 51.78,102.83 46.57,108.04 45.47,108.04 v1(44.55,108.96)
FBB_D2: length 20.3
  TOP w0.165: M43.T4 v1(43.75,110.56) ; v6(60,103.23) 60.05,103.18 G1.A33
  L3_IN1 w0.135: v6(60,103.23) 59.58,103.65 59.45,103.65 58.05,105.05 50.96,105.05 45.84,110.17 44.14,110.17 v1(43.75,110.56)
FBB_D3: length 21.7
  TOP w0.1: 59.83,102.05 60.15,102.05 60.25,102.15
  TOP w0.102: G1.B32 61,102.48 60.67,102.15 60.25,102.15 ; v6(59.45,102.43) 59.83,102.05
  TOP w0.165: M43.T2 v1(43.75,108.96)
  L3_IN1 w0.135: v6(59.45,102.43) 59.29,102.59 59.29,102.6 59.07,102.82 59.06,102.82 58.98,102.9 58.98,103.47 58.01,104.44 50.88,104.44 46.83,108.5 45.69,108.5 44.82,109.36 44.15,109.36 v1(43.75,108.96)
FBB_D4: length 29.6
  TOP w0.165: G1.E32 63.05,102.48 62.68,102.12 62.18,102.12 v6(62.1,102.04) ; M43.N4 v1(40.55,110.56)
  L3_IN1 w0.135: v6(62.1,102.04) 62.05,102.08 61.33,102.08 60.71,101.47 51.73,101.47 46.4,106.8 41.21,106.8 40.15,107.86 40.15,110.16 v1(40.55,110.56)
FBB_D5: length 29.4
  TOP w0.165: v6(64.34,102.1) 64.65,102.41 G1.G32 ; M43.N2 v1(41.35,108.96)
  L3_IN1 w0.135: v1(41.35,108.96) 41.75,109.36 41.75,110.84 41.88,110.96 44.05,110.96 44.41,110.6 46.16,110.6 49.89,106.87 56.83,106.87 59.79,103.91 60.08,103.91 61.25,102.74 63.7,102.74 v6(64.34,102.1)
FBB_D6: length 34.3
  TOP w0.165: G1.J30 v6(66.35,101.38) ; M43.M4 v1(39.75,110.56)
  L3_IN1 w0.135: v1(39.75,110.56) 39.25,110.06 39.25,107.58 40.6,106.23 46.19,106.23 51.43,101 61.27,101 61.43,100.84 65.8,100.84 v6(66.35,101.38)
FBB_D7: length 27.7
  TOP w0.165: M43.M2 v1(40.55,108.96) ; G1.F32 v6(63.65,102.18)
  L3_IN1 w0.135: v6(63.65,102.18) 63.39,102.44 60.97,102.44 60.47,101.93 51.95,101.93 46.57,107.31 41.52,107.31 40.95,107.88 40.95,108.56 v1(40.55,108.96)
FBB_D8: length 27.3
  TOP w0.165: M43.V11 44.53,116.94 v1(44.53,116.93) ; v6(65.64,104.98) G1.H36
  L8_IN3 w0.135: v1(44.53,116.93) 44.58,116.93 44.82,116.69 46.48,115.03 51.09,110.42 54.33,110.42 54.35,110.44 58.21,106.58 59.64,106.58 61.54,104.68 65.34,104.68 v6(65.64,104.98)
FBB_D9: length 27.6
  TOP w0.165: M43.V13 v1(44.55,118.56) ; G1.G36 v6(64.95,105.58)
  L8_IN3 w0.135: v6(64.95,105.58) 64.67,105.86 64.67,106.82 64.2,107.29 61.74,107.29 60.89,108.14 59.08,108.14 54.64,112.58 52.45,112.58 46.16,118.87 44.87,118.87 v1(44.55,118.56)
FBB_D10: length 29
  TOP w0.165: v1(43.75,116.96) M43.T11 ; G1.J36 v6(66.35,105.58)
  L8_IN3 w0.135: v1(43.75,116.96) 44.14,117.35 45.44,117.35 51.63,111.15 54.44,111.15 58.45,107.14 59.69,107.14 61.76,105.07 65.09,105.07 65.44,105.43 66.19,105.43 v6(66.35,105.58)
FBB_D11: length 27.3
  TOP w0.165: v1(43.75,118.56) M43.T13 ; G1.F36 v6(64.25,105.58)
  L8_IN3 w0.135: v6(64.25,105.58) 64.25,105.6 63.88,105.96 63.88,106.64 63.64,106.88 61.56,106.88 60.85,107.59 58.84,107.59 54.56,111.87 51.86,111.87 45.58,118.16 44.15,118.16 v1(43.75,118.56)
FBB_D12: length 30.5
  TOP w0.165: v6(64.35,103.58) G1.F33 ; M43.N11 v1(41.35,116.96)
  L8_IN3 w0.102: v6(64.35,103.58) 64.11,103.34 63.27,103.34 63.02,103.1 61.86,103.1 61.78,103.17 61.66,103.17
  L8_IN3 w0.135: v1(41.35,116.96) 41.35,116.76 41.75,116.36 41.75,115.86 43.02,114.59 44.43,114.59 50.39,108.63 54.34,108.63 54.35,108.63 57.56,105.42 59.41,105.42 61.66,103.17
FBB_D13: length 29.5
  TOP w0.165: M43.N13 v1(41.35,118.56) ; v6(62.25,103.48) G1.D33
  L8_IN3 w0.135: v1(41.35,118.56) 41.75,118.16 41.75,116.78 41.97,116.56 42.37,116.56 42.55,116.38 42.55,115.97 43.31,115.21 44.79,115.21 50.52,109.49 54.35,109.49 57.84,106 59.52,106 61.23,104.29 61.95,104.29 62.25,103.99 v6(62.25,103.48)
FBB_D14: length 34.5
  TOP w0.165: G1.J32 v6(66.35,102.18) ; M43.M11 v1(40.55,116.96)
  L8_IN3 w0.102: v6(66.35,102.18) 65.62,102.91 63.48,102.91 63.2,102.63 61.28,102.63
  L8_IN3 w0.135: v1(40.55,116.96) M43.M11 40.15,115.65 42.73,113.08 43.69,113.08 49.46,107.31 54.1,107.31 54.35,107.06 57.31,104.1 59.82,104.1 61.28,102.63
FBB_D15: length 33.5
  TOP w0.165: v1(40.55,118.56) M43.M13 ; v6(64.95,103.48) G1.G33
  L8_IN3 w0.102: 61.54,102.88 63.12,102.88 63.36,103.12 64.59,103.12 v6(64.95,103.48)
  L8_IN3 w0.135: 61.54,102.88 59.62,104.79 57.43,104.79 54.24,107.98 49.8,107.98 46.48,111.3 44.05,113.73 42.97,113.73 40.95,115.75 40.95,118.16 v1(40.55,118.56)
FBB_D16: length 48.8
  TOP w0.165: M43.A11 v1(30.95,116.16) ; v6(62.95,111.88) G1.E45
  L8_IN3 w0.135: v6(62.95,111.88) 62.45,112.38 62.05,112.38 61.85,112.58 60.67,112.58 58.68,114.57 58.68,115.46 54.21,119.93 53.28,119.93 47.35,125.86 33.73,125.86 29.64,121.77 29.64,116.82 30.3,116.16 v1(30.95,116.16)
FBB_D17: length 44.4
  TOP w0.165: M43.A13 v1(30.95,117.76) ; G1.D45 v6(62.25,111.88)
  L8_IN3 w0.135: v6(62.25,111.88) 62.1,111.73 60.8,111.73 58.06,114.47 58.06,115.15 53.99,119.22 52.95,119.22 47.05,125.12 33.99,125.12 30.29,121.42 30.29,118.42 v1(30.95,117.76)
FBB_D18: length 47.6
  TOP w0.165: M43.B11 v1(31.75,116.16) ; v6(64.24,111.88) G1.F45
  L8_IN3 w0.135: v1(31.75,116.16) 31.35,116.57 31.35,117.59 31.35,117.59 31.35,117.92 31.35,117.92 31.35,118.24 30.82,118.77 30.82,121.22 34.38,124.78 46.43,124.78 52.71,118.5 53.92,118.5 57.26,115.16 57.26,114.48 60.47,111.27 63.67,111.27 64.24,111.85 v6(64.24,111.88)
FBB_D19: length 43.9
  TOP w0.165: M43.B13 v1(31.75,118.56) ; v6(65.12,111.5) 65.04,111.58 G1.G45
  L8_IN3 w0.135: v6(65.12,111.5) 65.1,111.52 64.69,111.52 64.17,111.01 60.24,111.01 56.85,114.4 56.85,114.65 53.78,117.72 52.6,117.72 46.7,123.62 45.36,123.62 45.33,123.59 44.98,123.59 44.94,123.62 35.07,123.62 35.06,123.62 34.71,123.62 34.71,123.62 34.54,123.62 31.52,120.6 31.3,120.38 31.3,119.01 v1(31.75,118.56)
FBB_D20: length 38.4
  TOP w0.165: G1.D42 v6(62.25,109.78) ; M43.E11 v1(34.15,116.96)
  L8_IN3 w0.135: v6(62.25,109.78) 62.06,109.59 61.52,109.59 61.16,109.95 59.67,109.95 54.35,115.27 53.27,116.35 52.13,116.35 46.25,122.23 38.31,122.23 37.81,121.73 35.85,121.73 34.55,120.43 34.55,117.36 v1(34.15,116.96)
FBB_D21: length 40.4
  TOP w0.165: M43.E13 v1(34.15,118.56) ; v6(62.95,109.78) G1.E42
  L8_IN3 w0.135: v6(62.95,109.78) 62.23,110.5 60.02,110.5 54.35,116.17 53.54,116.98 52.38,116.98 46.15,123.22 35.84,123.22 32.96,120.34 32.96,119.17 33.17,118.96 33.75,118.96 v1(34.15,118.56)
FBB_D22: length 39
  TOP w0.165: v1(34.95,116.96) M43.F11 ; G1.F42 v6(64.25,109.78)
  L8_IN3 w0.135: v1(34.95,116.96) 35.35,117.36 35.35,119.68 35.7,120.03 35.7,120.34 36.76,121.4 46.12,121.4 51.24,116.28 51.71,115.81 52.9,115.81 59.51,109.2 63.67,109.2 v6(64.25,109.78)
FBB_D23: length 37.2
  TOP w0.165: M43.F13 v1(35.75,118.56)
  TOP w0.17: G1.H41 v6(65.65,108.48)
  L8_IN3 w0.135: v1(35.75,118.56) 36.25,119.06 36.25,119.97 36.53,120.25 45.69,120.25 51.72,114.22 53.75,114.22 54.35,113.62 59.36,108.61 62.21,108.61 62.5,108.9 65.23,108.9 v6(65.65,108.48)
FBB_D24: length 39.5
  TOP w0.165: G1.E41 v6(62.95,108.48) ; M43.A4 v1(31.75,110.56)
  L3_IN1 w0.135: v1(31.75,110.56) 30.93,111.38 30.93,113.08 31.99,114.13 37.65,114.13 38.7,115.18 47.49,115.18 50.76,111.91 56.83,111.91 60.12,108.62 62.82,108.62 62.95,108.49 v6(62.95,108.48)
FBB_D25: length 43.4
  TOP w0.165: v1(30.95,109.76) M43.A2 ; G1.F39 v6(64.25,107.68)
  L3_IN1 w0.135: v1(30.95,109.76) 30.46,110.25 30.46,110.74 30.56,110.84 30.56,113.68 31.72,114.84 32.68,114.84 33.55,115.71 47.7,115.71 50.74,112.66 56.85,112.66 60.59,108.93 63.68,108.93 63.92,108.69 63.92,108.22 64.25,107.89 v6(64.25,107.68)
FBB_D26: length 37.9
  TOP w0.165: M43.B4 v1(31.75,111.36) ; v6(62.95,107.68) G1.E39
  L3_IN1 w0.135: v6(62.95,107.68) 62.3,108.33 59.73,108.33 56.98,111.08 50.78,111.08 47.09,114.78 39.01,114.78 37.82,113.59 32.26,113.59 31.3,112.63 31.3,111.81 v1(31.75,111.36)
FBB_D27: length 37.4
  TOP w0.165: G1.D39 v6(62.25,107.68) ; v1(31.75,109.76) M43.B2
  L3_IN1 w0.135: v6(62.25,107.68) 62.1,107.53 59.88,107.53 56.96,110.45 50.68,110.45 46.92,114.21 39.14,114.21 38.16,113.23 33.03,113.23 32.15,112.35 32.15,110.16 v1(31.75,109.76)
FBB_D28: length 36.2
  TOP w0.165: v1(34.95,110.56) M43.E4
  TOP w0.17: v6(63.49,106.22) G1.F38
  L3_IN1 w0.135: v6(63.49,106.22) 63.52,106.26 63.52,106.7 63.13,107.09 61.66,107.09 61.45,106.88 59.92,106.88 56.78,110.02 50.39,110.02 46.89,113.52 39.07,113.52 38.22,112.67 34.76,112.67 34.62,112.53 34.55,112.46 M43.E4 v1(34.95,110.56)
FBB_D29: length 34.3
  TOP w0.165: v6(62.93,106.32) 63.25,106.64 G1.E38 ; v1(34.95,109.76) M43.E2
  L3_IN1 w0.135: v1(34.95,109.76) 35.35,110.16 35.35,111.58 35.55,111.78 36.1,111.78 36.47,112.15 38.39,112.15 39.17,112.94 46.78,112.94 50.35,109.37 56.84,109.37 59.95,106.27 61.49,106.27 61.96,106.75 62.5,106.75 v6(62.93,106.32)
FBB_D30: length 30.9
  TOP w0.165: M43.F4 v1(35.75,111.36) ; G1.D36 v6(62.25,105.58)
  L3_IN1 w0.135: v1(35.75,111.36) 36.28,111.36 36.68,111.75 38.74,111.75 39.48,112.49 46.49,112.49 50.28,108.7 56.91,108.7 60.13,105.48 61.43,105.48 61.48,105.43 61.8,105.43 61.84,105.48 62.14,105.48 v6(62.25,105.58)
FBB_D31: length 32.5
  TOP w0.165: v6(62.95,105.58) G1.E36 ; M43.F2 v1(35.75,109.76)
  L3_IN1 w0.135: v1(35.75,109.76) 36.15,110.16 36.15,110.78 36.58,111.21 38.84,111.21 39.48,111.85 46.39,111.85 50.11,108.13 56.83,108.13 60.01,104.95 62.32,104.95 v6(62.95,105.58)
FBB_D32: length 22.7
  TOP w0.11: G1.M50 68.15,115.31 68.5,115.66 68.5,115.98 68.77,116.25 68.77,118.08 v6(68.16,118.69)
  TOP w0.165: v1(57.9,132.43) 57.9,132.43 M44.A4
  L8_IN3 w0.135: v1(57.9,132.43) 57.9,130.96 67.67,121.19 67.67,119.18 v6(68.16,118.69)
FBB_D33: length 23.7
  TOP w0.165: G1.P48 69.3,113.93 v6(69.15,113.93) ; v1(59.5,132.43) 59.5,132.43 M44.A2
  L8_IN3 w0.135: v1(59.5,132.43) 59.5,131.78 59.75,131.53 59.75,130.52 69.12,121.15 69.12,116.05 69.31,115.86 69.31,114.09 v6(69.15,113.93)
FBB_D34: length 23.4
  TOP w0.11: G1.M51 68.15,115.98 68.54,116.37 68.54,117.09 68.14,117.49 v6(68.14,117.55)
  TOP w0.165: v1(57.9,133.23) 57.9,133.23 M44.B4
  L8_IN3 w0.135: v1(57.9,133.23) 57.35,132.68 57.35,129.11 64.72,121.73 65.25,121.73 67.1,119.89 67.1,118.59 v6(68.14,117.55)
FBB_D35: length 23.9
  TOP w0.165: v1(58.7,133.23) M44.B2 ; G1.M49 v6(68.55,114.79)
  L8_IN3 w0.135: v6(68.55,114.79) 68.32,115.02 68.32,116.05 68.6,116.33 68.6,119.48 68.2,119.88 68.2,121.4 59.1,130.5 59.1,132.83 v1(58.7,133.23)
FBB_D36: length 31.3
  TOP w0.165: M44.E4 v1(57.9,136.43) ; G1.P47 v6(69.25,113.28)
  L8_IN3 w0.135: v1(57.9,136.43) 58.3,136.03 60.59,136.03 61.42,135.2 61.42,132.24 69.22,124.43 69.22,122.67 70.64,121.26 70.64,116.67 69.61,115.65 69.61,113.65 v6(69.25,113.28)
FBB_D37: length 25.2
  TOP w0.11: v6(70.22,118.08) 70.05,118.08 69.55,117.57 G1.P52
  TOP w0.165: M44.E2 v1(59.5,135.63)
  L8_IN3 w0.135: v6(70.22,118.08) 70.06,118.08 69.55,118.59 69.55,121.46 60.63,130.38 60.63,131.75 60.83,131.95 60.83,134.93 60.53,135.23 59.9,135.23 v1(59.5,135.63)
FBB_D38: length 34.9
  TOP w0.165: M44.F4 v1(57.9,137.23) ; G1.R46 v6(70.55,111.98)
  L8_IN3 w0.135: v1(57.9,137.23) 58.4,137.73 60.45,137.73 60.8,137.38 61.21,137.38 63.3,135.29 63.3,132.44 70.6,125.13 70.6,122.64 71.18,122.07 71.18,120.51 71.35,120.34 71.35,116.35 70.12,115.13 70.12,112.4 v6(70.55,111.98)
FBB_D39: length 32
  TOP w0.165: v1(59.48,136.49) 59.13,136.83 M44.F2 ; v6(69.15,112.43) 69.4,112.43 G1.P46
  L8_IN3 w0.135: v6(69.15,112.43) 69.88,113.16 69.88,115.37 71.03,116.52 71.03,119.97 70.91,120.09 70.91,121.57 69.95,122.52 69.95,124.77 63.12,131.6 62.8,131.6 62.01,132.4 62.01,135.47 60.65,136.83 60.12,136.83 60.06,136.77 59.78,136.77 59.78,136.76 59.76,136.76 v1(59.48,136.49)
FBB_D40: length 28
  TOP w0.11: G1.L50 67.45,115.33 67.1,115.68 67.1,115.93 66.88,116.15 66.88,116.8 v6(66.55,117.13)
  TOP w0.165: M44.A11 v1(51.5,132.43)
  L3_IN1 w0.135: v1(51.5,132.43) 52.01,131.92 52.01,130.6 60.59,122.01 64.36,122.01 65.33,121.04 66.48,121.04 67.22,120.29 67.22,117.81 v6(66.55,117.13)
FBB_D41: length 27.9
  TOP w0.11: v6(66.5,117.73) 66.85,117.73 67.11,117.47 67.11,116.28 67.45,115.94 G1.L51
  TOP w0.165: M44.A13 v1(49.9,132.43)
  L3_IN1 w0.135: v1(49.9,132.43) 49.9,130.01 59.36,120.54 63.73,120.54 64.86,119.41 64.86,118.48 65.76,117.58 66.35,117.58 v6(66.5,117.73)
FBB_D42: length 27.9
  TOP w0.11: v6(66.6,118.29) 66.9,118.29 67.45,117.74 G1.L52
  TOP w0.165: v1(51.5,133.23) M44.B11
  L3_IN1 w0.135: v1(51.5,133.23) 51.1,132.83 51.1,131.86 51.23,131.73 51.23,130.26 59.94,121.54 64.1,121.54 65.13,120.51 66.44,120.51 66.97,119.98 66.97,118.67 v6(66.6,118.29)
FBB_D43: length 30.5
  TOP w0.1: G1.L49 67.8,114.73 67.8,116.63 67.7,116.73 67.7,118.42 66.6,119.52 v6(66.55,119.52)
  TOP w0.165: v1(49.9,133.23) M44.B13
  L3_IN1 w0.135: v6(66.55,119.52) 66.55,119.43 66.3,119.18 65.65,119.18 63.79,121.03 59.59,121.03 50.52,130.1 50.52,131.53 50.3,131.75 50.3,132.83 v1(49.9,133.23)
FBB_D44: length 37.8
  TOP w0.165: G1.M46 67.81,111.94 67.81,111.3 67.88,111.23 68.5,111.23 v6(68.57,111.16) ; v1(51.5,135.63) 51.66,135.8 51.66,135.8 M44.E11
  L3_IN1 w0.135: v6(68.57,111.16) 67.79,111.94 67.79,116.66 67.7,116.75 67.7,117.4 67.73,117.44 67.73,121.25 63.98,125.01 59.68,125.01 53.63,131.06 53.63,135.05 52.65,136.03 M44.E11 v1(51.5,135.63)
FBB_D45: length 35.6
  TOP w0.165: M44.E13 50.09,136.24 50.09,136.24 v1(49.9,136.43)
  TOP w0.17: G1.L47 v6(67.15,113.28)
  L3_IN1 w0.135: v6(67.15,113.28) 67.5,113.64 67.5,115.58 67.07,116.01 67.07,117.1 67.48,117.51 67.48,120.76 64.34,123.9 59.99,123.9 52.92,130.97 52.92,134.81 52.5,135.23 50.49,135.23 50.3,135.42 M44.E13 v1(49.9,136.43)
FBB_D46: length 34.6
  TOP w0.165: G1.M48 68.42,113.95 v6(68.56,113.95) ; M44.F11 v1(51.5,136.43)
  L3_IN1 w0.135: v6(68.56,113.95) 68.15,114.36 68.15,115.62 68.57,116.04 68.57,119.14 68.08,119.63 68.08,121.6 63.84,125.84 59.98,125.84 54.3,131.53 54.3,135.35 52.82,136.83 M44.F11 v1(51.5,136.43)
FBB_D47: length 39.3
  TOP w0.165: M44.F13 v1(49.9,137.23)
  TOP w0.17: v6(68.45,112.68) G1.M47
  L3_IN1 w0.135: v6(68.45,112.68) 68.83,112.68 69.01,112.86 69.48,112.86 69.77,113.15 69.77,115.8 69.28,116.3 69.28,119.38 68.8,119.86 68.8,121.49 63.44,126.85 59.86,126.85 55.01,131.7 55.01,135.59 52.97,137.63 50.3,137.63 v1(49.9,137.23)
FBB_D48: length 53.4
  TOP w0.165: M44.V11 51.64,145.89 v1(51.64,146.11) ; G1.D48 v6(62.85,113.38)
  L3_IN1 w0.135: v1(51.64,146.11) 51.5,146.25 51.5,146.48 51.29,146.69 51.29,147.05 50.3,148.04 46.43,148.04 44.03,145.64 44.03,128.36 54.35,118.05 59.41,112.98 61.25,112.98 61.65,113.38 v6(62.85,113.38)
FBB_D49: length 42.1
  TOP w0.165: v1(49.9,146.03) 49.91,146.03 50.3,145.64 M44.V13 ; G1.C50 v6(61.55,115.38)
  L3_IN1 w0.135: v6(61.55,115.38) 61.15,115.78 60.6,115.78 60.4,115.58 59.27,115.58 45.68,129.17 45.68,143.11 48.21,145.63 49.5,145.63 v1(49.9,146.03)
FBB_D50: length 50.1
  TOP w0.165: M44.T11 v1(51.5,145.23) ; G1.C48 v6(61.55,113.98)
  L3_IN1 w0.135: v6(61.55,113.98) 61.05,113.48 59.95,113.48 44.58,128.85 44.58,145.23 46.73,147.38 50.11,147.38 51.17,146.31 51.17,145.55 v1(51.5,145.23)
FBB_D51: length 46.5
  TOP w0.165: v1(49.9,145.23) M44.T13 ; G1.C49 v6(61.55,114.68)
  L3_IN1 w0.135: v6(61.55,114.68) 61.25,114.38 59.84,114.38 45.15,129.07 45.15,144.79 46.84,146.48 50.1,146.48 50.3,146.28 50.3,145.63 v1(49.9,145.23)
FBB_D52: length 42.7
  TOP w0.165: G1.E49 v6(62.95,114.08) ; M44.N11 v1(51.5,142.83)
  L3_IN1 w0.135: v6(62.95,114.08) 63.41,114.55 63.41,115.12 63.68,115.38 63.68,116.59 61.87,118.4 58.57,118.4 46.66,130.31 46.66,140.85 48.24,142.43 51.1,142.43 v1(51.5,142.83)
FBB_D53: length 43.5
  TOP w0.165: G1.E50 v6(62.95,115.38) ; v1(49.9,142.83) M44.N13
  L3_IN1 w0.135: v6(62.95,115.38) 63.43,115.86 63.43,116.21 63.15,116.49 61.73,116.49 60.69,117.52 58.12,117.52 46.17,129.47 46.17,141.96 48.09,143.87 48.25,144.03 50.1,144.03 50.3,143.83 50.3,143.23 v1(49.9,142.83)
FBB_D54: length 41.8
  TOP w0.165: G1.F49 v6(64.35,113.98) ; M44.M11 51.58,141.95 v1(51.5,142.03)
  L3_IN1 w0.135: v1(51.5,142.03) 51.1,141.63 50.5,141.63 50.3,141.43 50.3,140.93 50.15,140.78 48.7,140.78 48.23,140.31 48.23,130.21 59.06,119.38 62.28,119.38 63.41,118.25 63.95,118.25 65.46,116.74 65.46,114.7 65.14,114.38 64.75,114.38 v6(64.35,113.98)
FBB_D55: length 41
  TOP w0.165: M44.M13 v1(49.9,141.23) ; v6(64.25,113.38) G1.F48
  L3_IN1 w0.135: v6(64.25,113.38) G1.F48 63.95,115.41 64.41,115.87 64.41,117.26 63.8,117.87 63.36,117.87 62.37,118.86 58.82,118.86 47.2,130.48 47.2,140.04 48.79,141.63 49.5,141.63 v1(49.9,141.23)
FBB_D56: length 40
  TOP w0.165: G1.F50 64.25,114.78 v6(64.35,114.78) ; v1(57.1,145.23) 57.31,145.44 M44.V4
  L8_IN3 w0.135: v6(64.35,114.78) 64.25,114.78 63.51,115.52 63.51,116.12 62.7,116.93 62.7,117.69 62.02,118.36 61.41,118.36 53.34,126.43 53.34,137.86 52.65,138.56 52.65,139.37 54.06,140.78 54.06,143.91 55.79,145.64 56.69,145.64 v1(57.1,145.23)
FBB_D57: length 40.2
  TOP w0.165: G1.D52 62.58,116.51 62.58,117.1 62.1,117.58 v6(62.09,117.58) ; M44.V2 v1(58.7,145.23)
  L8_IN3 w0.135: v1(58.7,145.23) 57.54,146.39 55.67,146.39 53.59,144.32 53.59,141.03 52.08,139.52 52.08,138.31 52.84,137.56 52.84,126.17 54.84,124.17 61.2,117.8 61.87,117.8 v6(62.09,117.58)
FBB_D58: length 36.3
  TOP w0.165: M44.T4 57.5,144.83 v1(57.1,144.43) ; G1.J50 v6(66.35,115.38)
  L8_IN3 w0.135: v1(57.1,144.43) 56.7,144.03 56.1,144.03 55.17,143.1 55.17,140.16 54.58,139.58 54.58,127.07 63.8,117.86 63.87,117.86 v6(66.35,115.38)
FBB_D59: length 41.6
  TOP w0.165: G1.H48 v6(65.05,113.98) ; M44.T2 v1(59.5,145.23)
  L8_IN3 w0.135: v1(59.5,145.23) M44.T2 56,144.83 54.62,143.46 54.62,140.57 53.97,139.92 53.97,126.62 61.53,119.06 61.97,119.06 63.44,117.6 63.44,116.95 64.16,116.23 64.3,116.23 65.4,115.13 65.4,114.33 v6(65.05,113.98)
FBB_D60: length 34.4
  TOP w0.11: v6(64.43,118.55) 64.6,118.38 64.6,117.54 64.7,117.43 64.7,116.57 65.35,115.93 G1.H51
  TOP w0.165: v1(57.9,142.03) 57.77,142.16 M44.N4
  L8_IN3 w0.135: v6(64.43,118.55) 64.42,118.54 63.68,118.54 62.59,119.62 62.59,120.57 55.11,128.06 55.11,139.06 55.68,139.64 55.68,142.08 56.08,142.47 57.46,142.47 v1(57.9,142.03)
FBB_D61: length 33.9
  TOP w0.165: M44.N2 v1(58.7,142.03) ; G1.J51 v6(66.45,116.18)
  L8_IN3 w0.135: v6(66.45,116.18) 66.25,116.18 65.47,116.96 65.47,117.8 65.14,118.13 65.14,119.11 55.59,128.66 55.59,138.55 56.63,139.6 56.63,140.77 56.7,140.83 56.7,141.4 56.93,141.63 58.6,141.63 58.7,141.73 v1(58.7,142.03)
FBB_D62: length 32.7
  TOP w0.11: G1.H49 65.7,114.73 65.7,116.73 65.44,116.99 65.44,118.29 v6(65.92,118.76)
  TOP w0.165: M44.M4 57.67,141.46 v1(57.9,141.23)
  L8_IN3 w0.135: v1(57.9,141.23) 57.9,141.08 57.15,140.33 57.15,138.94 56.12,137.91 56.12,128.78 65.5,119.4 65.5,119.18 v6(65.92,118.76)
FBB_D63: length 32.4
  TOP w0.11: G1.H52 65.11,116.72 65.11,118.75 65.95,119.59 v6(65.97,119.59)
  TOP w0.165: M44.M2 v1(59.5,142.03)
  L8_IN3 w0.135: v6(65.97,119.59) 65.92,119.64 65.92,119.75 56.65,129.02 56.65,137.43 57.65,138.43 58.95,138.43 59.1,138.58 59.1,141.63 v1(59.5,142.03)
FBB_DBI0: length 24
  TOP w0.1: v6(57.75,102.43) 58.13,102.05 ; 61.52,102.15 61.02,102.15 60.81,101.95 ; 59.57,101.85 60.25,101.85 60.35,101.95
  TOP w0.102: 58.13,102.05 59.37,102.05 59.57,101.85 ; 61.52,102.15 G1.C32 ; 60.35,101.95 60.81,101.95
  TOP w0.165: M43.P2 v1(42.15,108.96)
  L6_IN2 w0.14: v1(42.15,108.96) 42.55,108.56 42.55,107.86 43.72,106.69 53.62,106.69 56.97,103.34 56.97,103.21 v6(57.75,102.43)
FBB_DBI1: length 29.8
  TOP w0.165: G1.E33 63.25,103.28 v6(62.95,103.58) ; M43.P13 v1(42.15,118.56)
  L6_IN2 w0.14: v1(42.15,118.56) 42.55,118.16 42.55,115.16 43.51,114.2 50.85,114.2 60.8,104.25 62.28,104.25 v6(62.95,103.58)
FBB_DBI2: length 39.2
  TOP w0.165: M43.D13 v1(33.35,118.56) ; G1.E44 v6(62.95,110.58)
  L6_IN2 w0.14: v6(62.95,110.58) 62.81,110.72 61.06,110.72 54.35,117.43 48.6,123.18 35.93,123.18 32.96,120.21 32.96,118.95 v1(33.35,118.56)
FBB_DBI3: length 51.1
  TOP w0.1: v6(64.47,108.31) 64.48,108.32 64.5,108.32 64.63,108.19 64.63,107.4 G1.G39
  TOP w0.165: v1(34.15,108.96) M43.D2
  L6_IN2 w0.14: v6(64.47,108.31) 63.42,109.36 61.02,109.36 47.89,122.49 38.7,122.49 37.53,121.32 35.72,121.32 34.92,120.51 34.55,120.15 34.55,115.91 34.15,115.51 34.15,114.31 33.06,113.22 33.06,111.21 32.95,111.1 32.95,109.56 33.16,109.35 33.76,109.35 v1(34.15,108.96)
FBB_DBI4: length 26.1
  TOP w0.11: G1.P49 69.9,114.73 69.9,116.63 69.8,116.73 69.8,117.06 70.2,117.46 v6(70.2,117.51)
  TOP w0.165: M44.D2 v1(58.7,134.83)
  L6_IN2 w0.14: v6(70.2,117.51) 70.2,117.53 68.67,119.06 68.67,121.05 65.75,123.96 65.75,124.52 59.1,131.18 59.1,134.43 v1(58.7,134.83)
FBB_DBI5: length 31.2
  TOP w0.127: v6(67.07,114.74) 67.1,114.72 67.1,114.29 67.45,113.94 G1.L48
  TOP w0.165: M44.D13 v1(49.9,134.83)
  L6_IN2 w0.14: v1(49.9,134.83) 50.3,134.43 52.48,134.43 52.91,133.99 52.91,129.26 64.06,118.11 64.66,118.11 65.54,117.23 65.54,116.94 65.89,116.59 66.6,116.59 67.32,115.87 67.32,115.05 67.07,114.81 v6(67.07,114.74)
FBB_DBI6: length 40.1
  TOP w0.165: M44.P13 v1(49.9,143.63) ; G1.D50 v6(62.85,114.78)
  L6_IN2 w0.14: v1(49.9,143.63) 49.5,143.23 48.27,143.23 47.44,142.4 47.44,140.67 46.86,140.09 46.86,130.81 60.26,117.4 60.79,117.4 61.68,116.51 63.09,116.51 63.42,116.18 63.42,115.26 62.94,114.78 v6(62.85,114.78)
FBB_DBI7: length 35
  TOP w0.11: v6(64.02,119.63) 64.02,117.7 64.35,117.37 64.35,116.58 65,115.93 65,115.43 G1.H50
  TOP w0.165: M44.P2 v1(59.5,142.83)
  L6_IN2 w0.14: v6(64.02,119.63) 64.02,120.24 55.34,128.92 55.34,138.78 57.5,140.94 57.5,142.24 57.69,142.43 59.1,142.43 v1(59.5,142.83)
FBB_DEBUG0: length 8.2
  TOP w0.102: G1.C35 61.5,104.23 61,104.23 60.74,103.97 57.15,103.97 56.76,103.58 v1(56.45,103.28)
  BOTTOM w0.102: v1(56.45,103.28) 56.46,103.41 v3(56.46,104.09)
  BOTTOM w0.125: R892.2 55.83,103.4 55.96,103.28 v1(56.45,103.28)
FBB_DEBUG1: length 5
  TOP w0.165: G1.B50 v6(60.85,115.38)
  BOTTOM w0.1: 57.32,115.53 v3(57.43,115.53) ; 57.32,115.53 60.7,115.53 v6(60.85,115.38) ; 57.32,115.53 57.28,115.53 56.42,115.53 R907.2
FBB_EDC0: length 22.5
  TOP w0.102: G1.B33 60.72,103.61 58.25,103.61 v6(58.09,103.45)
  TOP w0.165: v1(42.96,109.76) 42.56,109.36 M43.R2
  L6_IN2 w0.14: v6(58.09,103.45) 53.9,107.64 43.59,107.64 43.35,107.88 43.35,109.36 v1(42.96,109.76)
FBB_EDC1: length 28
  TOP w0.165: M43.R13 v1(42.95,117.76) ; G1.E35 v6(63.55,104.28)
  L6_IN2 w0.14: v6(63.55,104.28) 63.16,104.67 61.37,104.67 50.4,115.64 43.6,115.64 43.35,115.89 43.35,117.36 v1(42.95,117.76)
FBB_EDC2: length 45.3
  TOP w0.165: G1.G44 65.35,110.88 v6(65.54,110.69) ; M43.C13 v1(32.55,117.76)
  L6_IN2 w0.14: v6(65.54,110.69) 65.35,110.87 64.78,110.87 64.46,111.19 61.97,111.19 53.27,119.89 48.67,124.5 35.95,124.5 32.15,120.7 32.15,118.16 v1(32.55,117.76)
FBB_EDC3: length 49.2
  TOP w0.165: M43.C2 v1(33.35,109.76)
  TOP w0.17: v6(65.64,106.38) G1.H38
  L6_IN2 w0.076: v1(33.35,109.76) 33.76,110.16 34.37,110.16 34.55,110.34 34.55,110.76 34.75,110.96 36.07,110.96 36.29,111.18
  L6_IN2 w0.14: v6(65.64,106.38) 65.64,106.23 65.44,106.02 65.44,105.38 65.24,105.18 61.67,105.18 52.68,114.17 52.68,115.22 47.94,119.96 38.76,119.96 37.79,118.99 37.79,118.24 37.77,118.21 37.75,118.21 37.75,116.29 37.37,115.91 37.37,112.26 36.29,111.18
FBB_EDC4: length 25.2
  TOP w0.11: v6(70.22,119.26) 70.2,119.26 69.13,118.19 69.13,116.87 69.01,116.75 69.01,116.17 69.22,115.96 69.22,115.62 69.55,115.29 G1.P50
  TOP w0.165: v1(59.5,134.03) 59.5,134.03 M44.C2
  L6_IN2 w0.14: v6(70.22,119.26) 70.22,119.26 69.26,120.22 69.26,121.45 66.78,123.92 66.78,124.13 61.25,129.65 61.25,133.03 60.64,133.64 59.89,133.64 v1(59.5,134.03)
FBB_EDC5: length 27.7
  TOP w0.165: G1.J48 v6(66.35,113.98) ; M44.C13 v1(50.7,134.03)
  L6_IN2 w0.14: v1(50.7,134.03) 51.1,133.63 51.1,130.32 63.87,117.55 64.12,117.55 64.76,116.91 64.76,116.73 65.89,115.6 65.89,115.21 66.08,115.02 66.08,114.25 v6(66.35,113.98)
FBB_EDC6: length 42.4
  TOP w0.165: G1.D51 v6(62.25,116.08) ; M44.R13 v1(50.7,144.43)
  L6_IN2 w0.14: v1(50.7,144.43) 50.3,144.83 47.86,144.83 45.95,142.93 45.95,129.38 59.68,115.66 60.46,115.66 60.57,115.77 61.79,115.77 62.1,116.08 v6(62.25,116.08)
FBB_EDC7: length 35.1
  TOP w0.11: G1.F51 63.61,116.11 63.61,116.76 63.49,116.89 63.49,118.75 63.13,119.11 v6(63.13,119.7)
  TOP w0.165: M44.R2 58.91,143.84 v1(58.7,143.63)
  L6_IN2 w0.14: v1(58.7,143.63) 58.3,143.23 57.6,143.23 57.11,142.74 56.17,142.74 55.44,142.01 55.44,140.6 54.44,139.6 54.44,128.39 v6(63.13,119.7)
FBB_VREFC: length 33.9
  TOP w0.381: v1(45.15,124.01) 45.13,124.04 45.13,138.62 45.45,138.94 C955.2 48.62,138.94 48.91,139.23 M44.J14 ; v1(37.92,122.63) 37.97,122.58 R2713.1 37.24,122 R2716.1 36.04,122.33 R2712.2 C884.2 37.54,119.79 37.54,119.17 M43.J14
  L3_IN1 w0.381: v1(45.15,124.01) 44.31,123.18 38.46,123.18 v1(37.92,122.63)
FBB_WCK01_N: length 34.4
  TOP w0.127: G1.H33 65.35,102.96 65.43,102.87 65.6,102.87 65.71,102.97 65.71,103.42 v6(65.65,103.48) ; M43.P5 41.75,111.49 41.88,111.36 v1(42.15,111.36)
  L6_IN2 w0.094: v6(65.65,103.48) 65.8,103.33 65.88,103.25 65.88,102.91 65.8,102.83 61.42,102.83 60.27,103.99 59.24,103.99 50.24,112.98 49.25,112.98 49.15,113.07 49.15,113.26 48.95,113.46 48.6,113.46 48.39,113.26 48.39,113.07 48.3,112.98 48.11,112.98 48.02,113.07 48.02,113.26 47.81,113.46 47.47,113.46 47.26,113.26 47.26,113.07 47.17,112.98 46.98,112.98 46.89,113.07 46.89,113.26 46.68,113.46 46.33,113.46 46.13,113.26 46.13,113.07 46.03,112.98 45.85,112.98 45.75,113.07 45.75,113.26 45.55,113.46 45.2,113.46 45,113.26 45,113.07 44.9,112.98 44.71,112.98 44.62,113.07 44.62,113.26 44.41,113.46 44.07,113.46 43.86,113.26 43.86,113.07 43.77,112.98 43.69,112.98 42.15,111.44 v1(42.15,111.36)
FBB_WCK01_P: length 34.4
  TOP w0.127: v1(42.19,110.54) 42.19,110.52 41.76,110.96 M43.P4 ; G1.J33 v6(66.35,103.48)
  L6_IN2 w0.094: v1(42.19,110.54) 42.19,110.63 42.56,111.25 42.56,111.58 43.77,112.79 43.85,112.79 44.05,112.99 44.05,113.18 44.15,113.27 44.34,113.27 44.43,113.18 44.43,112.99 44.64,112.79 44.98,112.79 45.19,112.99 45.19,113.18 45.28,113.27 45.47,113.27 45.56,113.18 45.56,112.99 45.77,112.79 46.11,112.79 46.32,112.99 46.32,113.18 46.41,113.27 46.6,113.27 46.7,113.18 46.7,112.99 46.9,112.79 47.25,112.79 47.45,112.99 47.45,113.18 47.55,113.27 47.73,113.27 47.83,113.18 47.83,112.99 48.03,112.79 48.38,112.79 48.59,112.99 48.59,113.18 48.68,113.27 48.87,113.27 48.96,113.18 48.96,112.99 49.17,112.79 50.16,112.79 59.16,103.8 60.19,103.8 60.4,103.58 61.34,102.64 65.88,102.64 66.07,102.83 66.07,103.2 66.24,103.38 v6(66.35,103.48)
FBB_WCK23_N: length 47.5
  TOP w0.127: v6(65.65,107.68) 65.7,107.63 65.7,107.15 65.62,107.07 65.44,107.07 65.35,107.16 G1.H39 ; v1(34.14,112.15) M43.D5
  L6_IN2 w0.094: v6(65.65,107.68) 65.67,107.71 65.83,107.71 65.94,107.59 65.94,107.3 65.84,107.2 61.56,107.2 61.13,107.63 61.13,108.08 47.44,121.77 38.64,121.77 37.58,120.71 37.58,119.91 36.46,118.79 36.46,114.87 34.34,112.75 34.34,112.35 v1(34.14,112.15)
FBB_WCK23_P: length 47.5
  TOP w0.127: v1(34.14,111.35) M43.D4 ; G1.J39 v6(66.35,107.68)
  L6_IN2 w0.094: v1(34.14,111.35) 34.14,111.58 34.53,111.97 34.53,112.67 36.65,114.79 36.65,118.71 37.77,119.83 37.77,120.63 38.71,121.58 47.36,121.58 60.94,108 60.94,107.55 61.48,107.01 65.92,107.01 66.13,107.22 66.13,107.55 66.26,107.68 v6(66.35,107.68)
FBB_WCK45_N: length 34.8
  TOP w0.127: v1(57.1,135.63) 56.66,135.63 56.59,135.56 56.59,135.34 M44.D5 ; G1.L45 v6(67.15,111.28)
  L6_IN2 w0.094: v6(67.15,111.28) 67.15,111.44 67.58,111.87 67.58,112.14 67.9,112.45 67.9,116.52 67.41,117 67.41,121.06 66.54,121.93 63.92,121.93 62.17,123.68 62.17,126.92 60.18,128.92 57.39,128.92 56.38,129.93 56.38,135.62 56.59,135.84 56.89,135.84 v1(57.1,135.63)
FBB_WCK45_P: length 34.9
  TOP w0.127: G1.L46 v6(67.15,111.98) ; M44.D4 57.48,135.23 57.88,135.63 v1(57.9,135.63)
  L6_IN2 w0.094: v1(57.9,135.63) 57.5,136.03 56.51,136.03 56.19,135.7 56.19,129.85 57.31,128.73 60.1,128.73 61.98,126.85 61.98,123.6 63.84,121.74 66.46,121.74 67.22,120.98 67.22,116.92 67.71,116.44 67.71,112.53 67.15,111.98 v6(67.15,111.98)
FBB_WCK67_N: length 47.1
  TOP w0.127: v6(65.05,112.58) 65.09,112.62 65.49,112.62 65.59,112.52 65.59,112.36 65.51,112.28 G1.H46 ; v1(56.3,143.63) M44.P5
  L6_IN2 w0.094: v1(56.3,143.63) 56.1,143.83 55.44,143.83 54,142.39 54,140.85 53.52,140.37 50.48,140.37 49.63,139.52 49.13,139.52 48.36,138.76 48.36,130.82 60.62,118.57 62.04,118.57 62.96,117.65 62.96,117.53 63.9,116.58 64.08,116.58 65.65,115.01 65.65,113.6 65.35,113.3 65.35,112.88 v6(65.05,112.58)
FBB_WCK67_P: length 47.1
  TOP w0.127: M44.P4 57.25,143.48 v1(57.1,143.63) ; G1.H47 v6(64.95,113.38)
  L6_IN2 w0.094: v6(64.95,113.38) 65.16,113.38 65.46,113.68 65.46,114.93 64,116.39 63.82,116.39 62.77,117.45 62.77,117.57 61.97,118.37 60.54,118.37 48.17,130.74 48.17,138.84 49.05,139.71 49.55,139.71 50.41,140.56 53.44,140.56 53.81,140.93 53.81,142.47 55.36,144.02 56.42,144.02 v1(57.1,143.63)
FBB_ZQ0: length 3.2
  TOP w0.125: v1(37.36,118.59) 37.36,118.56 M43.J13
  BOTTOM w0.102: v1(37.36,118.59) 37.36,118.84 v3(37.92,119.41) 37.92,119.59 37.42,120.08 37.42,120.66 R2715.1
FBB_ZQ2: length 5.1
  TOP w0.125: M44.J13 v1(49.9,138.83)
  BOTTOM w0.102: R2731.1 46.35,139.4
  BOTTOM w0.117: 46.35,139.4 47.65,139.4 v3(48,139.04) 48.22,138.83 v1(49.9,138.83)
FBC_CLK0_N: length 39.2
  TOP w0.127: G1.F15 v6(64.4,91.03) ; M45.J11 v1(38.15,81.96)
  L3_IN1 w0.109: v6(64.4,91.03) 64.1,90.74 61.85,90.74 61.6,90.98 55.37,90.98 51.87,87.48 50.01,87.48 49.24,86.7 48.49,86.7 48.26,86.47 48.26,85.91 48.14,85.79 47.95,85.79 47.83,85.91 47.83,86.47 47.6,86.7 47.21,86.7 46.98,86.47 46.98,85.53 46.86,85.41 46.67,85.41 46.55,85.53 46.55,86.47 46.32,86.7 40.54,86.7 40.31,86.47 40.31,86.05 40.17,85.91 v1(39.8,85.91) 40.23,85.48 40.23,85.25 39.96,84.97 39.28,84.97 37.75,83.45 37.75,82.36 v1(38.15,81.96)
  BOTTOM w0.127: v1(39.8,85.91) 40.14,85.91 40.33,86.1 40.33,86.67 40.29,86.72 R2742.2
