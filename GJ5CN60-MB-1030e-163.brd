# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C197D79
  round 5.004 hole 2.007: 1(0,0)
C236D158
  round 5.994 hole 4.013: 1(0,0)
C315D110
  round 8.001 hole 2.794: 1(0,0)
CAP_EEEFZ1E101P_6D3_L45
  rect 1.6x3.2 smd: 1(0,-2.5) 2(0,2.5)
CAP_EEEFZ1E101P_6D3_L60
  rect 1.6x3.2 smd: 1(0,-2.5) 2(0,2.5)
CHOKE-4D1_4D0_2D0
  rect 1.499x2.489 smd: 1(1.85,0) 2(-1.85,0)
CHOKE-4P_2X1_2X1_2
  rect 0.914x0.406 smd: 1(-0.85,0.4) 2(0.85,0.4) 3(0.85,-0.4) 4(-0.85,-0.4)
CHOKE-7D3_6D8_3
  rect 3.505x2.515 smd: 1(0,3.1) 2(0,-3.1)
CHOKE-7D3_8D3_5
  rect 3.505x2.515 smd: 1(0,3.1) 2(0,-3.1)
CHOKE_3X3_1D5
  rect 1.016x2.718 smd: 1(-1.1,0) 2(1.1,0)
CHOKE_3X3_1D7
  rect 2.692x1.194 smd: 1(0,-1.2) 2(0,1.2)
CHOKE_7D6X6D8_4
  rect 2.5x3.5 smd: 1(-3.1,0) 2(3.1,0)
CON_DCIN_WO_2DC3003-002211_SIN
  round 2.108 hole 1.397: 1(-8.58,5.08)
  oval 1.397x2.21 hole 0.711x1.499: 2(-5.78,5.08) 3(-3.33,5.08)
  oval 1.803x2.896 hole 0.991x2.108: 4(-0.63,14.93) 5(-14.03,14.93)
CON_FFC_6R05-AFC34-S06FCA_HF
  rect 0.3x1 smd: 1(1.25,0) 2(0.75,0) 3(0.25,0) 4(-0.25,0) 5(-0.75,0) 6(-1.25,0)
  rect 1.35x1.8 smd: S1(3.255,-1.8) S2(-3.255,-1.8)
CON_FFC_6R100_51524-00601_ACES
  rect 0.6x1.3 smd: 1(-2.5,0) 2(-1.5,0) 3(-0.5,0) 4(0.5,0) 5(1.5,0) 6(2.5,0)
  rect 2.5x2.2 smd: S1(-5.325,-3.05) S2(5.325,-3.05)
CON_FFC_10R05_6712K-V10N07L_ENT
  rect 0.305x1.295 smd: 1(2.25,2.15) 2(1.75,2.15) 3(1.25,2.15) 4(0.75,2.15) 5(0.25,2.15) 6(-0.25,2.15) 7(-0.75,2.15) 8(-1.25,2.15) 9(-1.75,2.15) 10(-2.25,2.15)
  rect 1.803x1.397 smd: S1(3.9,-0.5) S2(-3.9,-0.5)
CON_FFC_18B05_51625-01801_ACES
  rect 0.305x0.864 smd: 1(-4.25,0) 2(-3.75,0) 3(-3.25,0) 4(-2.75,0) 5(-2.25,0) 6(-1.75,0) 7(-1.25,0) 8(-0.75,0) 9(-0.25,0) 10(0.25,0) 11(0.75,0) 12(1.25,0) 13(1.75,0) 14(2.25,0) 15(2.75,0) 16(3.25,0) 17(3.75,0) 18(4.25,0)
  rect 0.991x1.499 smd: S1(-6.04,-3.555) S2(6.04,-3.555)
CON_FFC_40R05-51517_ACES
  rect 0.3x1.3 smd: 1(-9.75,5.3) 2(-9.25,5.3) 3(-8.75,5.3) 4(-8.25,5.3) 5(-7.75,5.3) 6(-7.25,5.3) 7(-6.75,5.3) 8(-6.25,5.3) 9(-5.75,5.3) 10(-5.25,5.3) 11(-4.75,5.3) 12(-4.25,5.3) 13(-3.75,5.3) 14(-3.25,5.3) 15(-2.75,5.3) 16(-2.25,5.3) 17(-1.75,5.3) 18(-1.25,5.3) 19(-0.75,5.3) 20(-0.25,5.3) 21(0.25,5.3) 22(0.75,5.3) 23(1.25,5.3) 24(1.75,5.3) 25(2.25,5.3) 26(2.75,5.3) 27(3.25,5.3) 28(3.75,5.3) 29(4.25,5.3) 30(4.75,5.3) 31(5.25,5.3) 32(5.75,5.3) 33(6.25,5.3) 34(6.75,5.3) 35(7.25,5.3) 36(7.75,5.3) 37(8.25,5.3) 38(8.75,5.3) 39(9.25,5.3) 40(9.75,5.3)
  rect 1.8x2.2 smd: S1(-11.85,-0.35) S2(11.85,-0.35)
CON_FFC_40TB05_6718K_Y40N_ENT
  rect 0.3x0.8 smd: 1(9.75,2.5) 2(9.25,2.5) 3(8.75,2.5) 4(8.25,2.5) 5(7.75,2.5) 6(7.25,2.5) 7(6.75,2.5) 8(6.25,2.5) 9(5.75,2.5) 10(5.25,2.5) 11(4.75,2.5) 12(4.25,2.5) 13(3.75,2.5) 14(3.25,2.5) 15(2.75,2.5) 16(2.25,2.5) 17(1.75,2.5) 18(1.25,2.5) 19(0.75,2.5) 20(0.25,2.5) 21(-0.25,2.5) 22(-0.75,2.5) 23(-1.25,2.5) 24(-1.75,2.5) 25(-2.25,2.5) 26(-2.75,2.5) 27(-3.25,2.5) 28(-3.75,2.5) 29(-4.25,2.5) 30(-4.75,2.5) 31(-5.25,2.5) 32(-5.75,2.5) 33(-6.25,2.5) 34(-6.75,2.5) 35(-7.25,2.5) 36(-7.75,2.5) 37(-8.25,2.5) 38(-8.75,2.5) 39(-9.25,2.5) 40(-9.75,2.5)
  rect 0.4x0.8 smd: S1(-10.75,0) S2(10.75,0)
CON_FFC_50B05_FP225H050S10M_JXT
  rect 0.3x1 smd: 1(-12.25,0) 2(-11.75,0) 3(-11.25,0) 4(-10.75,0) 5(-10.25,0) 6(-9.75,0) 7(-9.25,0) 8(-8.75,0) 9(-8.25,0) 10(-7.75,0) 11(-7.25,0) 12(-6.75,0) 13(-6.25,0) 14(-5.75,0) 15(-5.25,0) 16(-4.75,0) 17(-4.25,0) 18(-3.75,0) 19(-3.25,0) 20(-2.75,0) 21(-2.25,0) 22(-1.75,0) 23(-1.25,0) 24(-0.75,0) 25(-0.25,0) 26(0.25,0) 27(0.75,0) 28(1.25,0) 29(1.75,0) 30(2.25,0) 31(2.75,0) 32(3.25,0) 33(3.75,0) 34(4.25,0) 35(4.75,0) 36(5.25,0) 37(5.75,0) 38(6.25,0) 39(6.75,0) 40(7.25,0) 41(7.75,0) 42(8.25,0) 43(8.75,0) 44(9.25,0) 45(9.75,0) 46(10.25,0) 47(10.75,0) 48(11.25,0) 49(11.75,0) 50(12.25,0)
  rect 1x2 smd: S1(-14.35,-3.1) S2(14.35,-3.1)
CON_HDMI-A-R_HAR01-191CN5V_HT
  round 0.762 hole 0.508: 1(-4.5,-1.725) 2(-4,-0.175) 3(-3.5,-1.725) 4(-3,-0.175) 5(-2.5,-1.725) 6(-2,-0.175) 7(-1.5,-1.725) 8(-1,-0.175) 9(-0.5,-1.725) 10(0,-0.175) 11(0.5,-1.725) 12(1,-0.175) 13(1.5,-1.725) 14(2,-0.175) 15(2.5,-1.725) 16(3,-0.175) 17(3.5,-1.725) 18(4,-0.175) 19(4.5,-1.725)
  oval 1.829x3.048 hole 0.787x2.108: H1(9.15,0) H2(-9.15,0) H3(9.15,-7.1) H4(-9.15,-7.1)
CON_M2-E-S67_AS0BC21-S48BE_FOX
  round 1.118 hole 1.118 unplated: (-10,-1.5)
  round 1.626 hole 1.626 unplated: (10,-1.5)
  rect 0.305x1.575 smd: 1(-9.25,3.775) 2(-9,-3.775) 3(-8.75,3.775) 4(-8.5,-3.775) 5(-8.25,3.775) 6(-8,-3.775) 7(-7.75,3.775) 8(-7.5,-3.775) 9(-7.25,3.775) 10(-7,-3.775) 11(-6.75,3.775) 12(-6.5,-3.775) 13(-6.25,3.775) 14(-6,-3.775) 15(-5.75,3.775) 16(-5.5,-3.775) 17(-5.25,3.775) 18(-5,-3.775) 19(-4.75,3.775) 20(-4.5,-3.775) 21(-4.25,3.775) 22(-4,-3.775) 23(-3.75,3.775) 32(-1.5,-3.775) 33(-1.25,3.775) 34(-1,-3.775) 35(-0.75,3.775) 36(-0.5,-3.775) 37(-0.25,3.775) 38(0,-3.775) 39(0.25,3.775) 40(0.5,-3.775) 41(0.75,3.775) 42(1,-3.775) 43(1.25,3.775) 44(1.5,-3.775) 45(1.75,3.775) 46(2,-3.775) 47(2.25,3.775) 48(2.5,-3.775) 49(2.75,3.775) 50(3,-3.775) 51(3.25,3.775) 52(3.5,-3.775) 53(3.75,3.775) 54(4,-3.775) 55(4.25,3.775) 56(4.5,-3.775) 57(4.75,3.775) 58(5,-3.775) 59(5.25,3.775) 60(5.5,-3.775) 61(5.75,3.775) 62(6,-3.775) 63(6.25,3.775) 64(6.5,-3.775) 65(6.75,3.775) 66(7,-3.775) 67(7.25,3.775) 68(7.5,-3.775) 69(7.75,3.775) 70(8,-3.775) 71(8.25,3.775) 72(8.5,-3.775) 73(8.75,3.775) 74(9,-3.775) 75(9.25,3.775)
  rect 1.219x2.743 smd: 76(10.35,3) 77(-10.35,3)
CON_M2_M_S67_NXSM0-S67XX_ARG
  round 1.1 hole 1.1 unplated: (-10,-1.512)
  round 1.6 hole 1.6 unplated: (10,-1.512)
  rect 0.3x1.55 smd: 1(-9.25,3.763) 2(-9,-3.787) 3(-8.75,3.763) 4(-8.5,-3.787) 5(-8.25,3.763) 6(-8,-3.787) 7(-7.75,3.763) 8(-7.5,-3.787) 9(-7.25,3.763) 10(-7,-3.787) 11(-6.75,3.763) 12(-6.5,-3.787) 13(-6.25,3.763) 14(-6,-3.787) 15(-5.75,3.763) 16(-5.5,-3.787) 17(-5.25,3.763) 18(-5,-3.787) 19(-4.75,3.763) 20(-4.5,-3.787) 21(-4.25,3.763) 22(-4,-3.787) 23(-3.75,3.763) 24(-3.5,-3.787) 25(-3.25,3.763) 26(-3,-3.787) 27(-2.75,3.763) 28(-2.5,-3.787) 29(-2.25,3.763) 30(-2,-3.787) 31(-1.75,3.763) 32(-1.5,-3.787) 33(-1.25,3.763) 34(-1,-3.787) 35(-0.75,3.763) 36(-0.5,-3.787) 37(-0.25,3.763) 38(0,-3.787) 39(0.25,3.763) 40(0.5,-3.787) 41(0.75,3.763) 42(1,-3.787) 43(1.25,3.763) 44(1.5,-3.787) 45(1.75,3.763) 46(2,-3.787) 47(2.25,3.763) 48(2.5,-3.787) 49(2.75,3.763) 50(3,-3.787) 51(3.25,3.763) 52(3.5,-3.787) 53(3.75,3.763) 54(4,-3.787) 55(4.25,3.763) 56(4.5,-3.787) 57(4.75,3.763) 58(5,-3.787) 67(7.25,3.763) 68(7.5,-3.787) 69(7.75,3.763) 70(8,-3.787) 71(8.25,3.763) 72(8.5,-3.787) 73(8.75,3.763) 74(9,-3.787) 75(9.25,3.763)
  rect 1.2x2.75 smd: MTG76(-10.35,2.988) MTG77(10.35,2.988)
CON_RJ45_WO_130456-781_SANTA
  round 1.2 hole 0.9: 1(3.57,1.1) 2(2.55,0) 3(1.53,1.1) 4(0.51,0) 5(-0.51,1.1) 6(-1.53,0) 7(-2.55,1.1) 8(-3.57,0)
  oval 1.1x3 hole 0.5x2.4: GND1(-8.025,-6.4) GND2(8.025,-6.4)
CON_S-DDR4-S40_D4ASX-260-40_ARG
  round 1.092 hole 1.092 unplated: (-1.025,4.1)
  round 1.6 hole 1.6 unplated: (67.775,4.1)
  rect 0.305x1.753 smd: 1(66.75,8.2) 2(66.5,0) 3(66.25,8.2) 4(66,0) 5(65.75,8.2) 6(65.5,0) 7(65.25,8.2) 8(65,0) 9(64.75,8.2) 10(64.5,0) 11(64.25,8.2) 12(64,0) 13(63.75,8.2) 14(63.5,0) 15(63.25,8.2) 16(63,0) 17(62.75,8.2) 18(62.5,0) 19(62.25,8.2) 20(62,0) 21(61.75,8.2) 22(61.5,0) 23(61.25,8.2) 24(61,0) 25(60.75,8.2) 26(60.5,0) 27(60.25,8.2) 28(60,0) 29(59.75,8.2) 30(59.5,0) 31(59.25,8.2) 32(59,0) 33(58.75,8.2) 34(58.5,0) 35(58.25,8.2) 36(58,0) 37(57.75,8.2) 38(57.5,0) 39(57.25,8.2) 40(57,0) 41(56.75,8.2) 42(56.5,0) 43(56.25,8.2) 44(56,0) 45(55.75,8.2) 46(55.5,0) 47(55.25,8.2) 48(55,0) 49(54.75,8.2) 50(54.5,0) 51(54.25,8.2) 52(54,0) 53(53.75,8.2) 54(53.5,0) 55(53.25,8.2) 56(53,0) 57(52.75,8.2) 58(52.5,0) 59(52.25,8.2) 60(52,0) 61(51.75,8.2) 62(51.5,0) 63(51.25,8.2) 64(51,0) 65(50.75,8.2) 66(50.5,0) 67(50.25,8.2) 68(50,0) 69(49.75,8.2) 70(49.5,0) 71(49.25,8.2) 72(49,0) 73(48.75,8.2) 74(48.5,0) 75(48.25,8.2) 76(48,0) 77(47.75,8.2) 78(47.5,0) 79(47.25,8.2) 80(47,0) 81(46.75,8.2) 82(46.5,0) 83(46.25,8.2) 84(46,0) 85(45.75,8.2) 86(45.5,0) 87(45.25,8.2) 88(45,0) 89(44.75,8.2) 90(44.5,0) 91(44.25,8.2) 92(44,0) 93(43.75,8.2) 94(43.5,0) 95(43.25,8.2) 96(43,0) 97(42.75,8.2) 98(42.5,0) 99(42.25,8.2) 100(42,0) 101(41.75,8.2) 102(41.5,0) 103(41.25,8.2) 104(41,0) 105(40.75,8.2) 106(40.5,0) 107(40.25,8.2) 108(40,0) 109(39.75,8.2) 110(39.5,0) 111(39.25,8.2) 112(39,0) 113(38.75,8.2) 114(38.5,0) 115(38.25,8.2) 116(38,0) 117(37.75,8.2) 118(37.5,0) 119(37.25,8.2) 120(37,0) 121(36.75,8.2) 122(36.5,0) 123(36.25,8.2) 124(36,0) 125(35.75,8.2) 126(35.5,0) 127(35.25,8.2) 128(35,0) 129(34.75,8.2) 130(34.5,0) 131(34.25,8.2) 132(34,0) 133(33.75,8.2) 134(33.5,0) 135(33.25,8.2) 136(33,0) 137(32.75,8.2) 138(32.5,0) 139(32.25,8.2) 140(32,0) 141(31.75,8.2) 142(31.5,0) 143(31.25,8.2) 144(31,0) 145(28.75,8.2) 146(28.5,0) 147(28.25,8.2) 148(28,0) 149(27.75,8.2) 150(27.5,0) 151(27.25,8.2) 152(27,0) 153(26.75,8.2) 154(26.5,0) 155(26.25,8.2) 156(26,0) 157(25.75,8.2) 158(25.5,0) 159(25.25,8.2) 160(25,0) 161(24.75,8.2) 162(24.5,0) 163(24.25,8.2) 164(24,0) 165(23.75,8.2) 166(23.5,0) 167(23.25,8.2) 168(23,0) 169(22.75,8.2) 170(22.5,0) 171(22.25,8.2) 172(22,0) 173(21.75,8.2) 174(21.5,0) 175(21.25,8.2) 176(21,0) 177(20.75,8.2) 178(20.5,0) 179(20.25,8.2) 180(20,0) 181(19.75,8.2) 182(19.5,0) 183(19.25,8.2) 184(19,0) 185(18.75,8.2) 186(18.5,0) 187(18.25,8.2) 188(18,0) 189(17.75,8.2) 190(17.5,0) 191(17.25,8.2) 192(17,0) 193(16.75,8.2) 194(16.5,0) 195(16.25,8.2) 196(16,0) 197(15.75,8.2) 198(15.5,0) 199(15.25,8.2) 200(15,0) 201(14.75,8.2) 202(14.5,0) 203(14.25,8.2) 204(14,0) 205(13.75,8.2) 206(13.5,0) 207(13.25,8.2) 208(13,0) 209(12.75,8.2) 210(12.5,0) 211(12.25,8.2) 212(12,0) 213(11.75,8.2) 214(11.5,0) 215(11.25,8.2) 216(11,0) 217(10.75,8.2) 218(10.5,0) 219(10.25,8.2) 220(10,0) 221(9.75,8.2) 222(9.5,0) 223(9.25,8.2) 224(9,0) 225(8.75,8.2) 226(8.5,0) 227(8.25,8.2) 228(8,0) 229(7.75,8.2) 230(7.5,0) 231(7.25,8.2) 232(7,0) 233(6.75,8.2) 234(6.5,0) 235(6.25,8.2) 236(6,0) 237(5.75,8.2) 238(5.5,0) 239(5.25,8.2) 240(5,0) 241(4.75,8.2) 242(4.5,0) 243(4.25,8.2) 244(4,0) 245(3.75,8.2) 246(3.5,0) 247(3.25,8.2) 248(3,0) 249(2.75,8.2) 250(2.5,0) 251(2.25,8.2) 252(2,0) 253(1.75,8.2) 254(1.5,0) 255(1.25,8.2) 256(1,0) 257(0.75,8.2) 258(0.5,0) 259(0.25,8.2) 260(0,0)
  rect 3.505x4.597 smd: 261(-0.425,-7.9) 262(67.175,-7.9)
CON_S-DDR4-S80_D4ASX-260-80_ARG
  round 1.092 hole 1.092 unplated: (-1.025,4.1)
  round 1.6 hole 1.6 unplated: (67.775,4.1)
  rect 0.305x1.753 smd: 1(66.75,8.2) 2(66.5,0) 3(66.25,8.2) 4(66,0) 5(65.75,8.2) 6(65.5,0) 7(65.25,8.2) 8(65,0) 9(64.75,8.2) 10(64.5,0) 11(64.25,8.2) 12(64,0) 13(63.75,8.2) 14(63.5,0) 15(63.25,8.2) 16(63,0) 17(62.75,8.2) 18(62.5,0) 19(62.25,8.2) 20(62,0) 21(61.75,8.2) 22(61.5,0) 23(61.25,8.2) 24(61,0) 25(60.75,8.2) 26(60.5,0) 27(60.25,8.2) 28(60,0) 29(59.75,8.2) 30(59.5,0) 31(59.25,8.2) 32(59,0) 33(58.75,8.2) 34(58.5,0) 35(58.25,8.2) 36(58,0) 37(57.75,8.2) 38(57.5,0) 39(57.25,8.2) 40(57,0) 41(56.75,8.2) 42(56.5,0) 43(56.25,8.2) 44(56,0) 45(55.75,8.2) 46(55.5,0) 47(55.25,8.2) 48(55,0) 49(54.75,8.2) 50(54.5,0) 51(54.25,8.2) 52(54,0) 53(53.75,8.2) 54(53.5,0) 55(53.25,8.2) 56(53,0) 57(52.75,8.2) 58(52.5,0) 59(52.25,8.2) 60(52,0) 61(51.75,8.2) 62(51.5,0) 63(51.25,8.2) 64(51,0) 65(50.75,8.2) 66(50.5,0) 67(50.25,8.2) 68(50,0) 69(49.75,8.2) 70(49.5,0) 71(49.25,8.2) 72(49,0) 73(48.75,8.2) 74(48.5,0) 75(48.25,8.2) 76(48,0) 77(47.75,8.2) 78(47.5,0) 79(47.25,8.2) 80(47,0) 81(46.75,8.2) 82(46.5,0) 83(46.25,8.2) 84(46,0) 85(45.75,8.2) 86(45.5,0) 87(45.25,8.2) 88(45,0) 89(44.75,8.2) 90(44.5,0) 91(44.25,8.2) 92(44,0) 93(43.75,8.2) 94(43.5,0) 95(43.25,8.2) 96(43,0) 97(42.75,8.2) 98(42.5,0) 99(42.25,8.2) 100(42,0) 101(41.75,8.2) 102(41.5,0) 103(41.25,8.2) 104(41,0) 105(40.75,8.2) 106(40.5,0) 107(40.25,8.2) 108(40,0) 109(39.75,8.2) 110(39.5,0) 111(39.25,8.2) 112(39,0) 113(38.75,8.2) 114(38.5,0) 115(38.25,8.2) 116(38,0) 117(37.75,8.2) 118(37.5,0) 119(37.25,8.2) 120(37,0) 121(36.75,8.2) 122(36.5,0) 123(36.25,8.2) 124(36,0) 125(35.75,8.2) 126(35.5,0) 127(35.25,8.2) 128(35,0) 129(34.75,8.2) 130(34.5,0) 131(34.25,8.2) 132(34,0) 133(33.75,8.2) 134(33.5,0) 135(33.25,8.2) 136(33,0) 137(32.75,8.2) 138(32.5,0) 139(32.25,8.2) 140(32,0) 141(31.75,8.2) 142(31.5,0) 143(31.25,8.2) 144(31,0) 145(28.75,8.2) 146(28.5,0) 147(28.25,8.2) 148(28,0) 149(27.75,8.2) 150(27.5,0) 151(27.25,8.2) 152(27,0) 153(26.75,8.2) 154(26.5,0) 155(26.25,8.2) 156(26,0) 157(25.75,8.2) 158(25.5,0) 159(25.25,8.2) 160(25,0) 161(24.75,8.2) 162(24.5,0) 163(24.25,8.2) 164(24,0) 165(23.75,8.2) 166(23.5,0) 167(23.25,8.2) 168(23,0) 169(22.75,8.2) 170(22.5,0) 171(22.25,8.2) 172(22,0) 173(21.75,8.2) 174(21.5,0) 175(21.25,8.2) 176(21,0) 177(20.75,8.2) 178(20.5,0) 179(20.25,8.2) 180(20,0) 181(19.75,8.2) 182(19.5,0) 183(19.25,8.2) 184(19,0) 185(18.75,8.2) 186(18.5,0) 187(18.25,8.2) 188(18,0) 189(17.75,8.2) 190(17.5,0) 191(17.25,8.2) 192(17,0) 193(16.75,8.2) 194(16.5,0) 195(16.25,8.2) 196(16,0) 197(15.75,8.2) 198(15.5,0) 199(15.25,8.2) 200(15,0) 201(14.75,8.2) 202(14.5,0) 203(14.25,8.2) 204(14,0) 205(13.75,8.2) 206(13.5,0) 207(13.25,8.2) 208(13,0) 209(12.75,8.2) 210(12.5,0) 211(12.25,8.2) 212(12,0) 213(11.75,8.2) 214(11.5,0) 215(11.25,8.2) 216(11,0) 217(10.75,8.2) 218(10.5,0) 219(10.25,8.2) 220(10,0) 221(9.75,8.2) 222(9.5,0) 223(9.25,8.2) 224(9,0) 225(8.75,8.2) 226(8.5,0) 227(8.25,8.2) 228(8,0) 229(7.75,8.2) 230(7.5,0) 231(7.25,8.2) 232(7,0) 233(6.75,8.2) 234(6.5,0) 235(6.25,8.2) 236(6,0) 237(5.75,8.2) 238(5.5,0) 239(5.25,8.2) 240(5,0) 241(4.75,8.2) 242(4.5,0) 243(4.25,8.2) 244(4,0) 245(3.75,8.2) 246(3.5,0) 247(3.25,8.2) 248(3,0) 249(2.75,8.2) 250(2.5,0) 251(2.25,8.2) 252(2,0) 253(1.75,8.2) 254(1.5,0) 255(1.25,8.2) 256(1,0) 257(0.75,8.2) 258(0.5,0) 259(0.25,8.2) 260(0,0)
  rect 2.007x3.505 smd: 261(-4.375,-3.9) 262(71.125,-7.9)
CON_SUSB-CS_UT11123-101W0_FXCN
  custom 0.088x0.088 smd: A1(-2.75,0.745) A12(2.75,0.745)
  rect 0.3x0.6 smd: A2(-2.25,0.745) A3(-1.75,0.745) A4(-1.25,0.745) A5(-0.75,0.745) A6(-0.25,0.745) A7(0.25,0.745) A8(0.75,0.745) A9(1.25,0.745) A10(1.75,0.745) A11(2.25,0.745) B1(3,-0.705) B2(2.5,-0.705) B3(2,-0.705) B4(1.5,-0.705) B5(1,-0.705) B6(0.5,-0.705) B7(-0.5,-0.705) B8(-1,-0.705) B9(-1.5,-0.705) B10(-2,-0.705) B11(-2.5,-0.705) B12(-3,-0.705)
  oval 1.2x2.1 hole 0.7x1.6: G1(-4.3,-0.204) G2(4.3,-0.205)
  oval 2.1x1.2 hole 1.6x0.7: G3(-3.775,-0.006) G4(3.776,-0.005)
  rect 1x0.5 smd: S1(-1,1.57) S2(1,1.57)
  oval 0.9x1.95 hole 0.5x1.55: S3(-5.9,-5.346) S4(5.9,-5.346)
CON_SUSB_3SR_UEA1111-R04012_FOX
  round 1.219 hole 0.711: 1(3.5,1.5) 2(1,1.5) 3(-1,1.5) 4(-3.5,1.5) 5(-4,0) 6(-2,0) 7(0,0) 8(2,0) 9(4,0)
  oval 1.575x2.565 hole 0.813x1.803: H1(6.4,0.6) H2(-6.4,0.6)
  oval 1.571x3.607 hole 0.555x2.591: H3(7.85,-7.2)
  oval 1.829x3.607 hole 0.813x2.591: H4(-7.85,-7.2)
CON_WB-4H125_11255W90-NP_JCTC
  rect 0.8x1.9 smd: 1(1.875,0) 2(0.625,0) 3(-0.625,0) 4(-1.875,0)
  rect 1.3x3.35 smd: S1(-4.725,-4.875) S2(4.725,-4.875)
CON_WB_2H125_W-00-1025_JCTC
  rect 0.813x1.626 smd: 1(-0.625,0) 2(0.625,0)
  rect 1.93x3.048 smd: S1(-3.07,-2.9) S2(3.07,-2.9)
CON_WB_3H125_3800K-F03N_ENT
  rect 0.813x1.626 smd: 1(1.25,0) 2(0,0) 3(-1.25,0)
  rect 2.134x3.048 smd: S1(-3.8,-2.9) S2(3.8,-2.9)
CON_WB_6H08_88460-0601_ACES
  rect 0.508x1.016 smd: 1(-2,0) 2(-1.2,0) 3(-0.4,0) 4(0.4,0) 5(1.2,0) 6(2,0)
  rect 1.194x1.702 smd: S1(-3.3,-1.95) S2(3.3,-1.95)
CON_WB_10H08_50208-010_ACES
  rect 0.61x1.549 smd: 1(-3.6,1.938) 2(-2.8,1.938) 3(-2,1.938) 4(-1.2,1.938) 5(-0.4,1.938) 6(0.4,1.938) 7(1.2,1.938) 8(2.001,1.938) 9(2.801,1.938) 10(3.601,1.938)
  rect 1.194x1.803 smd: S1(-4.9,-0.012) S2(4.902,-0.012)
CON_WB_13V150_51481-01371_ACES
  rect 0.85x2.65 smd: 1(9,-1.95) 2(7.5,-1.95) 3(6,-1.95) 4(4.5,-1.95) 5(3,-1.95) 6(1.5,-1.95) 7(0,-1.95) 8(-1.5,-1.95) 9(-3,-1.95) 10(-4.5,-1.95) 11(-6,-1.95) 12(-7.5,-1.95) 13(-9,-1.95)
  rect 0.85x3.55 smd: U1(9,1.95) U2(7.5,1.95) U3(6,1.95) U4(4.5,1.95) U5(3,1.95) U6(1.5,1.95) U7(0,1.95) U8(-1.5,1.95) U9(-3,1.95) U10(-4.5,1.95) U11(-6,1.95) U12(-7.5,1.95) U13(-9,1.95)
CRYSTAL-2P_3D2X1D5_0D9
  rect 1.016x1.803 smd: 1(-1.25,0) 2(1.25,0)
CRYSTAL-4P_3D2X2D5_0D9
  rect 1.016x1.194 smd: 1(-1.291,-0.8) 2(1.291,-0.8) 3(1.291,0.8) 4(-1.291,0.8)
DFN3X2-14L
  custom 0.152x0.152 smd: 1(-1,-1.1) 7(1,-1.1) 8(1,1.1) 14(-1,1.1)
  rect 0.203x0.813 smd: 2(-0.8,-1.1) 3(-0.4,-1.1) 4(0,-1.1) 5(0.4,-1.1) 6(0.8,-1.1) 9(0.8,1.1) 10(0.4,1.1) 11(0,1.1) 12(-0.4,1.1) 13(-0.8,1.1)
  rect 2.489x0.914 smd: S1(0,0)
DFN10_0D5_2D5X1D0
  rect 0.254x0.66 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x0.813 smd: 3(0,-0.388) 8(0,0.388)
DIODE-AZ5315-02F
  rect 0.225x0.35 smd: 1(-0.187,0.325) 2(0.187,0.325)
  rect 0.6x0.35 smd: 3(0,-0.325)
FUSE-0805
  rect 0.864x1.422 smd: 1(-0.875,0) 2(0.875,0)
GI_H3
  round 8.001 hole 2.794: 1(0,0)
GI_H8
  custom 1.75x1.75 hole 2.794: 1(0,0)
GI_H12
  custom 2x2 hole 2.794: 1(0,0)
GST5009
  rect 0.61x1.372 smd: 1(-5.5,-4.686) 2(-4.5,-4.686) 3(-3.5,-4.686) 4(-2.5,-4.686) 5(-1.5,-4.686) 6(-0.5,-4.686) 7(0.5,-4.686) 8(1.5,-4.686) 9(2.5,-4.686) 10(3.5,-4.686) 11(4.5,-4.686) 12(5.5,-4.686) 13(5.5,4.686) 14(4.5,4.686) 15(3.5,4.686) 16(2.5,4.686) 17(1.5,4.686) 18(0.5,4.686) 19(-0.5,4.686) 20(-1.5,4.686) 21(-2.5,4.686) 22(-3.5,4.686) 23(-4.5,4.686) 24(-5.5,4.686)
HOLEC197D71
  round 5.004 hole 1.803: 1(0,0)
HOLEC276D118
  round 7.01 hole 2.997: 1(0,0)
HOLEC295D157
  round 7.493 hole 3.988: 1(0,0)
LED_19-223-R7G
  rect 0.813x0.406 smd: 1(0.825,0.43) 2(-0.825,0.43) 3(0.825,-0.43) 4(-0.825,-0.43)
LED_WHITE_4_RNM_RNM
  rect 0.813x0.813 smd: A(-0.75,0) C(0.75,0)
M-B0402
  rect 0.508x0.508 smd: 1(-0.457,0) 2(0.457,0)
M-B0603
  rect 0.711x0.813 smd: 1(-0.65,0) 2(0.65,0)
M-B0805
  rect 1.245x1.6 smd: 1(-0.975,0) 2(0.975,0)
M-C0402
  rect 0.508x0.508 smd: 1(-0.457,0) 2(0.457,0)
M-C0603
  rect 0.711x0.813 smd: 1(-0.65,0) 2(0.65,0)
M-C0805
  rect 0.864x1.422 smd: 1(-0.875,0) 2(0.875,0)
M-C1808
  rect 1.27x2.032 smd: 1(-2.286,0) 2(2.286,0)
M-C7343
  rect 2.311x2.997 smd: 1(-3.2,0) 2(3.2,0)
M-MARK1
  round 1.016 smd: 1(0,0)
M-MSOP8
  rect 0.406x1.524 smd: 1(-0.975,-2.2) 2(-0.325,-2.2) 3(0.325,-2.2) 4(0.975,-2.2) 5(0.975,2.2) 6(0.325,2.2) 7(-0.325,2.2) 8(-0.975,2.2)
M-R0402
  rect 0.508x0.508 smd: 1(-0.457,0) 2(0.457,0)
M-R0603
  rect 0.711x0.813 smd: 1(-0.65,0) 2(0.65,0)
M-R0805
  rect 1.245x1.6 smd: 1(-0.975,0) 2(0.975,0)
M-R1206
  rect 1.6x1.702 smd: 1(-1.4,0) 2(1.4,0)
M-SOD323
  rect 1.27x0.762 smd: A(-1,0) C(1,0)
M-SOP8-208MIL
  oval 0.61x2.794 smd: 1(-1.905,-3.124) 2(-0.635,-3.124) 3(0.635,-3.124) 4(1.905,-3.124) 5(1.905,3.124) 6(0.635,3.124) 7(-0.635,3.124) 8(-1.905,3.124)
M-SOP8_150MIL
  rect 0.635x1.905 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
M-SOT23
  rect 0.762x0.762 smd: 1(-0.953,-1.143) 2(0.953,-1.143) 3(0,1.143)
M-SOT23-3L
  rect 1.016x1.016 smd: 1(-0.953,-1.27) 2(0,1.27) 3(0.953,-1.27)
M-SOT23A
  rect 0.762x0.762 smd: B(-0.953,-1.143) C(0,1.143) E(0.953,-1.143)
M-SOT23G
  rect 0.762x0.762 smd: D(0,1.143) G(-0.953,-1.143) S(0.953,-1.143)
M-SOT353
  oval 0.457x1.219 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
PDFN5X6P_8_DUALMOS
  rect 0.508x0.508 smd: 1(1.981,2.892)
  rect 0.508x0.61 smd: 2(0.66,2.841) 3(-0.66,2.841) 5(-1.981,-2.841) 6(-0.66,-2.841) 7(0.66,-2.841) 8(1.981,-2.841)
  custom 0.483x0.483 smd: 4(2.438,1.223)
  rect 4.877x2.642 smd: 9(0,-0.606)
PDFN-8P_B3X3_D65
  rect 0.406x0.762 smd: 1(-0.975,-1.58) 2(-0.325,-1.58) 3(0.325,-1.58) 4(0.975,-1.58) 5(0.975,1.58) 6(0.325,1.58) 7(-0.325,1.58) 8(-0.975,1.58)
  rect 2.616x2.007 smd: S1(0,0.253)
PQFN8-PPS
  custom 0.425x0.425 smd: 1(-1.905,-2.68)
  rect 0.635x1.702 smd: 2(-0.635,-2.68) 3(0.635,-2.68) 4(1.905,-2.68) 5(1.905,2.68) 6(0.635,2.68) 7(-0.635,2.68)
  custom 1.111x1.111 smd: 8(-1.905,2.68)
QFN4X4-24-0-5
  rect 1.219x0.305 smd: 1(-2.21,1.27) 2(-2.21,0.762) 3(-2.21,0.254) 4(-2.21,-0.254) 5(-2.21,-0.762) 6(-2.21,-1.27) 13(2.21,-1.27) 14(2.21,-0.762) 15(2.21,-0.254) 16(2.21,0.254) 17(2.21,0.762) 18(2.21,1.27)
  rect 0.305x1.219 smd: 7(-1.27,-2.21) 8(-0.762,-2.21) 9(-0.254,-2.21) 10(0.254,-2.21) 11(0.762,-2.21) 12(1.27,-2.21) 19(1.27,2.21) 20(0.762,2.21) 21(0.254,2.21) 22(-0.254,2.21) 23(-0.762,2.21) 24(-1.27,2.21)
  rect 2.591x2.591 smd: S1(0,0)
QFN16_3X3_NB687
  rect 2.1x0.25 smd: 1(-0.75,0.5) 2(-0.75,-0.5) 9(0.75,0)
  rect 0.25x0.7 smd: 3(-1.25,-1.45) 4(-0.75,-1.45) 5(-0.25,-1.45) 6(0.25,-1.45) 7(0.75,-1.45) 8(1.25,-1.45) 11(1.25,1.45) 12(0.75,1.45) 13(0.25,1.45) 14(-0.25,1.45) 15(-0.75,1.45) 16(-1.25,1.45)
  rect 0.9x0.25 smd: 10(1.35,0.5)
QFN20_3X3_D4
  rect 0.203x0.813 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.813x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.651x1.651 smd: S1(0,0)
QFN28-1_0D4_2D4X2D4_4X4
  oval 0.203x0.914 smd: 1(-1.2,-2.045) 2(-0.8,-2.045) 3(-0.4,-2.045) 4(0,-2.045) 5(0.4,-2.045) 6(0.8,-2.045) 7(1.2,-2.045) 15(1.2,2.045) 16(0.8,2.045) 17(0.4,2.045) 18(0,2.045) 19(-0.4,2.045) 20(-0.8,2.045) 21(-1.2,2.045)
  oval 0.914x0.203 smd: 8(2.045,-1.2) 9(2.045,-0.8) 10(2.045,-0.4) 11(2.045,0) 12(2.045,0.4) 13(2.045,0.8) 14(2.045,1.2) 22(-2.045,1.2) 23(-2.045,0.8) 24(-2.045,0.4) 25(-2.045,0) 26(-2.045,-0.4) 27(-2.045,-0.8) 28(-2.045,-1.2)
  rect 2.413x2.413 smd: 29(0,0)
QFN48_D4-6X6
  rect 0.203x0.813 smd: 1(2.2,3) 2(1.8,3) 3(1.4,3) 4(1,3) 5(0.6,3) 6(0.2,3) 7(-0.2,3) 8(-0.6,3) 9(-1,3) 10(-1.4,3) 11(-1.8,3) 12(-2.2,3) 25(-2.2,-3) 26(-1.8,-3) 27(-1.4,-3) 28(-1,-3) 29(-0.6,-3) 30(-0.2,-3) 31(0.2,-3) 32(0.6,-3) 33(1,-3) 34(1.4,-3) 35(1.8,-3) 36(2.2,-3)
  rect 0.813x0.203 smd: 13(-3,2.2) 14(-3,1.8) 15(-3,1.4) 16(-3,1) 17(-3,0.6) 18(-3,0.2) 19(-3,-0.2) 20(-3,-0.6) 21(-3,-1) 22(-3,-1.4) 23(-3,-1.8) 24(-3,-2.2) 37(3,-2.2) 38(3,-1.8) 39(3,-1.4) 40(3,-1) 41(3,-0.6) 42(3,-0.2) 43(3,0.2) 44(3,0.6) 45(3,1) 46(3,1.4) 47(3,1.8) 48(3,2.2)
  rect 4.318x4.318 smd: S1(0,0)
QFN-16_4X4_D65
  rect 0.381x0.914 smd: 1(-0.975,-2) 2(-0.325,-2) 3(0.325,-2) 4(0.975,-2) 9(0.975,2) 10(0.325,2) 11(-0.325,2) 12(-0.975,2)
  rect 0.914x0.381 smd: 5(2,-0.975) 6(2,-0.325) 7(2,0.325) 8(2,0.975) 13(-2,0.975) 14(-2,0.325) 15(-2,-0.325) 16(-2,-0.975)
  rect 2.54x2.54 smd: S1(0,0)
QFN-32_4X4_0D4
  custom 0.051x0.051 smd: 1(1.4,2.134) 8(-1.4,2.134) 9(-2.134,1.4) 16(-2.134,-1.4) 17(-1.4,-2.134) 24(1.4,-2.134) 25(2.134,-1.4) 32(2.134,1.4)
  rect 0.203x0.813 smd: 2(1,2.134) 3(0.6,2.134) 4(0.2,2.134) 5(-0.2,2.134) 6(-0.6,2.134) 7(-1,2.134) 18(-1,-2.134) 19(-0.6,-2.134) 20(-0.2,-2.134) 21(0.2,-2.134) 22(0.6,-2.134) 23(1,-2.134)
  rect 0.813x0.203 smd: 10(-2.134,1) 11(-2.134,0.6) 12(-2.134,0.2) 13(-2.134,-0.2) 14(-2.134,-0.6) 15(-2.134,-1) 26(2.134,-1) 27(2.134,-0.6) 28(2.134,-0.2) 29(2.134,0.2) 30(2.134,0.6) 31(2.134,1)
  rect 2.692x2.692 smd: S1(0,0)
QFPS128-04M-60
  rect 0.305x1.524 smd: 1(-6.248,-7.75) 32(6.248,-7.75) 65(6.248,7.75) 96(-6.248,7.75)
  oval 0.203x1.524 smd: 2(-5.8,-7.75) 3(-5.4,-7.75) 4(-5,-7.75) 5(-4.6,-7.75) 6(-4.2,-7.75) 7(-3.8,-7.75) 8(-3.4,-7.75) 9(-3,-7.75) 10(-2.6,-7.75) 11(-2.2,-7.75) 12(-1.8,-7.75) 13(-1.4,-7.75) 14(-1,-7.75) 15(-0.6,-7.75) 16(-0.2,-7.75) 17(0.2,-7.75) 18(0.6,-7.75) 19(1,-7.75) 20(1.4,-7.75) 21(1.8,-7.75) 22(2.2,-7.75) 23(2.6,-7.75) 24(3,-7.75) 25(3.4,-7.75) 26(3.8,-7.75) 27(4.2,-7.75) 28(4.6,-7.75) 29(5,-7.75) 30(5.4,-7.75) 31(5.8,-7.75) 66(5.8,7.75) 67(5.4,7.75) 68(5,7.75) 69(4.6,7.75) 70(4.2,7.75) 71(3.8,7.75) 72(3.4,7.75) 73(3,7.75) 74(2.6,7.75) 75(2.2,7.75) 76(1.8,7.75) 77(1.4,7.75) 78(1,7.75) 79(0.6,7.75) 80(0.2,7.75) 81(-0.2,7.75) 82(-0.6,7.75) 83(-1,7.75) 84(-1.4,7.75) 85(-1.8,7.75) 86(-2.2,7.75) 87(-2.6,7.75) 88(-3,7.75) 89(-3.4,7.75) 90(-3.8,7.75) 91(-4.2,7.75) 92(-4.6,7.75) 93(-5,7.75) 94(-5.4,7.75) 95(-5.8,7.75)
  rect 1.524x0.305 smd: 33(7.75,-6.248) 64(7.75,6.248) 97(-7.75,6.248) 128(-7.75,-6.248)
  oval 1.524x0.203 smd: 34(7.75,-5.8) 35(7.75,-5.4) 36(7.75,-5) 37(7.75,-4.6) 38(7.75,-4.2) 39(7.75,-3.8) 40(7.75,-3.4) 41(7.75,-3) 42(7.75,-2.6) 43(7.75,-2.2) 44(7.75,-1.8) 45(7.75,-1.4) 46(7.75,-1) 47(7.75,-0.6) 48(7.75,-0.2) 49(7.75,0.2) 50(7.75,0.6) 51(7.75,1) 52(7.75,1.4) 53(7.75,1.8) 54(7.75,2.2) 55(7.75,2.6) 56(7.75,3) 57(7.75,3.4) 58(7.75,3.8) 59(7.75,4.2) 60(7.75,4.6) 61(7.75,5) 62(7.75,5.4) 63(7.75,5.8) 98(-7.75,5.8) 99(-7.75,5.4) 100(-7.75,5) 101(-7.75,4.6) 102(-7.75,4.2) 103(-7.75,3.8) 104(-7.75,3.4) 105(-7.75,3) 106(-7.75,2.6) 107(-7.75,2.2) 108(-7.75,1.8) 109(-7.75,1.4) 110(-7.75,1) 111(-7.75,0.6) 112(-7.75,0.2) 113(-7.75,-0.2) 114(-7.75,-0.6) 115(-7.75,-1) 116(-7.75,-1.4) 117(-7.75,-1.8) 118(-7.75,-2.2) 119(-7.75,-2.6) 120(-7.75,-3) 121(-7.75,-3.4) 122(-7.75,-3.8) 123(-7.75,-4.2) 124(-7.75,-4.6) 125(-7.75,-5) 126(-7.75,-5.4) 127(-7.75,-5.8)
SCON2S
  custom 0.064x0.064 smd: 1(0,0.191) 2(0,-0.191)
SOT363
  rect 0.406x0.813 smd: 1(0.65,0.955) 2(0,0.955) 3(-0.65,0.955) 4(-0.65,-0.955) 5(0,-0.955) 6(0.65,-0.955)
SOT-23-5
  rect 0.635x1.27 smd: 1(-0.95,-1.2) 2(0,-1.2) 3(0.95,-1.2) 4(0.95,1.2) 5(-0.95,1.2)
SWITCH_T-V_SFNQGMP21E8T_FH
  rect 1.092x1.778 smd: 1(1.85,3.1) 2(1.85,-3.1) 3(-1.85,3.1) 4(-1.85,-3.1)
  rect 0.66x1.016 smd: 5(2.5,0) 6(-2.5,0)
SWITCH_T_V_ML4L12XQR_DIP
  rect 0.6x1 smd: 1(1.85,2.2) 2(1.85,-2.2) 3(-1.85,2.2) 4(-1.85,-2.2)
  rect 1x0.85 smd: L1(0,-3.075) L2(0,3.075)
TOPOPEN_20X30
  rect 0.762x0.508 smd: 1(0,0.381) 2(0,-0.381)
TOPOPEN_20X79
  rect 0.508x2.007 smd: 1(-0.318,0) 2(0.318,0)
TOPSHORT-R0201
  rect 0.35x0.3 smd: 1(-0.175,0) 2(0.175,0)
TOPSHORT_20X30
  rect 0.508x0.762 smd: 1(0,0.254) 2(0,-0.254)
TP20
  round 0.508 smd: 1(0,0)
TQFN21_3X4_MP86901B
  rect 1.6x0.25 smd: 1(-1,1.05) 2(-1,0.55) 3(-1,-0.25) 4(-1,-1.05) 12(1,-0.65) 13(1,0.15) 14(1,1.05)
  custom 0.2x0.2 smd: 5(0,-1.6)
  rect 0.2x0.45 smd: 6(-0.8,-2.075) 7(-0.4,-2.075) 8(0,-2.075) 9(0.4,-2.075) 10(0.8,-2.075) 11(1.2,-2.075)
  custom 0.175x0.175 smd: 15(1.2,1.9) 21(-1.2,1.9)
  rect 0.2x0.8 smd: 16(0.8,1.9) 17(0.4,1.9) 18(0,1.9) 19(-0.4,1.9) 20(-0.8,1.9)
TQFN23_0D5_4X4_APW8715AA8
  oval 0.8x0.3 smd: 1(-2,1.25) 2(-2,0.75) 3(-2,0.25) 4(-2,-0.25) 5(-2,-0.75) 6(-2,-1.25) 12(2,-1.25) 13(2,-0.75) 14(2,-0.25) 15(2,0.25) 16(2,0.75) 17(2,1.25)
  oval 0.3x0.8 smd: 7(-1.25,-2) 8(-0.75,-2) 11(1.25,-2) 18(1.25,2) 19(0.75,2) 20(0.25,2) 21(-0.25,2) 22(-0.75,2) 23(-1.25,2)
  custom 0.337x0.337 smd: 9(-0.675,-0.325)
  custom 0.237x0.237 smd: 10(0.875,-0.325)
unnamed#2
  round 1.803 hole 1.803 unplated: (0,0)
unnamed#3
  round 0.508 smd: 1(0,0)
WDFN8_0D5_1D0_2D0X2D0
  oval 0.3x1 smd: 1(-0.75,-1) 2(-0.25,-1) 3(0.25,-1) 4(0.75,-1) 5(0.75,1) 6(0.25,1) 7(-0.25,1) 8(-0.75,1)
  rect 1.4x0.5 smd: 9(0,0)
WDFN10-1_0D5_2D0X2D0_3X3
  rect 0.279x0.914 smd: 1(-1,-1.524) 2(-0.5,-1.524) 3(0,-1.524) 4(0.5,-1.524) 5(1,-1.524) 6(1,1.524) 7(0.5,1.524) 8(0,1.524) 9(-0.5,1.524) 10(-1,1.524)
  rect 2.413x1.397 smd: 11(0,0)

## Nets
1.2VS_DDR_PG: R151.1 U5.120 U25.12
1.8V_MAIN_DISCHARGE: C1375.1 Q130.5 Q130.6 R905.2
1V8_AON: C432.1 C1243.1 C1413.2 C1452.2 C3656.1 C3657.1 G1.BA10 G1.BB14 G1.BC14 Q99.5 Q114.2 Q114.5 Q122.2 Q122.5 R398.2 R430.2 R436.1 R437.1 R438.1 R439.1 R440.1 R441.1 R483.2 R486.2 R489.1 R492.2 R493.1 R756.2 R790.1 R815.1 R817.1 R819.1 R822.1 R823.1 R825.1 R845.1 R850.1 R861.1 R956.1 R961.1 R964.1 R2808.1 R2809.1 R2810.1 R2811.1 R2812.1 R2813.1 R2814.1 R2815.1 R2848.1 R2849.1 R2875.2 R2877.2 R2881.2 R2921.1 R2924.1 U83.8 U107.13 U107.14
1V8_MAIN: B27.1 B34.1 C406.1 C415.1 C857.2 C858.2 C861.1 C862.1 C863.2 C864.2 C865.1 C870.2 C872.2 C1295.1 C1296.1 C1302.1 C1303.1 C1415.2 C1417.2 C3658.1 C3659.1 G1.AM10 G1.AM11 G1.AN10 G1.AN11 G1.AR10 G1.AR11 G1.AT10 G1.AT11 G1.AV10 G1.AV11 G1.AW10 G1.AW11 G1.BB26 G1.BB27 G1.BB29 G1.BB30 G1.BB32 G1.BC26 G1.BC27 G1.BC29 G1.BC30 G1.BC32 G1.BD27 G1.BD30 Q78.G R501.2 R1001.2 U107.8 U107.9
3V3_1.2VS: C120.1 R179.1 U25.3
+0.6V_DDR: C181.1 C385.1 C386.1 C391.1 C392.1 C3421.2 C3424.2 C3443.2 C3445.2 CN1.258 CN11.258 R35.1 U25.5
+1.00V_CPU: C174.1 C3644.1 C3646.1 R25.2 R28.2 R198.2 R291.2 R292.2 R298.2 U26.G30 U26.H29 U105.8 U105.9
+1.0VA_PCH: C222.1 C321.2 C329.2 C331.2 C340.1 C3606.1 C3611.1 C3612.1 C3613.1 C3626.2 L53.2 R322.1 R370.1 R372.1 R375.1 R378.1 R3367.2 U28.AA22 U28.AA23 U28.AB20 U28.AB22 U28.AB23 U28.AB27 U28.AB28 U28.AB30 U28.AD20 U28.AD23 U28.AD27 U28.AD28 U28.AD30 U28.AD31 U28.AE17 U28.AF23 U28.AF27 U28.AF30 U28.AF31 U28.AG31 U28.B1 U28.B2 U28.B3 U28.C1 U28.C2 U28.U26 U28.U29 U28.V19 U28.V25 U28.V27 U28.V28 U28.V30 U28.V31 U28.W19 U28.W20 U28.W22 U28.W23 U28.W31 U105.1 U105.2 U105.6 U105.7
+1.00VS_CPU: C150.1 C219.1 C654.2 C3641.1 C3643.1 R26.2 R33.2 R98.1 R691.1 R750.1 R785.1 U26.H28 U26.H30 U26.J28 U105.13 U105.14
+1.0VS_LAN: C263.1 C264.1 C267.1 C359.1 L54.2 R213.2 U1901.3 U1901.8 U1901.22 U1901.30
+1.2VS: C135.1 C149.1 C154.1 C167.1 C169.1 C170.1 C171.1 C176.1 C184.1 C187.1 C189.1 C190.1 C191.1 C196.1 C206.1 C212.1 C215.1 C217.1 C218.1 C373.1 C378.1 C380.1 C381.1 C387.1 C388.1 C3416.1 C3417.1 C3418.1 C3419.1 C3420.1 C3422.1 C3423.1 C3425.1 C3427.1 C3428.1 C3431.1 C3432.1 C3438.1 C3439.1 C3440.1 C3441.1 C3463.2 C3464.2 C3465.2 C3466.2 C3467.2 C3468.2 C3470.1 C3471.1 CN1.12 CN1.33 CN1.54 CN1.75 CN1.96 CN1.111 CN1.112 CN1.117 CN1.118 CN1.123 CN1.124 CN1.129 CN1.130 CN1.135 CN1.136 CN1.141 CN1.142 CN1.147 CN1.148 CN1.153 CN1.154 CN1.159 CN1.160 CN1.163 CN1.178 CN1.199 CN1.220 CN1.241 CN11.12 CN11.33 CN11.54 CN11.75 CN11.96 CN11.111 CN11.112 CN11.117 CN11.118 CN11.123 CN11.124 CN11.129 CN11.130 CN11.135 CN11.136 CN11.141 CN11.142 CN11.147 CN11.148 CN11.153 CN11.154 CN11.159 CN11.160 CN11.163 CN11.178 CN11.199 CN11.220 CN11.241 L13.2 R38.1 R42.1 R53.1 R163.1 R197.2 R206.2 R207.2 U25.6 U26.AA6 U26.AE12 U26.AF5 U26.AF6 U26.AG5 U26.AG9 U26.AJ12 U26.AL11 U26.AP6 U26.AP7 U26.AR6 U26.AR12 U26.AT12 U26.AW6 U26.AY6 U26.J5 U26.J6 U26.K6 U26.K12 U26.L6 U26.L12 U26.R6 U26.T6 U26.W6 U26.Y12
+1.8VA: C134.1 C1425.1 C1440.1 C1441.1 C3892.1 C3895.2 L52.2 R193.2 R355.1 R356.1 R368.1 R369.2 R374.2 U107.1 U107.2 U107.6 U107.7
+1.8VA_PCH: C328.2 R374.1 R376.2 U28.AG19 U28.AG20 U28.AN15 U28.AR15 U28.BB11
+2.5VS: C374.1 C384.1 C389.1 C390.1 C1237.1 C3399.2 C3401.2 C3426.2 C3447.1 CN1.257 CN1.259 CN11.257 CN11.259 U25.11
+3.3V: AB2.2 B10.1 B25.2 C46.2 C175.1 C1176.1 C1193.1 C1194.1 C1195.1 C1196.1 C1197.1 C1318.2 C1319.2 C1321.2 C1322.2 C1326.2 C1327.2 C1328.2 C1329.2 C3654.1 C3655.1 C3847.1 CN1.255 CN11.255 CNDEG1.1 CNDEG1.S1 CNDEG2.5 CNEDP1.35 CNSSD1.2 CNSSD1.4 CNSSD1.12 CNSSD1.14 CNSSD1.16 CNSSD1.18 CNSSD1.70 CNSSD1.72 CNSSD1.74 CNSSD2.2 CNSSD2.4 CNSSD2.12 CNSSD2.14 CNSSD2.16 CNSSD2.18 CNSSD2.70 CNSSD2.72 CNSSD2.74 Q37.G Q96.5 Q109.2 Q109.5 Q165.5 R32.2 R92.2 R100.2 R102.2 R107.2 R109.2 R116.2 R126.2 R136.1 R146.2 R169.2 R173.2 R175.2 R184.2 R188.2 R190.1 R227.2 R235.1 R236.2 R250.2 R253.1 R254.2 R264.1 R266.2 R273.2 R294.2 R312.1 R327.1 R329.1 R335.1 R336.2 R338.2 R339.2 R341.1 R342.1 R343.1 R350.1 R361.1 R365.2 R460.1 R472.1 R484.2 R485.2 R560.1 R674.1 R794.1 R795.2 R828.2 R832.1 R834.1 R905.1 R972.1 R978.1 R1794.2 R1795.2 R1921.1 R2850.1 R2925.1 R3290.1 R3536.1 R3537.1 R3539.1 R3540.1 R3716.1 R3721.2 U1.4 U4.20 U5.11 U6.20 U10.20 U11.20 U13.20 U15.20 U29.5 U106.8 U106.9
+3.3V_CHGR_LED: Q54.D R5.2 R653.1
+3.3VA: B1.1 C147.1 C205.1 C221.1 C325.2 C326.2 C327.2 C379.1 C1276.1 C1278.1 C1280.1 C1369.1 C1508.1 C3570.1 C3622.2 CN12.50 L35.2 Q5.S Q19.S Q54.S Q55.S Q147.S Q155.S R36.2 R59.2 R60.2 R72.2 R73.2 R76.2 R77.1 R79.1 R80.1 R81.1 R82.1 R85.1 R86.1 R88.1 R89.1 R103.1 R111.2 R112.1 R118.2 R135.2 R137.1 R140.1 R143.2 R144.2 R145.2 R151.2 R155.1 R164.2 R168.2 R170.2 R171.2 R179.2 R216.2 R245.1 R246.1 R251.1 R257.1 R286.1 R287.2 R288.1 R290.2 R309.1 R314.1 R379.2 R475.2 R482.2 R623.1 R687.1 R688.2 R880.2 R889.2 R909.2 R931.2 R937.2 R3197.2 R3198.2 R3240.1 R3306.1 R3313.1 R3323.1 R3329.1 R3332.1 R3334.1 R3512.1 R3514.1 R3654.1 R3724.1 R3822.1 U3.35 U5.74 U8.8 U20.8 U23.5 U24.5 U28.AC35 U28.AC36 U28.AE35 U28.AE36 U28.AN21 U28.AN26 U28.AN32 U28.AN44 U28.AP26 U28.AT44 U28.AW9 U28.AY8 U28.BB7 U28.BB14 U28.V23 U30.8 U30.9 U30.10 U106.1 U106.2 U106.6 U106.7
+3.3VA_RTC: C254.1 C284.2 C320.2 D1.3 R138.1 R142.1 R149.1 R315.2 U28.BC49 U28.BD49
+3.3VDVDD: AB2.1 C180.1 C1235.1 U7.1 U7.9
+3.3VS: C3652.1 C3653.1 CN17.10 Q60.2 Q60.5 Q105.G R189.1 R321.2 R435.2 R487.2 R488.2 R764.2 U106.13 U106.14
+3.3VS_LAN: C246.1 C252.1 C332.1 Q19.D R434.1 R1907.1 R1908.1 R1920.1 U1901.11 U1901.23 U1901.32
+5V: AB6.2 AC3.1 B12.1 B14.2 C143.2 C183.1 C199.2 C278.1 C279.1 C431.1 C553.1 C3647.1 C3648.1 C4092.1 C4093.1 CN41.5 CN41.6 D10.2 D41.3 PS1.2 Q106.S R3.1 R280.2 R508.1 R632.1 R793.1 R837.2 R969.1 R970.2 R1010.1 R3523.1 U7.25 U7.38 U14.2 U16.2 U104.13 U104.14
+5V_3.3V_L: B10.2 B12.2 C545.1 Q101.S R506.1 R911.1
+5V_3.3V_LCD: C393.1 C394.1 CNEDP1.17 CNEDP1.18 Q101.D R506.2 R912.1
+5V_AMP: AB6.1 AC4.1 AC5.1 AC8.1 AC9.1 U7.39 U7.46
+5V_HDD: C21.2 C23.1 C486.1 CNHDD1.9 CNHDD1.10 CNHDD1.11 CNHDD1.12 CNHDD1.13 CNHDD1.14 CNHDD1.15 Q106.D R508.2 R510.2
+5V_TYPEC: C197.2 C200.2 C201.2 C202.2 C3642.1 CON3.A4 CON3.A9 CON3.B4 CON3.B9 U27.6 U27.7 U27.8
+5VA: C128.1 C129.1 C311.1 C3566.1 C3567.1 C3568.1 C3569.1 C3630.2 C3631.2 C3634.2 C3635.2 C3650.1 C3962.1 CN42.1 L50.2 PJP17.2 R68.2 R70.2 R87.2 R225.2 R881.2 R924.2 R941.2 R942.1 R3381.2 U2.5 U19.8 U31.2 U31.3 U104.1 U104.2 U104.4 U104.6 U104.7 U105.4 U106.4 U107.4
+5VS: C255.2 C3649.1 C3651.1 C3897.1 C3898.1 C3899.1 C3990.1 C3991.1 C3992.1 C4084.1 C4085.1 C4104.1 CN9.1 CN12.27 CN12.28 CN12.29 CN12.30 CN12.31 CN14.8 CN14.9 CN14.10 CN14.S2 CN17.1 CN17.2 CN19.5 CN19.6 CNKB1.38 CNKB1.39 CNKB1.40 Q27.S Q50.S R6.1 R222.2 R509.1 R586.1 R662.1 R3517.1 R3520.1 U27.2 U27.3 U104.8 U104.9 U733.2 U733.3
+VCCA_XTAL_1P05: R375.2 U28.P2 U28.P3
+VCCAMPHYPLL_1P05: C322.2 R372.2 U28.C49 U28.D49 U28.E49
+VCCAZPLL_1P05: R378.2 U28.D1 U28.E1
+VCCCORE: C3.1 C5.1 C6.1 C7.1 C9.1 C10.1 C11.1 C22.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C47.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C65.1 C66.1 C67.1 C69.1 C70.1 C71.1 C75.1 C77.1 C79.1 C80.1 C81.1 C90.1 C91.1 C92.1 C98.1 C103.1 C108.1 C364.1 C366.1 C367.1 C368.1 C370.1 C371.1 C395.1 C396.1 C397.1 C398.1 C577.1 C579.1 C580.1 C582.1 C583.1 C584.1 C587.1 C589.1 C590.1 C591.1 C593.1 C594.1 C603.1 C604.1 C605.1 C607.1 C608.1 C609.1 C611.1 C612.1 C613.1 C614.1 C616.1 C617.1 C618.1 C619.1 C620.1 C624.1 C675.1 L12.2 L14.2 L15.2 L17.2 R49.2 R310.1 U26.AA13 U26.AA31 U26.AA32 U26.AA33 U26.AA34 U26.AA35 U26.AA36 U26.AA37 U26.AA38 U26.AB29 U26.AB30 U26.AB31 U26.AB32 U26.AB35 U26.AB36 U26.AB37 U26.AB38 U26.AC13 U26.AC14 U26.AC29 U26.AC30 U26.AC31 U26.AC32 U26.AC33 U26.AC34 U26.AC35 U26.AC36 U26.AD13 U26.AD14 U26.AD31 U26.AD32 U26.AD33 U26.AD34 U26.AD35 U26.AD36 U26.AD37 U26.AD38 U26.AE13 U26.AE14 U26.AE30 U26.AE31 U26.AE32 U26.AE35 U26.AE36 U26.AE37 U26.AE38 U26.AF29 U26.AF30 U26.AF31 U26.AF32 U26.AF33 U26.AF34 U26.AF35 U26.AF36 U26.AF37 U26.AF38 U26.AG14 U26.AG31 U26.AG32 U26.AG33 U26.AG34 U26.AG35 U26.AG36 U26.AH13 U26.AH14 U26.AH29 U26.AH30 U26.AH31 U26.AH32 U26.AJ14 U26.AJ29 U26.AJ30 U26.AJ31 U26.AJ32 U26.AJ33 U26.AJ34 U26.AJ35 U26.AJ36 U26.AK31 U26.AK32 U26.AK33 U26.AK34 U26.AK35 U26.AK36 U26.AK37 U26.AK38 U26.AL13 U26.AL29 U26.AL30 U26.AL31 U26.AL32 U26.AL35 U26.AL36 U26.AL37 U26.AL38 U26.AM13 U26.AM14 U26.AM29 U26.AM30 U26.AM31 U26.AM32 U26.AM33 U26.AM34 U26.AM35 U26.AM36 U26.AN13 U26.AN14 U26.AN31 U26.AN32 U26.AN33 U26.AN34 U26.AN35 U26.AN36 U26.AN37 U26.AN38 U26.AP13 U26.AP30 U26.AP31 U26.AP32 U26.AP35 U26.AP36 U26.AP37 U26.AP38 U26.K13 U26.K14 U26.L13 U26.L14 U26.N13 U26.N14 U26.N30 U26.N31 U26.N32 U26.N35 U26.N36 U26.N37 U26.N38 U26.P13 U26.P14 U26.P29 U26.P30 U26.P31 U26.P32 U26.P33 U26.P34 U26.P35 U26.P36 U26.R13 U26.R31 U26.R32 U26.R33 U26.R34 U26.R35 U26.R36 U26.R37 U26.R38 U26.T29 U26.T30 U26.T31 U26.T32 U26.T35 U26.T36 U26.T37 U26.T38 U26.U29 U26.U30 U26.U31 U26.U32 U26.U33 U26.U34 U26.U35 U26.U36 U26.V13 U26.V14 U26.V31 U26.V32 U26.V33 U26.V34 U26.V35 U26.V36 U26.V37 U26.V38 U26.W13 U26.W14 U26.W29 U26.W30 U26.W31 U26.W32 U26.W35 U26.W36 U26.W37 U26.W38 U26.Y29 U26.Y30 U26.Y31 U26.Y32 U26.Y33 U26.Y34 U26.Y35 U26.Y36
+VCCDSW_3P3: C324.2 R379.1 U28.BE48 U28.BE49
+VCCGT: C93.1 C94.1 C95.1 C96.1 C97.1 C99.1 C100.1 C101.1 C102.1 C104.1 C105.1 C106.1 C107.1 C109.1 C110.1 C111.1 C112.1 C114.1 C115.1 C116.1 C117.1 C118.1 C121.1 C122.1 C123.1 C125.1 C127.1 C132.1 C133.1 C372.1 C375.1 C376.1 C377.1 C399.1 C401.1 C585.1 C586.1 C598.1 C606.1 C621.1 C622.1 C623.1 C1372.1 C1373.1 C1376.1 C1377.1 L20.2 R50.2 U26.AT14 U26.AT31 U26.AT32 U26.AT33 U26.AT34 U26.AT35 U26.AT36 U26.AT37 U26.AT38 U26.AU14 U26.AU29 U26.AU30 U26.AU31 U26.AU32 U26.AU35 U26.AU36 U26.AU37 U26.AU38 U26.AV29 U26.AV30 U26.AV31 U26.AV32 U26.AV33 U26.AV34 U26.AV35 U26.AV36 U26.AW14 U26.AW31 U26.AW32 U26.AW33 U26.AW34 U26.AW35 U26.AW36 U26.AW37 U26.AW38 U26.AY29 U26.AY30 U26.AY31 U26.AY32 U26.AY35 U26.AY36 U26.AY37 U26.AY38 U26.BA13 U26.BA14 U26.BA29 U26.BA30 U26.BA31 U26.BA32 U26.BA33 U26.BA34 U26.BA35 U26.BA36 U26.BB13 U26.BB14 U26.BB31 U26.BB32 U26.BB33 U26.BB34 U26.BB35 U26.BB36 U26.BB37 U26.BB38 U26.BC29 U26.BC30 U26.BC31 U26.BC32 U26.BC35 U26.BC36 U26.BC37 U26.BC38 U26.BD13 U26.BD14 U26.BD29 U26.BD30 U26.BD31 U26.BD32 U26.BD33 U26.BD34 U26.BD35 U26.BD36 U26.BE31 U26.BE32 U26.BE33 U26.BE34 U26.BE35 U26.BE36 U26.BE37 U26.BE38 U26.BF13 U26.BF14 U26.BF29 U26.BF30 U26.BF31 U26.BF32 U26.BF35 U26.BF36 U26.BF37 U26.BF38 U26.BG29 U26.BG30 U26.BG31 U26.BG32 U26.BG33 U26.BG34 U26.BG35 U26.BG36 U26.BH33 U26.BH34 U26.BH35 U26.BH36 U26.BH37 U26.BH38 U26.BJ16 U26.BJ17 U26.BJ19 U26.BJ20 U26.BJ21 U26.BJ23 U26.BJ24 U26.BJ26 U26.BJ27 U26.BJ37 U26.BJ38 U26.BK16 U26.BK17 U26.BK19 U26.BK20 U26.BK21 U26.BK23 U26.BK24 U26.BK26 U26.BK27 U26.BL15 U26.BL16 U26.BL17 U26.BL23 U26.BL24 U26.BL25 U26.BL26 U26.BL27 U26.BL28 U26.BL36 U26.BL37 U26.BM15 U26.BM16 U26.BM17 U26.BM36 U26.BM37 U26.BN15 U26.BN16 U26.BN17 U26.BN36 U26.BN37 U26.BN38 U26.BP15 U26.BP16 U26.BP17 U26.BP37 U26.BP38 U26.BR15 U26.BR16 U26.BR17 U26.BR37 U26.BT15 U26.BT16 U26.BT17 U26.BT37
+VCCIO: C146.1 C186.1 C208.1 C3632.1 C3744.1 C3745.1 C3747.1 L62.2 R54.2 R148.1 R262.2 R3369.1 U26.AG12 U26.G15 U26.G17 U26.G19 U26.G21 U26.H15 U26.H16 U26.H17 U26.H19 U26.H20 U26.H21 U26.H26 U26.H27 U26.J15 U26.J16 U26.J17 U26.J19 U26.J20 U26.J21 U26.J26 U26.J27
+VCCRTCEXT: C339.2 U28.BF47 U28.BG47
+VCCSA: C144.1 C148.1 C152.1 C153.1 C173.1 C188.1 C192.1 C204.1 C209.1 C210.1 C211.1 C213.1 C220.1 C382.1 C383.1 C599.1 C600.1 C601.1 C625.1 C626.1 C627.1 C628.1 L21.2 R55.2 U26.J30 U26.K29 U26.K30 U26.K31 U26.K32 U26.K33 U26.K34 U26.K35 U26.L31 U26.L32 U26.L35 U26.L36 U26.L37 U26.L38 U26.M29 U26.M30 U26.M31 U26.M32 U26.M33 U26.M34 U26.M35 U26.M36
AGND_+1.0VA: C88.1 PJP13.1 R62.1 U17.4
AGND_+3.3VA: C87.1 PJP11.1 R61.1 U12.4
AGND_+5VA: C1315.2 PJP5.1 R228.1 U9.4
AGND_VCCIO: C89.1 PJP15.1 R65.1 R3370.1 U18.4
