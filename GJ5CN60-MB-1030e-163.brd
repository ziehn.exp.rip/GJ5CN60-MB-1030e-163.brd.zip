# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_MDI2+: length 144.4
  TOP w0.102: LT2.2 81.15,162.01 81.5,161.66 81.5,160.87 81.24,160.61 v1(81.1,160.61) ; v1(93.67,55.45) 93.6,55.38 93.6,54.51 93.84,54.27 U1901.6
  L3_IN1 w0.076: v1(81.1,160.61) 81.36,160.61 81.52,160.77 81.52,161.79 82.17,162.44 85.46,162.44 86.23,161.67 86.23,159.89 86.36,159.76 86.36,158.65 90.03,154.98 96.75,154.98 96.97,154.75 99.22,154.75 105.28,148.69 105.28,147.52 109.48,143.32 109.48,128.63 108.44,127.59 108.44,112.05 102.31,105.92 102.31,91.82 98.09,87.6 98.09,83.19 98.68,82.6 98.68,79.75 100.16,78.26 100.16,70.96 97.61,68.41 97.61,64.98 99.95,62.64 99.95,58.88 99.26,58.19 95.53,58.19 93.55,56.21 93.55,55.58 v1(93.67,55.45)
LAN_MDI2-: length 144.4
  TOP w0.102: U1901.7 93.44,54.14 93.17,54.41 93.17,55.32 v1(93.04,55.45) ; LT2.3 82.15,161.95 81.93,161.74 81.93,160.69 81.48,160.24 v1(81.48,160)
  L3_IN1 w0.076: v1(93.04,55.45) 93.24,55.65 93.24,56.34 95.4,58.5 99.14,58.5 99.64,59.01 99.64,62.51 97.31,64.85 97.31,68.53 99.86,71.08 99.86,78.14 98.37,79.62 98.37,82.48 97.79,83.06 97.79,87.73 102.01,91.94 102.01,106.05 108.14,112.18 108.14,127.72 109.17,128.75 109.17,143.2 104.98,147.39 104.98,148.56 99.09,154.45 96.85,154.45 96.62,154.68 89.9,154.68 86.05,158.52 86.05,159.63 85.93,159.76 85.93,161.54 85.33,162.13 82.29,162.13 81.83,161.66 81.83,160.57 81.48,160.23 v1(81.48,160)
LAN_MDI3+: length 137.3
  TOP w0.102: v1(83.64,161.24) 83.73,161.16 84.25,161.16 84.45,161.36 84.45,161.71 84.15,162.01 LT2.5 ; U1901.9 91.64,53.04 91.46,53.22 91.46,53.37 v1(91.64,53.55)
  L3_IN1 w0.076: v1(91.64,53.55) 91.64,53.32 91.56,53.25 91.36,53.25 90.88,53.72 90.88,55.18 92.66,56.96 92.66,59.01 95.35,61.7 95.35,68.05 98.5,71.2 98.5,78.31 97.53,79.28 97.53,82.11 96.94,82.7 96.94,88.06 101.17,92.29 101.17,106.39 107.3,112.53 107.3,128.07 108.33,129.1 108.33,142.85 104.14,147.04 104.14,148.21 98.74,153.61 96.5,153.61 96.27,153.84 88.56,153.84 85.22,157.18 85.22,159.29 85.09,159.41 85.09,160.73 84.58,161.24 84.02,161.24 v1(83.64,161.24)
LAN_MDI3-: length 137.4
  TOP w0.102: v1(91.01,52.91) 91.16,52.91 91.43,52.64 U1901.10 ; LT2.6 85.15,162 84.88,161.74 84.88,161.18 84.43,160.72 83.9,160.72 83.77,160.59 v1(83.77,160.56)
  L3_IN1 w0.076: v1(83.77,160.56) 83.77,160.61 84.1,160.94 84.45,160.94 84.78,160.61 84.78,159.29 84.91,159.16 84.91,157.05 88.43,153.53 96.15,153.53 96.37,153.3 98.62,153.3 103.83,148.09 103.83,146.92 108.03,142.72 108.03,129.23 107,128.2 107,112.66 100.86,106.52 100.86,92.42 96.63,88.19 96.63,82.58 97.23,81.98 97.23,79.15 98.2,78.18 98.2,71.33 95.05,68.18 95.05,61.83 92.35,59.13 92.35,57.08 90.58,55.31 90.58,53.6 91.01,53.17 v1(91.01,52.91)
LAN_PWR: length 87.8
  TOP w0.102: v1(96.47,57.23) 96.34,57.23 96.09,56.98 94.77,56.98 R255.2
  L3_IN1 w0.089: v1(155.83,46.49) 154.89,45.55 154.89,34.71 v1(156.54,33.06)
  BOTTOM w0.102: U5.119 157.62,29.86 156.92,30.56 156.92,32.68 v1(156.54,33.06) ; v1(155.83,46.49) 155.42,46.08 149.66,46.08 149.25,46.49 142.61,46.49 142.13,46.97 134.98,46.97 130.99,50.96 130.99,52.12 126.91,56.19 106.9,56.19 106.09,57 102.88,57 102.24,56.37 100,56.37 98.37,57.99 96.98,57.99 96.6,57.61 96.6,57.36 v1(96.47,57.23)
LAN_RSET: length 2
  TOP w0.102: U1901.31 96.89,52.64 97.2,52.95 97.2,53.24 97.46,53.5 97.97,53.5 R1912.2
LAN_XTAL_IN: length 8.3
  TOP w0.102: U1901.28 97.18,51.44 97.61,51.01 99.57,51.01 R260.1 100,50.78 C247.1 101.32,50.78 101.55,51.01 103.09,51.01 Y2.3
LAN_XTAL_OUT: length 1.6
  TOP w0.102: U1901.29 97.28,51.84 97.61,51.51 R1925.2
LANWAKEB: length 15
  TOP w0.102: U1901.21 94.64,48.34 95.2,47.78 R434.2 95.71,47.15 95.71,46.05 96.45,45.31 R226.1 96.45,44.67 97.1,44.02 104.66,44.02 Q68.S
LB_BLUE_PWM: length 14.1
  BOTTOM w0.102: U5.32 163.35,14.66 163.55,14.46 163.55,13.95 162.86,13.26 162.86,9.89 161.84,8.87 159.84,8.87 159.16,8.18 159.16,4.27 R3518.2
LB_GREEN_PWM: length 23.5
  L6_IN2 w0.089: v1(159.08,9.99) 157.05,7.95 147.14,7.95 v1(146.25,7.06)
  L8_IN3 w0.089: v1(159.08,9.99) 159,10.07 159,12.32 160.98,14.3 160.98,15.53 v1(161.62,16.16)
  BOTTOM w0.102: R3515.2 v1(146.25,7.06) ; v1(161.62,16.16) 161.88,15.91 U5.29
LB_RED_PWM: length 61.5
  L6_IN2 w0.089: v1(159.44,9.2) 159.09,8.84 158.22,8.84 157.13,7.75 147.7,7.75 146.49,6.54 145.32,6.54 144.87,6.99 144.34,6.99 143.37,6.02 139.43,6.02 138.8,5.39 134.15,5.39 133.54,6 121.98,6 121.26,6.71 113.6,6.71 v1(113.5,6.81)
  L8_IN3 w0.089: v1(159.44,9.2) 160.35,10.11 160.35,12.27 163.14,15.07 163.14,16.97 v1(164.03,17.86)
  BOTTOM w0.102: R661.2 112.98,6.28 v1(113.5,6.81) ; U5.25 163.68,17.51 v1(164.03,17.86)
LDO_+5VA: length 4.3
  TOP w0.254: U9.21 191.97,94.31 v1(192.48,94.82) 192.99,95.33 C308.1
  BOTTOM w0.381: v1(192.48,94.82) 191.21,96.09 R69.2
LDOCAP_CODEC: length 3.8
  TOP w0.203: C1234.1 17.08,60.66 19.51,60.66 19.62,60.77 U7.28
LDRV_CHG: length 29
  TOP w0.203: v1(61.8,42.62) 61.89,42.54 U97.23
  TOP w0.508: v1(52.02,62.31) 51.81,62.51 C3581.1 PQ37.8
  L6_IN2 w0.508: v1(52.02,62.31) 52.65,61.67 52.65,52.28 57.13,47.8 57.13,45.51 58.65,44 58.65,43.13 59.16,42.62 v1(61.8,42.62)
LED_B: length 6.8
  TOP w0.305: v1(95.96,3.38) 96.17,3.59 CN19.4
  BOTTOM w0.508: R3519.1 99.31,1.86 v3(99.03,1.58) 96.95,1.58 C3904.1 96.8,2.04 95.96,2.87 v1(95.96,3.38)
LED_G: length 5.5
  TOP w0.305: v1(96.75,3.43) 96.67,3.51 CN19.3
  BOTTOM w0.508: R3516.1 99.64,3.25 98.8,2.42 C3902.1 97.56,2.42 v3(97.36,2.62) 96.75,3.23 v1(96.75,3.43)
LED_R: length 5.8
  TOP w0.305: CN19.1 97.67,3.67 97.49,3.49 v1(97.49,3.45) 97.17,3.78 CN19.2
  BOTTOM w0.508: R664.1 v3(99.19,4.65) 98.88,4.65 98.55,4.32 C2747.1 98,4.32 97.49,3.81 v1(97.49,3.45)
LG1_NVD: length 16.3
  TOP w0.305: U722.23 18.24,118.7 17.86,119.08 16.92,119.08 R2880.1
  TOP w0.508: v1(16.79,120.73) C3941.1 R2880.1 ; v1(12.44,123.27) 12.19,123.52 PQ42.8 ; PQ43.8 18.16,123.32 v1(18.11,123.27)
  L3_IN1 w0.508: v1(12.44,123.27) 13.84,124.67 17.09,124.67 18.11,123.65 v1(18.11,123.27) 18.11,122.05 v1(16.79,120.73)
LG2_NVD: length 44
  TOP w0.305: 21.54,119.08 20.14,119.08 19.76,118.7 U722.20
  TOP w0.508: PQ41.8 8.23,145.95 C3940.1 8.71,146.13 v1(9.09,145.75) ; v1(22.3,120.48) 22.35,120.42 R950.1 22.1,119.08 21.54,119.08 ; v1(13.28,145.75) 14.2,144.83 PQ40.8
  L6_IN2 w0.508: v1(22.3,120.48) 20.52,122.25 20.52,124.29 19.38,125.43 19.38,141.05 14.68,145.75 v1(13.28,145.75) 13.28,145.24 12.78,144.73 9.6,144.73 9.09,145.24 v1(9.09,145.75)
LG3_NVD: length 14.8
  TOP w0.508: PQ48.8 18.03,150.79 18.31,150.5 C3939.1 19,150.07 v1(19.02,150.09) ; PQ49.8 v1(12.19,150.57)
  L6_IN2 w0.508: v1(12.19,150.57) 12.19,150.63 12.9,151.34 17.77,151.34 v1(19.02,150.09) 19.02,148.39 v1(20.14,147.27)
  BOTTOM w0.254: U32.5 20.47,147.6 v1(20.14,147.27)
LG_MEM: length 36.3
  TOP w0.254: v1(5.21,100.74) 5.68,100.74 5.93,100.99 U84.6
  TOP w0.508: v1(5.36,83.9) 5.36,84.74 PQ53.8 ; v1(11.78,83.21) C554.1 PQ52.8
  L3_IN1 w0.508: v1(5.36,83.9) 5.36,84.74 6.3,85.68 8.05,85.68 10.51,83.21 v1(11.78,83.21) 11.78,84.33 11.12,84.99 11.12,88.47 12.27,89.61 12.27,95.71 9.35,98.63 9.35,100.16 8.33,101.17 6.02,101.17 5.59,100.74 v1(5.21,100.74)
LID#: length 490.2
  L6_IN2 w0.089: v1(118.57,172.04) 119.8,172.04 121.15,173.39 143.07,173.39 145.41,175.72 157.79,175.72 164.27,169.24 170.38,169.24 171.94,167.69 179.44,167.69 180.34,166.79 180.34,166.27 180.42,166.2 180.42,157.24 180.4,157.22 180.4,156.56 181.84,155.12 182.66,155.12 183.26,155.72 190.63,155.72 193.7,152.66 193.7,138.65 193.32,138.28 193.32,137.3 194.75,135.88 194.75,100.39 193.62,99.27 193.62,93.04 193.32,92.74 193.32,75.77 192.66,75.12 192.66,59.14 193.32,58.48 193.32,48.92 192.35,47.96 185.39,47.96 184.36,48.99 181.2,48.99 v1(181.18,48.97)
  L8_IN3 w0.089: v1(6.81,71.58) 6.81,70.31 6.93,70.18 6.93,67.14 7.44,66.63 7.44,64.47 8.65,63.26 8.65,58.44 6.17,55.96 6.17,50.24 9.79,46.62 9.79,41.29 13.46,37.62 25.61,37.62 27.36,39.37 30.48,39.37 32.04,37.8 33.9,37.8 34.49,38.4 34.49,38.94 35.33,39.78 46.23,39.78 47.05,38.96 53.91,38.96 59.26,33.61 77.33,33.61 79.65,31.29 79.65,13.61 80.85,12.41 80.85,9.57 82.21,8.2 82.21,7.22 86.51,2.92 94.39,2.92 94.9,2.42 97.66,2.42 98.13,2.88 109.68,2.88 110.31,3.51 118.02,3.51 119.29,4.78 137.92,4.78 141.43,8.29 141.43,10.75 145.19,14.51 147.57,14.51 152.24,19.18 155.95,19.18 156.54,19.76 160.22,19.76 v1(160.35,19.64) 160.35,20.91 164.16,24.72 170.13,24.72 173.18,27.77 173.18,29.29 174.07,30.18 176.61,30.18 179.27,32.85 179.27,46.11 181.18,48.02 v1(181.18,48.97)
  BOTTOM w0.102: v1(6.81,71.58) 6.93,71.58 7.67,72.32 7.67,72.65 8.38,73.36 CN12.49 9.81,73.36 9.96,73.51 9.96,74.63 v3(10.57,75.24) ; SW5.3 119.67,171.22 R16.2 118.57,171.48 v1(118.57,172.04) ; U5.19 160.62,19.91 v1(160.35,19.64)
LID_OFF: length 234
  L8_IN3 w0.089: v1(108.79,162.77) 108.15,162.77 107.14,163.78 104.47,163.78 104.09,163.4 100.91,163.4 100.77,163.55 100.77,164.31 99.64,165.43 93.93,165.43 90.75,162.26 79.58,162.26 79.2,161.88 79.2,158.98 75.34,155.12 69.69,155.12 68.94,155.88 68.94,156.7 69.17,156.93 69.17,158.96 69.44,159.23 69.44,161.35 68.73,162.06 62.23,162.06 58.62,158.45 54.56,158.45 53.92,157.81 46.31,157.81 44.91,159.21 44.91,162.64 47.07,164.8 47.07,167.52 46.18,168.41 34.29,168.41 29.13,163.25 29.13,161.78 30.33,160.58 30.33,150.52 30.04,150.23 30.04,125.97 26.74,122.67 26.74,114.87 27.18,114.42 27.18,111.61 25.6,110.03 23.37,110.03 21.71,108.36 21.71,107.31 19.98,105.58 14.17,105.58 12.87,104.28 12.87,79.81 9.5,76.44 9.5,72.7 9.22,72.41 9.22,70.4 9.21,70.39 9.21,69.73 9.7,69.24 v1(11,69.24)
  BOTTOM w0.102: CN12.40 9.37,68.86 9.75,69.24 v1(11,69.24) ; v1(108.79,162.77) 109.04,163.02 109.04,164.29 109.8,165.05 114.83,165.05 C450.1 116.48,166.7 Q183.G 117.73,166.7 R688.1
LINE2_L: length 26.7
  TOP w0.203: U7.14 25.12,63.27 25.37,63.53 v1(25.37,63.62)
  BOTTOM w0.203: CN12.5 9.05,51.32 14.35,51.32 18.44,55.41 v3(18.44,55.86) 18.68,56.1 18.68,56.78 19.71,57.81 19.71,63.03 20.23,63.55 23.9,63.55 24.46,64.11 25.04,64.11 25.37,63.78 v1(25.37,63.62)
LINE2_R: length 26
  TOP w0.203: U7.15 v1(24.72,63.66)
  BOTTOM w0.203: CN12.4 14.53,50.86 19.13,55.45 19.13,56.75 19.48,57.1 v3(19.99,57.1) 20.17,57.28 20.17,62.84 20.55,63.22 24.41,63.22 24.72,63.53 v1(24.72,63.66)
LPC_AD0: length 80.1
  TOP w0.089: U28.BB39 v2(124.96,17.57)
  L3_IN1 w0.089: v2(124.96,17.57) 125.33,17.57 125.7,17.2 125.7,16.56 125.04,15.89 125.04,13.18 126.07,12.15 131.21,12.15 131.99,12.93 132.32,12.93 133.1,12.15 151.77,12.15 154.15,14.53 155.04,14.53 158.66,18.15 158.66,21.5 159.37,22.22 160.42,22.22 161.15,22.94 v1(161.16,22.94)
  BOTTOM w0.102: v1(161.16,22.94) 161.54,23.32 161.87,23.32 162.06,23.51 U5.10 163.71,23.51 163.88,23.68 168.35,23.68 168.86,23.17 v3(168.86,22.66) 169.33,22.18 170.16,22.18 173.58,18.76 173.58,13.44 172.82,12.68 172.82,10.19 174.12,8.9 174.12,5.08 173.93,4.9 CNDEG1.9
LPC_AD1: length 83.2
  TOP w0.089: U28.AW37 v2(124.11,18.88)
  L3_IN1 w0.089: v2(124.11,18.88) 125.62,18.88 126.07,18.43 126.31,18.43 126.69,18.05 126.69,17.78 125.91,17 125.91,16.47 125.25,15.81 125.25,13.27 126.15,12.37 128.69,12.37 129.47,13.14 132.41,13.14 133.19,12.37 151.68,12.37 154.06,14.75 154.95,14.75 158.44,18.24 158.44,21.67 159.31,22.53 160.32,22.53 160.58,22.79 v1(160.58,22.94)
  BOTTOM w0.102: CNDEG1.8 174.73,6.4 v3(174.73,6.4) 174.45,6.68 174.45,8.89 173.05,10.29 173.05,12.58 173.81,13.35 173.81,18.85 168.76,23.91 U5.9 162.07,23.91 161.76,23.6 161.24,23.6 v1(160.58,22.94)
LPC_AD2: length 88.2
  TOP w0.089: v2(122.76,19.64) 122.78,19.61 U28.AV37
  L3_IN1 w0.089: v1(160.02,22.94) 158.95,22.94 158.06,22.05 158.06,18.16 154.86,14.96 153.95,14.96 151.57,12.58 133.3,12.58 132.44,13.44 129.26,13.44 128.47,12.65 126.18,12.65 125.55,13.28 125.55,15.32 128.09,17.86 128.09,18.72 127.42,19.38 126.69,19.38 126.12,19.96 125.35,19.96 124.78,19.38 123.01,19.38 v2(122.76,19.64)
  BOTTOM w0.102: v1(160.02,22.94) 160.02,22.99 160.86,23.83 161.49,23.83 161.97,24.31 U5.8 168.68,24.31 174.04,18.95 174.04,13.25 173.28,12.49 173.28,10.38 174.98,8.68 v3(174.98,8.31) 174.98,7.73 175.53,7.18 CNDEG1.7
LPC_AD3: length 85.4
  TOP w0.089: U28.BA38 v2(124.58,18.23)
  L3_IN1 w0.089: v2(124.58,18.23) 124.58,17.9 124.46,17.78 124.46,15.47 124.82,15.1 124.82,13.4 124.28,12.85 124.28,12.28 124.62,11.93 151.86,11.93 153.54,13.61 155.65,13.61 158.29,16.25 158.29,17.18 158.95,17.84 158.95,19.43 161.66,22.14 161.66,23.01 v1(160.2,24.46)
  L6_IN2 w0.089: v1(173.68,10.75) 173.68,5.41 v1(173.56,5.29)
  BOTTOM w0.102: v1(173.68,10.75) 173.68,11.33 v3(173.89,11.53) 174.27,11.92 174.27,19.04 168.6,24.71 U5.7 161.99,24.71 161.47,24.18 160.88,24.18 160.6,24.46 v1(160.2,24.46) ; CNDEG1.10 173.13,5.04 173.38,5.29 v1(173.56,5.29)
LPC_FRAME#: length 83.6
  TOP w0.076: U28.BE38 123.85,15.86 124.02,15.69 124.02,15.42 123.9,15.3 123.88,15.3 123.83,15.24 123.83,14.69 123.82,14.35 123.62,14.15 123.52,14.15 123.42,14.05 v1(123.39,14.05)
  L3_IN1 w0.089: v1(123.39,14.05) 123.36,14.05 123.22,13.91 123.22,12.91 124.41,11.72 151.95,11.72 153.55,13.32 155.81,13.32 158.55,16.06 158.55,17.13 159.17,17.75 159.17,19.34 161.87,22.05 161.87,23.92 v1(161.2,24.59)
  BOTTOM w0.102: CNDEG1.5 177.13,4.96 176.22,5.87 176.22,7.83 175.51,8.54 v3(175.51,10.95) 175.51,11.69 174.5,12.7 174.5,19.14 168.7,24.94 164.32,24.94 164.14,25.11 U5.6 161.72,25.11 v1(161.2,24.59)
LRST1#: length 5.3
  BOTTOM w0.102: U5.14 164.86,21.91 C162.1 165.35,21.47 165.71,21.82 167.11,21.82 R118.1
LVDS_VIN: length 305.2
  TOP w0.102: v1(75.78,159.99) 75.64,160.13 R373.2
  L3_IN1 w0.076: v1(75.78,159.99) 75.86,160.06
  L3_IN1 w0.089: 75.86,160.06 76.02,160.23 78.69,160.23 82.37,163.91 94.18,163.91 95.66,165.38 107.85,165.38 108.93,166.47 108.93,169.14 109.96,170.16 113.57,170.16 114.71,171.29 117.1,171.29 118.09,170.3 121.72,170.3 123.56,168.46 138.87,168.46 140.47,170.07 144.46,170.07 145.26,169.27 170.76,169.27 175.99,164.05 178.11,164.05 179.27,162.89 185.59,162.89 187.78,160.7 187.78,159.37 189.45,157.71 191.39,157.71 193.27,155.83 193.27,139.23 192.46,138.42 192.46,137.81 194.34,135.93 194.34,102.62 193.7,101.97 193.7,93.44 192.94,92.68 192.94,76.73 192.26,76.04 192.26,64.69 185.57,58.01 185.57,46.36 187.18,44.75 187.18,43.43 188.29,42.32 v1(188.29,42.24)
  L6_IN2 w0.089: v1(188.29,42.24) 188.78,41.75 188.78,31.09 183.18,25.49 179.25,25.49 177.25,23.48 177.25,20.38 175.85,18.98 169.42,18.98 169.16,19.24 165.23,19.24 164.24,20.22 162.71,20.22 160.45,17.96 v1(160.45,17.24)
  BOTTOM w0.102: v1(160.45,17.24) 160.42,17.2 U5.35
M_A_A0: length 28.7
  TOP w0.076: v1(142.36,101.33) 141.59,101.33 141.36,101.56 141.36,103.69 141.17,103.89 141.17,105.09 U26.AH3
  TOP w0.165: CN1.144 145.39,81.53 143.16,83.76 v1(143.16,83.99)
  L8_IN3 w0.135: v1(143.16,83.99) 143.76,84.6 143.76,85.96 143.31,86.42 143.31,86.74 142.58,87.46 142.58,89.31 141.79,90.1 141.79,94.02 143.33,95.56 143.33,97.68 141.96,99.05 141.96,100.94 142.35,101.33 v1(142.36,101.33)
M_A_A1: length 28.6
  TOP w0.076: v1(147.36,102.02) 146.99,102.39 146.99,102.91 147.09,103.01 147.09,105.41 U26.AP4
  TOP w0.165: v1(148.04,85.78) 147.52,86.3 147.52,87.55 148.14,88.17 CN1.133
  L8_IN3 w0.135: v1(147.36,102.02) 147.09,102.29 146.5,102.29 146.09,101.88 146.09,94.09 147.52,92.67 147.52,91.13 147.11,90.72 147.11,85.39 147.24,85.26 147.52,85.26 147.67,85.41 147.67,85.66 147.8,85.78 v1(148.04,85.78)
M_A_A2: length 27.4
  TOP w0.076: v1(145.25,105.69) U26.AN4
  TOP w0.165: CN1.132 148.39,82.07 148.68,82.35 148.68,83.62 v1(148.04,84.26)
  L8_IN3 w0.135: v1(148.04,84.26) 146.92,84.26 146.67,84.51 146.67,90.87 146.5,91.04 146.5,93.06 145.65,93.91 145.65,105.28 v1(145.25,105.69)
M_A_A3: length 27.4
  TOP w0.076: v1(147.36,101.38) 146.8,101.95 146.8,103.69 146.92,103.81 146.92,104.5 146.77,104.66 146.77,105.47 146.54,105.69 146.4,105.69 146.2,105.9 146.2,106.39 U26.AP5
  TOP w0.165: CN1.131 148.65,87.27 v1(148.04,86.67)
  L8_IN3 w0.135: v1(148.04,86.67) 147.75,86.96 147.75,87.15 148.04,87.43 148.04,87.66 147.91,87.79 147.68,87.79 147.55,87.93 147.55,88.2 147.68,88.33 148.07,88.33 148.2,88.47 148.2,88.74 148.07,88.87 147.68,88.87 147.55,89.01 147.55,89.27 147.68,89.41 148.08,89.41 148.22,89.54 148.22,89.81 148.08,89.95 147.68,89.95 147.55,90.08 147.55,90.35 147.68,90.49 147.82,90.49 147.96,90.62 147.96,92.85 146.53,94.27 146.53,100.56 v1(147.36,101.38)
M_A_A4: length 27.9
  TOP w0.076: U26.AP2 146.76,104.44 146.76,103.95 146.59,103.78 146.59,101.58 v1(147.38,100.79)
  TOP w0.165: v1(148.04,85.02) 149.39,83.67 CN1.128
  L8_IN3 w0.076: v1(147.38,100.79) 146.83,100.24 146.83,99.23 146.97,99.09 146.97,98.88
  L8_IN3 w0.135: v1(148.04,85.02) 148.96,85.93 148.96,86.84 148.82,86.98 148.62,86.98 148.49,87.11 148.49,87.38 148.62,87.52 148.82,87.52 148.96,87.65 148.96,87.92 148.69,88.19 148.69,88.46 148.82,88.59 148.82,88.59 148.96,88.73 148.96,89 148.82,89.13 148.82,89.13 148.68,89.27 148.68,89.53 148.96,89.8 148.96,90.07 148.82,90.21 148.6,90.21 148.46,90.34 148.46,90.61 148.6,90.75 148.82,90.75 148.96,90.88 148.96,92.47 146.97,94.45 146.97,98.88
M_A_A5: length 28.2
  TOP w0.076: v1(147.38,100.18) 146.39,101.17 146.39,103.98 U26.AP1
  TOP w0.165: v1(151.25,85.59) 151.16,85.59 149.9,84.33 CN1.126
  L8_IN3 w0.076: 147.41,98.85 147.41,98.98 147,99.39 147,99.79 v1(147.38,100.18)
  L8_IN3 w0.135: v1(151.25,85.59) 149.54,85.59 149.4,85.73 149.4,90.43 150.15,91.18 150.15,92.37 149.72,92.8 149.35,92.8 149.15,93 149.15,93.37 148.95,93.56 148.58,93.56 148.39,93.76 148.39,94.13 148.19,94.32 147.82,94.32 147.63,94.52 147.63,94.89 147.41,95.1 147.41,98.85
M_A_A6: length 30.2
  TOP w0.076: 147.08,99.17 146.19,100.05 146.19,105.08 U26.AP3
  TOP w0.165: v1(148.63,98.61) 147.64,98.61 147.08,99.17 ; CN1.127 149.65,86.41 149.86,86.2 151.51,86.2 152.18,85.53 v1(152.74,85.53)
  L8_IN3 w0.135: v1(148.63,98.61) 148.74,98.61 149.99,97.35 149.99,95.63 152.93,92.7 152.93,90.8 153.3,90.42 153.3,86.05 152.78,85.53 v1(152.74,85.53)
M_A_A7: length 29.2
  TOP w0.076: U26.AN1 145.68,104 145.68,99.61 145.91,99.38 145.91,99.17
  TOP w0.165: v1(148.65,97.33) 147.58,97.33 145.91,99 145.91,99.17 ; v1(151.33,84.78) 150.68,84.13 150.68,82.32 150.9,82.1 CN1.122
  L8_IN3 w0.135: v1(151.33,84.78) 151.75,85.2 151.75,87.57 151.5,87.82 150.56,87.82 150.28,88.09 150.28,89.09 150.42,89.22 150.85,89.22 150.99,89.36 150.99,89.63 150.85,89.76 150.42,89.76 150.28,89.9 150.28,90.07 151.03,90.81 151.03,92.73 148.29,95.47 148.29,96.97 v1(148.65,97.33)
M_A_A8: length 29.5
  TOP w0.076: 146.41,99.17 146.41,99.21 145.94,99.69 145.94,103.74 146.02,103.83 146.02,105.09 U26.AN3
  TOP w0.165: v1(148.63,97.99) 147.58,97.99 146.41,99.17 ; v1(152.72,86.18) 152.37,86.18 151.88,86.67 150.3,86.67 150.14,86.83 150.14,87.18 150.27,87.3 150.49,87.3 150.62,87.43 150.62,87.79 150.49,87.91 150.27,87.91 150.14,88.04 CN1.125
  L8_IN3 w0.135: v1(148.63,97.99) 148.73,97.99 149.55,97.17 149.55,95.45 152.49,92.51 152.49,90.02 152.35,89.89 152.08,89.89 151.95,89.75 151.95,89.48 152.08,89.35 152.35,89.35 152.49,89.21 152.49,88.11 152.72,87.88 v1(152.72,86.18)
M_A_A9: length 27.8
  TOP w0.076: v1(147.81,105.69) U26.AT4
  TOP w0.165: v1(151.25,87.3) 151.14,87.41 CN1.121
  L8_IN3 w0.135: v1(151.25,87.3) 151.25,86.3 150.98,86.03 149.98,86.03 149.84,86.17 149.84,86.6 149.98,86.73 150.52,86.73 150.65,86.87 150.65,87.14 150.52,87.27 149.98,87.27 149.84,87.4 149.84,90.25 150.59,91 150.59,92.55 147.85,95.29 147.85,104.52 148.21,104.87 148.21,105.29 v1(147.81,105.69)
M_A_A10_AP: length 28.9
  TOP w0.076: v1(142.36,102.45) 142.28,102.45 141.74,102.99 141.74,104.42 U26.AH2
  TOP w0.165: v1(143.2,85.03) 142.38,84.21 142.38,82.4 142.48,82.3 142.79,82.3 142.9,82.2 CN1.146
  L8_IN3 w0.135: v1(143.2,85.03) 143.2,84.7 143.03,84.53 142.44,84.53 142.25,84.72 142.25,86.55 141.54,87.26 141.54,89.11 140.32,90.33 140.32,93.8 142.45,95.92 142.45,97.77 141.51,98.71 141.51,101.61 142.35,102.45 v1(142.36,102.45)
M_A_A11: length 29.4
  TOP w0.165: CN1.120 151.39,82.1 151.84,82.54 151.84,83.36 151.38,83.81 v1(151.28,83.81) ; U26.AN2 145.49,104.46 145.49,104.27 145.42,104.2 145.42,103.93 145.47,103.88 145.47,99.53 145.4,99.46 145.4,98.8 147.52,96.68 v1(148.81,96.68)
  L8_IN3 w0.135: v1(148.81,96.68) 148.81,95.57 152.05,92.33 152.05,91.17 151.43,90.55 151.43,89.18 150.97,88.72 150.97,88.48 151.19,88.26 151.68,88.26 152.19,87.75 152.19,84.72 v1(151.28,83.81)
M_A_A12: length 30.9
  TOP w0.076: U26.AU4 149.44,105.57 149.44,103.29 149.34,103.2 v1(149.34,102.56)
  TOP w0.165: v1(152.74,84.89) 152.83,84.89 153.27,85.33 153.27,86.39 152.52,87.14 152.4,87.14 151.65,87.89 CN1.119
  L8_IN3 w0.135: v1(152.74,84.89) 153.14,84.89 153.74,85.49 153.74,86.99 154.14,87.38 154.14,92.12 150.43,95.83 150.43,97.56 148.5,99.5 148.5,102.51 148.71,102.72 149.19,102.72 v1(149.34,102.56)
M_A_A13: length 30.1
  TOP w0.076: v1(140.27,101.14) 138.66,102.76 138.66,105.09 U26.AE3
  TOP w0.165: v1(137.34,84.89) 137.5,84.89 137.81,84.59 138.24,84.59 138.53,84.3 138.53,83.2 139.13,82.61 139.53,82.61 139.9,82.24 CN1.158
  L8_IN3 w0.135: v1(137.34,84.89) 137.74,84.89 138.3,85.45 138.3,88 135.95,90.35 135.95,93.77 139.34,97.17 139.34,97.53 139.34,97.53 139.34,100.21 v1(140.27,101.14)
M_A_A14_MA_WE#: length 28.5
  TOP w0.076: U26.AG4 v1(140.27,106.31)
  TOP w0.165: CN1.151 141.64,87.41 139.88,85.65 v1(139.79,85.65)
  L8_IN3 w0.135: v1(139.79,85.65) 139.86,85.65 140.29,86.08 140.29,86.5 140.23,86.56 140.23,88.56 138.39,90.4 138.39,93.72 141.13,96.47 141.13,97.94 140.73,98.34 140.73,103.99 139.87,104.85 139.87,105.92 v1(140.27,106.31)
M_A_A15_MA_CAS#: length 31
  TOP w0.076: U26.AD1 138.2,101.78 140.01,99.97 v1(140.27,99.97)
  TOP w0.165: v1(139.83,83.8) 140.32,83.32 140.32,82.68 140.39,82.6 CN1.156
  L8_IN3 w0.135: v1(139.83,83.8) 139.34,83.3 139.34,82.86 139.51,82.68 139.97,82.68 140.45,83.16 140.45,84.51 140.01,84.95 139.77,84.95 139.18,85.55 139.18,88.37 137.51,90.03 137.51,92.96 137.37,93.09 137.05,93.09 136.92,93.23 136.92,93.5 137.05,93.63 137.37,93.63 137.51,93.77 137.51,94.09 140.25,96.83 140.25,97.8 139.9,98.15 139.9,99.6 v1(140.27,99.97)
M_A_A16_MA_RAS#: length 29.1
  TOP w0.076: U26.AH4 141.16,105.72 140.33,105.72 v1(140.27,105.66)
  TOP w0.165: v1(141.31,85.65) 141.21,85.65 140.8,85.24 140.8,82.87 141.39,82.27 CN1.152
  L8_IN3 w0.135: v1(141.31,85.65) 141.31,86.25 140.67,86.89 140.67,88.74 138.83,90.58 138.83,93.54 141.57,96.29 141.57,97.91 140.99,98.49 140.99,104.94 v1(140.27,105.66)
M_A_ACT_N: length 28.7
  TOP w0.076: U26.AU3 149.27,105.09 149.27,103.45 148.97,103.14 148.97,102.34 v1(149.34,101.97)
  TOP w0.165: v1(152.74,84.26) 152.83,84.26 153.33,83.76 153.33,82.47 152.9,82.03 CN1.114
  L8_IN3 w0.135: v1(152.74,84.26) 153.37,84.26 154.18,85.07 154.18,86.81 154.58,87.2 154.58,92.3 150.94,95.94 150.94,97.64 148.97,99.61 148.97,101.6 v1(149.34,101.97)
M_A_BA0: length 32
  TOP w0.076: v1(142.36,103.01) 141.94,103.42 141.94,106.78 141.84,106.88 141.55,106.88 141.45,106.78 U26.AH5
  TOP w0.165: CN1.150 141.9,84.69 141.56,85.02 v1(141.31,85.02)
  L8_IN3 w0.135: v1(141.31,85.02) 141.38,85.02 141.81,85.45 141.81,86.37 141.11,87.07 141.11,88.92 139.88,90.14 139.88,93.98 142.01,96.1 142.01,97.89 141.29,98.61 141.29,103.08 142.17,103.96 142.5,103.96 142.74,103.73 142.74,103.39 v1(142.36,103.01)
M_A_BA1: length 27.9
  TOP w0.076: U26.AH1 141.58,103.94 141.58,101.69 141.68,101.59 141.97,101.59 142.03,101.64 142.03,101.85 142.12,101.94 142.31,101.94 v1(142.36,101.89)
  TOP w0.165: v1(143.08,85.91) 143.08,86.75 143.39,87.06 144.65,87.06 144.82,87.22 144.82,87.55 144.65,87.72 143.31,87.72 143.15,87.88 CN1.145
  L8_IN3 w0.135: v1(143.08,85.91) 142.87,86.13 142.87,86.56 142.1,87.33 142.1,89.18 141.36,89.92 141.36,94.21 142.89,95.74 142.89,97.68 141.73,98.84 141.73,101.27 142.35,101.89 v1(142.36,101.89)
M_A_BG0: length 30.7
  TOP w0.076: v1(150.03,101.28) 149.71,100.97 149.09,100.97 148.72,101.33 148.72,103.22 148.99,103.5 U26.AU1
  TOP w0.165: v1(155.56,84.87) 155.54,84.87 153.88,86.53 153.88,86.54 152.94,87.48 152.65,87.77 CN1.115
  L8_IN3 w0.076: 153.31,97.48 153.31,97.78 150.03,101.07 v1(150.03,101.28)
  L8_IN3 w0.135: 153.31,97.48 153.31,96.68 157.58,92.4 157.58,86.45 156,84.87 v1(155.56,84.87)
M_A_BG1: length 29.2
  TOP w0.076: v1(149.92,100.62) 149.1,100.62 148.44,101.28 148.44,103.38 148.71,103.65 148.71,104.44 U26.AU2
  TOP w0.165: v1(155.59,85.55) 155.53,85.55 154.35,86.73 153.14,87.93 CN1.113
  L8_IN3 w0.076: 152.87,97.48 152.87,97.88 150.13,100.62 v1(149.92,100.62)
  L8_IN3 w0.135: v1(155.59,85.55) 155.92,85.55 157.13,86.76 157.13,92.24 152.87,96.5 152.87,97.48
M_A_DQ0: length 39.9
  TOP w0.076: U26.BR6 161.94,107.26 161.99,107.2 162.62,107.2 162.75,107.33 163.12,107.33 v1(163.57,106.87)
  TOP w0.102: v1(179.92,83.62) 179.76,83.62 179.4,83.26 CN1.8
  L8_IN3 w0.089: v1(179.92,83.62) 179.98,83.68 179.98,86.2 180.28,86.5 180.28,88.62 179.68,89.22 179.68,91.18 179.1,91.76 179.1,95.69 179,95.79 178.87,95.79 178.74,95.66 178.62,95.66 178.49,95.78 178.49,95.91 178.62,96.04 178.62,96.17 170.73,104.05 170.73,104.31 169.07,105.98 167.76,105.98 167.68,106.07 167.68,106.34 167.59,106.43 167.41,106.43 167.32,106.34 167.32,106.07 167.23,105.98 167.05,105.98 166.96,106.07 166.96,106.32 166.88,106.41 166.7,106.41 166.61,106.32 166.61,106.07 166.52,105.98 166.18,105.98 165.26,106.9 163.6,106.9 v1(163.57,106.87)
M_A_DQ1: length 39.9
  TOP w0.076: v1(165.04,105.63) 165.03,105.63 165.03,106.17 163.54,107.66 U26.BT6
  TOP w0.102: v1(179.19,86.19) 180.65,87.64 CN1.3
  L8_IN3 w0.089: v1(179.19,86.19) 179.19,86.25 179.69,86.75 179.69,88.13 179.44,88.39 179.31,88.39 179.06,88.15 178.94,88.15 178.81,88.27 178.81,88.4 179.06,88.64 179.06,88.77 178.52,89.31 178.52,94.91 176.43,96.99 176.43,97.37 176.26,97.54 175.89,97.54 175.77,97.67 175.77,97.79 175.9,97.93 175.9,98.06 175.72,98.24 175.6,98.24 175.46,98.1 175.33,98.1 175.21,98.22 175.21,98.35 175.35,98.49 175.35,98.61 175.15,98.81 175.02,98.81 174.88,98.67 174.75,98.67 174.63,98.8 174.63,98.92 174.77,99.06 174.77,99.19 174.64,99.31 174.52,99.31 174.38,99.17 174.25,99.17 174.12,99.3 174.12,99.42 174.27,99.57 174.27,99.69 174.09,99.87 173.96,99.87 173.82,99.73 173.7,99.73 173.57,99.85 173.57,99.98 173.71,100.12 173.71,100.25 173.59,100.37 173.46,100.37 173.32,100.23 173.19,100.23 173.07,100.36 173.07,100.48 173.21,100.62 173.21,100.75 173.08,100.88 172.96,100.88 172.82,100.73 172.69,100.73 172.56,100.86 172.56,100.98 172.71,101.13 172.71,101.25 170.15,103.81 170.15,104.07 168.83,105.39 165.8,105.39 165.53,105.67 165.08,105.67 v1(165.04,105.63)
M_A_DQ2: length 39.1
  TOP w0.076: v1(163.23,104.72) 163.23,105.22 162.9,105.56 162.73,105.56 162.54,105.76 161.21,105.76 U26.BP3
  TOP w0.102: v1(176.8,86.8) 176.57,86.8 176.14,87.22 CN1.21
  L8_IN3 w0.089: v1(163.23,104.72) 163.74,104.72 164.06,104.4 164.25,104.4 165.06,103.59 167.78,103.59 176.35,95.03 176.35,94.84 176.11,94.61 176.11,94.45 176.16,94.4 176.97,94.4 177.07,94.31 177.07,94 177,93.93 176.15,93.93 176.06,93.84 176.06,93.66 176.15,93.58 177,93.58 177.07,93.51 177.07,93.29 177,93.22 176.2,93.22 176.11,93.13 176.11,92.95 176.2,92.86 177,92.86 177.07,92.8 177.07,92.57 177,92.51 176.25,92.51 176.16,92.42 176.16,92.31 176.32,92.15 176.98,92.15 177.07,92.06 177.07,91.92 176.95,91.8 176.95,91.66 177.07,91.54 177.07,91.43 176.89,91.25 176.89,91.07 177.07,90.9 177.07,90.72 176.89,90.54 176.89,90.36 177.07,90.18 177.07,90 176.89,89.83 176.89,89.65 177.07,89.47 177.07,89.33 176.88,89.14 176.88,88.86 177.35,88.39 177.35,86.63 177.28,86.55 177.05,86.55 v1(176.8,86.8)
M_A_DQ3: length 38
  TOP w0.076: U26.BR3 162.12,104.98 162.44,104.98 162.76,104.65
  TOP w0.102: CN1.17 177.22,89.23 177.22,87.89 v1(176.76,87.43) ; 162.76,104.65 163.22,104.19 v1(163.5,104.19)
  L8_IN3 w0.089: v1(163.5,104.19) 163.59,104.1 164.14,104.1 164.99,103.25 167.71,103.25 174.32,96.64 174.32,95.35 174.38,95.29 174.65,95.29 174.74,95.38 174.74,95.89 174.83,95.98 174.98,95.98 175.09,95.87 175.09,95.38 175.18,95.29 175.67,95.29 175.75,95.21 175.75,94.95 175.67,94.86 174.4,94.86 174.32,94.79 174.32,94.58 174.4,94.5 175.67,94.5 175.75,94.42 175.75,94.24 175.67,94.15 174.4,94.15 174.32,94.07 174.32,93.87 174.4,93.79 175.67,93.79 175.75,93.7 175.75,93.53 175.67,93.44 175.01,93.44 174.92,93.35 174.92,93.17 175.01,93.08 175.67,93.08 175.75,92.99 175.75,92.88 175.57,92.7 175.57,92.49 176.6,91.46 176.6,90.95 176.68,90.87 176.68,90.74 176.6,90.66 176.6,90.24 176.68,90.16 176.68,90.03 176.6,89.95 176.6,89.53 176.68,89.45 176.68,89.35 176.59,89.27 176.59,88.74 177.05,88.28 177.05,87.53 176.95,87.43 v1(176.76,87.43)
M_A_DQ4: length 40.5
  TOP w0.076: 165.45,105.84 165.45,105.98 163.48,107.95 162.01,107.95 161.92,107.86 161.06,107.86 160.46,107.26 U26.BN5
  TOP w0.102: 165.45,105.84 165.45,105.13 v1(165.42,105.1) ; v1(179.21,87.64) 179.65,88.08 CN1.7
  L8_IN3 w0.089: v1(179.21,87.64) 178.74,87.64 178.51,87.87 178.51,88.91 178.22,89.19 178.22,94.79 172.09,100.92 172.09,101.04 172.23,101.18 172.23,101.3 172.11,101.43 171.98,101.43 171.84,101.29 171.72,101.29 171.59,101.42 171.59,101.54 171.73,101.68 171.73,101.81 171.6,101.93 171.48,101.93 171.34,101.8 171.21,101.8 171.09,101.92 171.09,102.05 171.23,102.18 171.23,102.31 171.1,102.44 170.97,102.44 170.84,102.3 170.71,102.3 170.59,102.42 170.59,102.55 170.72,102.69 170.72,102.81 170.6,102.94 170.47,102.94 170.33,102.8 170.21,102.8 170.08,102.93 170.08,103.05 170.22,103.19 170.22,103.32 170.09,103.44 169.97,103.44 169.83,103.3 169.71,103.3 169.58,103.43 169.58,103.56 169.86,103.83 169.86,103.95 169.72,104.08 169.61,104.08 169.33,103.81 169.2,103.81 169.08,103.93 169.08,104.06 169.34,104.32 169.34,104.45 169.21,104.57 169.09,104.57 168.83,104.31 168.7,104.31 168.57,104.44 168.57,104.56 168.85,104.84 168.85,104.96 168.72,105.09 168.6,105.09 168.32,104.81 168.2,104.81 167.91,105.1 167.58,105.1 167.49,105.01 167.49,104.85 167.4,104.77 167.22,104.77 167.13,104.85 167.13,105.01 167.04,105.1 166.86,105.1 166.78,105.01 166.78,104.85 166.69,104.77 166.51,104.77 166.42,104.85 166.42,105.01 166.33,105.1 v1(165.42,105.1)
M_A_DQ5: length 40.2
  TOP w0.076: U26.BP6 161.31,107.36 161.49,107.54 161.89,107.54 162.06,107.37 162.43,107.37 162.56,107.49 163.47,107.49 164.02,106.95 v1(164.02,106.42)
  TOP w0.102: v1(179.92,82.99) 180.4,82.51 CN1.4
  L8_IN3 w0.089: v1(179.92,82.99) 179.88,82.99 179.44,83.42 179.44,83.89 179.68,84.13 179.68,86.32 179.99,86.63 179.99,88.41 179.39,89 179.39,91.06 178.81,91.64 178.81,95.04 177.88,95.97 177.88,96.09 178.02,96.23 178.02,96.36 177.89,96.48 177.76,96.48 177.63,96.35 177.5,96.35 177.38,96.47 177.38,96.6 177.51,96.73 177.51,96.86 177.39,96.99 177.26,96.99 177.12,96.85 177,96.85 176.87,96.97 176.87,97.1 177.01,97.24 177.01,97.36 170.44,103.93 170.44,104.19 168.95,105.69 166.06,105.69 165.32,106.42 v1(164.02,106.42)
M_A_DQ6: length 38.9
  TOP w0.076: U26.BP2 160.67,104.62 160.67,103.94 160.9,103.72 162,103.72
  TOP w0.102: v1(165.06,102.77) 164.69,103.14 164.11,103.14 164.11,103.14 163.71,103.14 163.71,103.14 162.86,103.14 162.28,103.72 162,103.72 ; CN1.20 176.39,83.2 176.74,83.55 v1(176.9,83.55)
  L8_IN3 w0.089: v1(176.9,83.55) 176.83,83.55 176.54,83.25 175.9,83.25 175.81,83.34 175.81,83.48 176.21,83.88 176.21,84.01 176.01,84.21 176.01,84.41 176.1,84.5 176.32,84.5 176.4,84.59 176.4,84.77 176.32,84.85 176.1,84.85 176.01,84.94 176.01,85.56 176.4,85.95 176.4,86.09 176.26,86.24 176.26,86.78 176.33,86.85 176.33,87.19 176.26,87.26 176.26,87.89 176.25,87.9 176.25,88.24 176.35,88.34 176.35,88.53 176.25,88.63 176.25,91.41 174.03,93.62 174.03,96.48 168.03,102.48 167.56,102.48 167.47,102.56 167.47,102.85 167.38,102.94 167.2,102.94 167.11,102.85 167.11,102.56 167.02,102.48 166.85,102.48 166.76,102.56 166.76,102.85 166.67,102.94 166.49,102.94 166.4,102.85 166.4,102.56 166.31,102.48 166.14,102.48 166.05,102.56 166.05,102.85 165.96,102.94 165.78,102.94 165.69,102.85 165.69,102.56 165.6,102.48 165.36,102.48 v1(165.06,102.77)
M_A_DQ7: length 39.2
  TOP w0.076: 162.06,104.29 161.95,104.41 161.95,104.78 161.95,104.88 161.68,105.15 161.52,105.15 161.43,105.23 160.5,105.23 U26.BN3
  TOP w0.102: v1(176.92,82.96) 177.39,82.49 CN1.16 ; 162.06,104.29 162.28,104.07 162.87,104.07 163.31,103.63 163.92,103.63 163.92,103.62 v1(163.91,103.62)
  L8_IN3 w0.089: v1(176.92,82.96) 176.16,82.96 176.07,82.87 176.07,82.19 175.98,82.11 175.8,82.11 175.71,82.19 175.71,82.87 175.62,82.96 175.35,82.96 175.23,83.08 175.23,83.74 175.32,83.83 175.63,83.83 175.72,83.92 175.72,84.1 175.63,84.19 175.32,84.19 175.23,84.28 175.23,84.46 175.32,84.54 175.63,84.54 175.72,84.63 175.72,84.81 175.63,84.9 175.32,84.9 175.23,84.99 175.23,85.17 175.32,85.26 175.63,85.26 175.72,85.35 175.72,85.68 175.97,85.92 175.97,87.76 175.95,87.78 175.95,91.28 173.74,93.5 173.74,96.36 167.91,102.18 164.97,102.18 164.59,102.57 164.59,102.94 v1(163.91,103.62)
M_A_DQ8: length 37.2
  TOP w0.076: v1(158.66,105.69) U26.BL4
  TOP w0.102: CN1.24 175.39,82.28 v1(173.9,83.77)
  L8_IN3 w0.089: v1(173.9,83.77) 174.22,83.77 174.44,83.99 174.44,85.72 174.56,85.84 174.77,85.84 175.18,86.26 175.18,87.1 175.17,87.12 175.17,87.63 175.03,87.76 175.03,87.88 175.17,88.01 175.17,88.31 174.94,88.53 174.94,88.66 175.17,88.88 175.17,89.15 175.08,89.24 174.96,89.24 174.87,89.33 174.87,89.5 174.96,89.59 175.08,89.59 175.17,89.68 175.17,89.92 175.04,90.05 174.81,90.05 174.72,90.13 174.72,90.69 174.49,90.92 173.76,90.92 173.67,91.01 173.67,92.46 172.95,93.18 172.95,95.81 167.36,101.4 164.42,101.4 160.66,105.15 159.2,105.15 v1(158.66,105.69)
M_A_DQ9: length 37.6
  TOP w0.076: v1(158.66,106.34) U26.BL5
  TOP w0.102: v1(173.92,83.06) 174.03,83.06 174.39,82.7 CN1.28
  L8_IN3 w0.089: v1(158.66,106.34) 159.58,105.42 161.04,105.42 164.77,101.69 167.48,101.69 173.24,95.93 173.24,93.3 174.45,92.09 174.45,91.96 173.96,91.47 173.96,91.33 174.07,91.21 174.24,91.21 174.7,91.67 174.83,91.67 175.01,91.49 175.01,90.49 175.46,90.04 175.46,87.57 175.47,87.56 175.47,86.13 174.73,85.39 174.73,83.87 v1(173.92,83.06)
M_A_DQ10: length 36
  TOP w0.076: v1(160.62,103.02) 160.59,103.05 160.04,103.05 159.1,103.99 U26.BL2
  TOP w0.102: v1(171.57,83.58) 171.5,83.58 170.9,82.97 CN1.42
  L8_IN3 w0.089: v1(160.62,103.02) 160.57,102.98 160.57,99.76 161.32,99.01 165.23,99.01 165.6,98.64 165.71,98.64 166.09,99.01 166.28,99.01 166.43,98.86 166.43,98.74 166.04,98.34 166.04,98.21 166.16,98.09 166.29,98.09 166.69,98.48 166.81,98.48 167,98.3 167,98.18 166.59,97.77 166.59,97.65 167.04,97.2 167.04,96.71 170.08,93.67 170.08,90.43 171.1,89.41 171.1,87.25 170.53,86.68 170.53,85.2 170.86,84.87 170.86,84.71 170.95,84.62 171.13,84.62 171.22,84.53 171.22,84.35 171.13,84.26 170.95,84.26 170.86,84.17 170.86,83.46 171,83.32 171.27,83.32 171.36,83.41 171.4,83.41 v1(171.57,83.58)
M_A_DQ11: length 34.6
  TOP w0.076: v1(160.22,103.48) 160.06,103.48 159.48,104.06 U26.BM1
  TOP w0.102: v1(171.56,82.93) 172.07,82.42 172.07,82.1 171.9,81.92 CN1.38
  L8_IN3 w0.089: v1(171.56,82.93) 170.74,82.93 170.67,82.86 170.67,82.74 171.02,82.38 171.02,82.25 170.9,82.13 170.77,82.13 170.41,82.48 170.29,82.48 170.09,82.28 169.96,82.28 169.79,82.46 169.79,82.63 170.52,83.36 170.52,84.8 170.24,85.08 170.24,86.8 170.76,87.33 170.76,89.34 169.79,90.31 169.79,93.55 166.75,96.59 166.75,97.08 165.11,98.72 161.3,98.72 160.22,99.8 v1(160.22,103.48)
M_A_DQ12: length 37.6
  TOP w0.076: v1(157.86,105.68) 158.26,106.02 U26.BK4
  TOP w0.102: v1(174.7,86.88) 174.88,86.88 175.14,87.14 CN1.25
  L8_IN3 w0.089: v1(174.7,86.88) 174.6,86.98 174.23,86.98 174.15,86.89 174.15,84.43 173.96,84.25 173.41,84.25 173.32,84.34 173.32,90.13 173.08,90.37 173.08,92.22 172.36,92.93 172.36,95.56 167.12,100.81 163.8,100.81 160.52,104.09 159.45,104.09 v1(157.86,105.68)
M_A_DQ13: length 38.1
  TOP w0.076: v1(157.87,106.34) U26.BK5
  TOP w0.102: v1(174.66,87.46) 174.3,87.46 174.14,87.61 CN1.29
  L8_IN3 w0.089: v1(157.87,106.34) 158.26,105.96 158.26,105.56 158.92,104.9 160.34,104.9 164.13,101.1 167.24,101.1 172.66,95.69 172.66,93.05 173.37,92.34 173.37,90.72 173.46,90.63 174.34,90.63 174.42,90.54 174.42,90.32 174.34,90.23 173.7,90.23 173.61,90.14 173.61,89.92 173.7,89.83 174.49,89.83 174.58,89.74 174.58,89.56 174.49,89.47 173.7,89.47 173.61,89.38 173.61,89.21 173.7,89.12 174.6,89.12 174.69,89.03 174.69,88.85 174.6,88.76 173.7,88.76 173.61,88.67 173.61,88.49 173.7,88.41 174.14,88.41 174.23,88.32 174.23,88.14 174.14,88.05 173.7,88.05 173.61,87.96 173.61,87.59 173.74,87.46 v1(174.66,87.46)
M_A_DQ14: length 35.6
  TOP w0.076: v1(160.95,102.56) 160.2,102.56 U26.BK1
  TOP w0.102: CN1.41 171.14,88.3 171.36,88.09 v1(171.66,88.09)
  L8_IN3 w0.089: v1(171.66,88.09) 171.4,88.36 171.4,89.53 170.92,90.01 170.92,90.81 170.37,91.35 170.37,93.55 170.37,93.79 170.11,94.05 170.11,94.19 170.4,94.48 170.4,94.78 170.3,94.88 170.12,94.88 169.77,94.52 169.64,94.52 169.51,94.65 169.51,94.78 169.87,95.14 169.87,95.26 169.75,95.39 169.62,95.39 169.24,95.01 169.15,95.01 168.99,95.17 168.99,95.26 169.4,95.67 169.4,95.83 169.29,95.94 169.17,95.94 168.75,95.52 168.65,95.52 168.49,95.67 168.49,95.77 169.22,96.49 169.22,96.62 169.09,96.74 168.96,96.74 168.24,96.02 168.15,96.02 167.99,96.18 167.99,96.27 168.67,96.94 168.67,97.1 168.46,97.31 168.34,97.31 167.67,96.64 167.54,96.64 167.42,96.76 167.42,96.89 168.08,97.56 168.08,97.68 167.96,97.81 167.83,97.81 167.6,97.57 167.47,97.57 167.34,97.7 167.34,97.82 167.58,98.06 167.58,98.19 166.46,99.3 161.28,99.3 160.95,99.63 v1(160.95,102.56)
M_A_DQ15: length 36.7
  TOP w0.076: U26.BK2 158.06,104.51 158.06,102.68 158.54,102.2
  TOP w0.102: v1(171.69,87.51) 171.86,87.51 172.14,87.8 172.14,87.89 172.15,87.89 172.15,88.29 172.14,88.29 CN1.37 ; v1(161.38,99.73) 161.01,99.73 158.54,102.2
  L8_IN3 w0.076: 162.06,99.6 161.51,99.6 v1(161.38,99.73)
  L8_IN3 w0.089: 162.06,99.6 162.16,99.6 162.25,99.69 162.25,100.08 162.34,100.17 162.51,100.17 162.6,100.08 162.6,99.69 162.69,99.6 166.7,99.6 169.95,96.34 169.95,96.22 169.69,95.96 169.69,95.83 169.82,95.71 169.94,95.71 170.2,95.97 170.33,95.97 170.45,95.84 170.45,95.72 170.17,95.43 170.17,95.3 170.29,95.18 170.42,95.18 170.71,95.46 170.83,95.46 171.21,95.09 171.21,94.71 171.12,94.62 170.78,94.62 170.69,94.53 170.69,94.35 170.78,94.26 171.12,94.26 171.21,94.18 171.21,94 171.12,93.91 170.78,93.91 170.69,93.82 170.69,93.64 170.78,93.55 171.12,93.55 171.21,93.46 171.21,93.29 171.12,93.2 170.78,93.2 170.69,93.11 170.69,92.93 170.78,92.84 171.12,92.84 171.21,92.75 171.21,92.57 171.12,92.49 170.78,92.49 170.69,92.4 170.69,92.22 170.78,92.13 171.12,92.13 171.21,92.04 171.21,91.86 171.12,91.77 170.78,91.77 170.69,91.69 170.69,91.51 170.78,91.42 171.12,91.42 171.21,91.33 171.21,90.61 171.36,90.46 171.36,90.34 171.25,90.23 171.25,90.1 171.37,89.98 171.5,89.98 171.61,90.09 171.73,90.09 172.14,89.68 172.14,89.37 172.05,89.28 171.78,89.28 171.69,89.19 171.69,89.02 171.78,88.93 172.05,88.93 172.14,88.84 172.14,87.8 171.85,87.51 v1(171.69,87.51)
M_A_DQ16: length 33.2
  TOP w0.076: v1(157.8,102.31) 157.45,102.31 156.69,103.06 156.69,103.55 156.98,103.84 156.98,104.49 156.97,104.49 156.97,105.78 156.74,106.02 U26.BG4
  TOP w0.102: CN1.49 169.14,87.16 169.15,87.16 169.43,86.87 169.43,86.87 169.59,86.72 v1(169.66,86.72)
  L8_IN3 w0.089: v1(157.8,102.31) 158.4,102.31 159.85,100.86 159.85,99.43 161.34,97.93 164.29,97.93 168.9,93.32 168.9,87.37 169.05,87.22 169.05,86.99 168.9,86.84 168.9,86.09 169.51,85.48 169.65,85.48 169.74,85.57 169.74,85.98 169.39,86.33 169.39,86.46 v1(169.66,86.72)
M_A_DQ17: length 33.5
  TOP w0.076: v1(157.68,102.88) 157.12,102.88 156.86,103.15 156.86,103.48 157.15,103.77 157.15,104.55 157.14,104.56 157.14,106.06 U26.BG5
  TOP w0.102: v1(169.63,87.36) 170.14,87.87 CN1.45
  L8_IN3 w0.089: v1(157.68,102.88) 158.08,102.88 160.03,100.93 160.03,99.55 161.36,98.22 164.41,98.22 164.74,97.89 164.87,97.89 164.98,98 165.11,98 165.23,97.88 165.23,97.75 165.12,97.64 165.12,97.51 165.25,97.39 165.37,97.39 165.48,97.5 165.61,97.5 165.74,97.37 165.74,97.25 165.62,97.14 165.62,97.01 165.75,96.89 165.88,96.89 165.99,97 166.11,97 166.24,96.87 166.24,96.75 166.13,96.63 166.13,96.51 169.3,93.34 169.3,92.94 169.19,92.84 169.19,92.59 169.3,92.48 169.3,92.23 169.19,92.13 169.19,91.87 169.3,91.77 169.3,91.52 169.19,91.41 169.19,91.16 169.3,91.06 169.3,90.81 169.19,90.7 169.19,90.21 169.55,89.86 169.55,89.73 169.19,89.38 169.19,89.17 169.36,89 169.49,89 169.88,89.39 170,89.39 170.13,89.26 170.13,89.14 169.64,88.65 169.64,88.49 169.73,88.4 170.08,88.4 170.22,88.26 170.22,87.94 v1(169.63,87.36)
M_A_DQ18: length 33.1
  TOP w0.076: v1(155.35,105.69) U26.BF4
  TOP w0.102: CN1.58 166.9,83.1 166.43,83.57 v1(166.33,83.57)
  L8_IN3 w0.089: v1(155.35,105.69) 156.54,104.51 156.54,102.71 157.39,101.85 157.39,99.14 160.67,95.86 163.45,95.86 166.26,93.05 166.26,88.09 166.12,87.96 166.12,87.82 166.26,87.68 166.26,87.41 166.16,87.31 166.16,87.13 166.26,87.03 166.26,86.75 166.15,86.63 166.15,86.56 166.26,86.45 166.26,85.67 166.17,85.58 165.79,85.58 165.7,85.49 165.7,85.32 165.79,85.23 166.17,85.23 166.26,85.14 166.26,84.85 166.72,84.38 166.72,83.96 v1(166.33,83.57)
M_A_DQ19: length 33.6
  TOP w0.076: v1(155.35,106.34) U26.BF5
  TOP w0.102: CN1.62 165.9,82.5 v1(166.36,82.96)
  L8_IN3 w0.089: v1(166.36,82.96) 166.39,82.96 167.01,83.58 167.01,84.5 166.67,84.85 166.67,85.01 166.72,85.06 166.81,85.06 166.89,85.15 166.89,85.33 166.81,85.42 166.64,85.42 166.55,85.51 166.55,85.68 166.64,85.77 166.79,85.77 166.88,85.86 166.88,86.04 166.79,86.13 166.64,86.13 166.55,86.22 166.55,93.17 163.56,96.17 160.77,96.17 158.62,98.32 158.56,98.32 157.57,99.3 157.57,101.98 156.8,102.75 156.8,104.89 v1(155.35,106.34)
M_A_DQ20: length 32
  TOP w0.076: U26.BG2 156.54,104.46 156.82,104.18 156.82,103.91 156.53,103.62 156.53,102.97 157.57,101.94 158.22,101.94 v1(158.48,101.68)
  TOP w0.102: CN1.50 168.9,82.5 v1(169.38,82.99)
  L8_IN3 w0.089: v1(169.38,82.99) 169.44,82.99 170.01,83.56 170.01,84.57 168.61,85.97 168.61,93.2 164.17,97.64 161.3,97.64 159.65,99.29 159.65,100.52 158.49,101.68 v1(158.48,101.68)
M_A_DQ21: length 31
  TOP w0.076: U26.BG1 156.54,103.86 156.36,103.69 156.36,103.04 156.36,102.91 157.5,101.77 157.7,101.77 157.9,101.57
  TOP w0.102: 157.9,101.57 158.35,101.12 v1(158.51,101.12) ; v1(169.35,83.57) 169.5,83.57 169.9,83.17 CN1.46
  L8_IN3 w0.089: v1(169.35,83.57) 169.72,83.94 169.72,84.45 168.31,85.85 168.31,93.08 164.05,97.35 161.28,97.35 159.43,99.2 159.43,100.48 158.8,101.12 v1(158.51,101.12)
M_A_DQ22: length 31.5
  TOP w0.076: v1(155.35,103.74) U26.BF1
  TOP w0.102: v1(165.72,86.9) 166.65,87.82 CN1.59
  L8_IN3 w0.089: v1(165.72,86.9) 165.72,86.9 165.19,87.42 165.19,87.82 165.36,87.98 165.36,92.3 164.03,93.63 162.71,93.63 162.57,93.49 162.36,93.49 162.25,93.6 162.25,93.75 162.96,94.47 162.96,94.59 162.84,94.72 162.71,94.72 161.96,93.96 161.83,93.96 161.71,94.09 161.71,94.22 162.48,95 162.48,95.12 162.36,95.25 162.23,95.25 161.45,94.47 161.33,94.47 161.2,94.59 161.2,94.72 161.53,95.05 161.53,95.18 161.44,95.27 161.25,95.27 160.95,94.97 160.83,94.97 160.55,95.25 160.44,95.25 157.02,98.67 157.02,101.52 155.84,102.71 155.84,103.25 v1(155.35,103.74)
M_A_DQ23: length 31.7
  TOP w0.076: v1(155.35,104.39) U26.BF2
  TOP w0.102: CN1.63 165.65,87.65 v1(165.67,87.62)
  L8_IN3 w0.089: v1(155.35,104.39) 156.17,103.57 156.17,102.72 157.21,101.68 157.21,98.89 160.55,95.56 162.51,95.56 162.74,95.33 162.86,95.33 163.1,95.57 163.26,95.57 163.37,95.46 163.37,95.33 163.05,95.02 163.05,94.92 163.2,94.77 163.3,94.77 163.61,95.07 163.73,95.07 163.86,94.95 163.86,94.82 163.62,94.58 163.62,94.45 163.74,94.33 163.87,94.33 164.12,94.58 164.25,94.58 164.38,94.46 164.38,94.33 164.12,94.08 164.12,93.95 164.25,93.82 164.37,93.82 164.64,94.09 164.76,94.09 164.89,93.96 164.89,93.84 164.62,93.57 164.62,93.45 164.75,93.32 164.87,93.32 165.16,93.61 165.29,93.61 165.41,93.48 165.41,93.36 165.13,93.07 165.13,92.94 165.25,92.82 165.38,92.82 165.64,93.08 165.76,93.08 165.89,92.95 165.89,92.83 165.65,92.59 165.65,92.33 165.74,92.24 165.9,92.24 165.97,92.18 165.97,91.95 165.9,91.89 165.72,91.89 165.65,91.82 165.65,91.61 165.72,91.53 165.9,91.53 165.97,91.46 165.97,91.25 165.9,91.18 165.71,91.18 165.65,91.12 165.65,90.88 165.71,90.82 165.89,90.82 165.97,90.75 165.97,90.54 165.89,90.47 165.74,90.47 165.65,90.38 165.65,90.06 165.74,89.97 165.9,89.97 165.97,89.91 165.97,89.7 165.89,89.62 165.73,89.62 165.67,89.56 v1(165.67,87.62)
M_A_DQ24: length 30.6
  TOP w0.076: v1(156.5,100.91) 156.12,100.91 155.28,101.76 155.12,101.76 154.3,102.57 154.3,104.2 154.02,104.48 U26.BD2
  TOP w0.102: CN1.71 163.65,88.28 163.57,88.21 163.57,87.87 164.04,87.41 v1(164.09,87.41)
  L8_IN3 w0.089: v1(156.5,100.91) 156.18,100.59 156.18,100 156.5,99.68 156.5,98.08 160.12,94.46 160.22,94.46 162.49,92.19 162.62,92.19 162.83,92.41 162.96,92.41 163.09,92.28 163.09,92.16 162.87,91.94 162.87,91.81 162.99,91.69 163.12,91.69 163.33,91.9 163.45,91.9 163.58,91.77 163.58,91.64 163.37,91.44 163.37,91.31 163.67,91.01 163.67,90.31 163.76,90.22 164.5,90.22 164.57,90.15 164.57,89.94 164.5,89.87 163.76,89.87 163.67,89.78 163.67,89.6 163.76,89.51 164.5,89.51 164.57,89.44 164.57,89.23 164.5,89.16 163.76,89.16 163.67,89.07 163.67,88.49 163.72,88.44 163.95,88.44 164.05,88.53 164.05,88.69 164.12,88.77 164.48,88.77 164.57,88.68 164.57,88.31 164.41,88.14 164.41,87.5 164.32,87.41 v1(164.09,87.41)
M_A_DQ25: length 29.6
  TOP w0.076: v1(156.55,100.33) 156.42,100.33 155.22,101.52 155.1,101.52 154.02,102.6 U26.BD1
  TOP w0.102: CN1.67 164.65,88.29 164.58,88.22 164.58,87.21 164.22,86.85 v1(164.15,86.85)
  L8_IN3 w0.089: v1(164.15,86.85) 164.57,86.42 164.78,86.42 164.93,86.58 164.93,86.74 164.56,87.11 164.56,87.24 164.7,87.37 164.7,88.02 164.86,88.19 164.86,90.51 164.77,90.6 164.59,90.6 164.52,90.67 164.52,90.89 164.59,90.96 164.77,90.96 164.86,91.05 164.86,91.23 164.77,91.32 164.64,91.32 164.57,91.38 164.57,91.6 164.64,91.67 164.77,91.67 164.86,91.76 164.86,92.09 163.96,93 163.76,93 163.67,92.91 163.67,92.45 163.58,92.37 163.41,92.37 163.31,92.46 163.31,92.91 163.23,93 162.92,93 162.83,92.91 162.83,92.78 162.74,92.69 162.57,92.69 162.48,92.78 162.48,92.91 162.39,92.99 162.1,92.99 160.35,94.75 160.24,94.75 156.81,98.18 156.81,100.08 v1(156.55,100.33)
M_A_DQ26: length 32.1
  TOP w0.076: v1(152.84,105.69) U26.BC4
  TOP w0.102: CN1.79 161.65,87.85 161.12,87.33 v1(161.12,86.72)
  L8_IN3 w0.089: v1(161.12,86.72) 161.54,86.72 161.64,86.81 161.64,87.18 161.55,87.26 160.42,87.26 160.33,87.35 160.33,87.53 160.42,87.62 161.55,87.62 161.64,87.71 161.64,88.37 161.55,88.46 160.39,88.46 160.3,88.55 160.3,88.73 160.39,88.82 161.55,88.82 161.62,88.89 161.62,88.97 161.06,89.53 160.94,89.53 160.69,89.28 160.57,89.28 160.44,89.4 160.44,89.53 160.69,89.78 160.69,89.9 160.3,90.29 160.3,91.39 154.77,96.93 154.77,98.3 153.48,99.59 153.48,105.05 v1(152.84,105.69)
M_A_DQ27: length 32.6
  TOP w0.076: v1(152.84,106.34) U26.BC5
  TOP w0.102: CN1.83 160.65,87.91 160.64,87.9 160.64,86.51 160.99,86.16 v1(161.12,86.16)
  L8_IN3 w0.089: v1(161.12,86.16) 161.12,84.91 161.31,84.72 161.74,84.72 161.93,84.91 161.93,89.07 161.54,89.47 161.54,89.59 161.91,89.97 161.91,90.09 161.78,90.22 161.66,90.22 161.28,89.85 161.16,89.85 160.6,90.41 160.6,91.52 155.08,97.03 155.08,98.43 153.79,99.73 153.79,105.39 v1(152.84,106.34)
M_A_DQ28: length 32.7
  TOP w0.076: U26.BD5 154.54,106.15 154.54,104.46 154.63,104.37 154.63,103.19 v1(155.35,102.47)
  TOP w0.102: CN1.70 163.9,82.02 163.8,82.12 163.8,82.63 v1(164.14,82.97)
  L8_IN3 w0.089: v1(164.14,82.97) 164.4,82.97 164.49,83.06 164.49,83.98 164.4,84.07 164.08,84.07 163.97,84.18 163.97,84.3 164.44,84.78 164.44,84.9 164.31,85.03 164.19,85.03 163.93,84.77 163.84,84.77 163.68,84.93 163.68,85.02 163.95,85.29 163.95,85.39 163.79,85.54 163.7,85.54 163.46,85.3 163.33,85.3 163.09,85.55 163.09,85.67 163.3,85.88 163.3,86.04 163.09,86.25 163.09,90.77 159.98,93.87 159.87,93.87 156,97.75 156,99.32 155.58,99.75 155.58,101.04 155.35,101.26 v1(155.35,102.47)
M_A_DQ29: length 31.8
  TOP w0.076: v1(155.8,102.02) 155.23,102.02 154.47,102.78 154.47,104.3 154.31,104.45 154.31,105.72 U26.BD4
  TOP w0.102: CN1.66 164.9,81.98 164.46,82.42 v1(164.28,82.42)
  L8_IN3 w0.089: v1(164.28,82.42) 164.78,82.92 164.78,83.24 164.87,83.33 165.15,83.33 165.24,83.42 165.24,83.6 165.15,83.68 164.87,83.68 164.78,83.77 164.78,83.95 164.87,84.04 165.17,84.04 165.25,84.13 165.25,84.31 165.17,84.4 164.87,84.4 164.78,84.48 164.78,84.97 163.38,86.37 163.38,90.89 160.1,94.17 160,94.17 156.18,97.98 156.18,99.55 155.8,99.93 v1(155.8,102.02)
M_A_DQ30: length 30.4
  TOP w0.102: v1(152.84,103.74) U26.BC1 ; CN1.84 160.39,82.67 160.79,83.06 v1(160.97,83.06)
  L8_IN3 w0.089: v1(152.84,103.74) 152.34,103.24 152.34,99.83 154.16,98.01 154.16,96.71 159.4,91.48 159.4,90.87 159.24,90.72 159.24,90.34 159.33,90.25 159.63,90.25 159.72,90.16 159.72,89.98 159.63,89.89 159.33,89.89 159.24,89.8 159.24,89.63 159.33,89.54 159.63,89.54 159.72,89.45 159.72,89.27 159.63,89.18 159.33,89.18 159.24,89.09 159.24,88.91 159.33,88.83 159.63,88.83 159.72,88.74 159.72,88.56 159.63,88.47 159.33,88.47 159.24,88.38 159.24,88.2 159.33,88.11 159.63,88.11 159.72,88.03 159.72,85.46 161.46,83.72 161.46,83.29 161.23,83.06 v1(160.97,83.06)
M_A_DQ31: length 30.5
  TOP w0.102: v1(152.84,104.39) U26.BC2 ; v1(160.97,82.45) 161.39,82.03 CN1.80
  L8_IN3 w0.089: v1(152.84,104.39) 153.12,104.39 153.23,104.29 153.23,102.8 152.85,102.42 152.85,99.77 154.48,98.14 154.48,96.81 160.01,91.27 160.01,87.01 160.1,86.92 160.48,86.92 160.57,86.83 160.57,86.65 160.48,86.56 160.1,86.56 160.01,86.48 160.01,86.3 160.1,86.21 160.5,86.21 160.59,86.12 160.59,85.94 160.5,85.85 160.1,85.85 160.01,85.76 160.01,85.58 161.75,83.84 161.75,82.92 161.28,82.45 v1(160.97,82.45)
M_A_DQ32: length 28.4
  TOP w0.076: U26.AB1 136.42,101.13 v1(137.05,100.51)
  TOP w0.102: v1(136.4,82.88) 136.47,82.88 136.9,82.46 CN1.170
  L8_IN3 w0.076: v1(137.05,100.51) 137.17,100.39 137.17,98.41 136.64,97.88 136.48,97.88 136.09,97.48
  L8_IN3 w0.089: 136.09,97.48 136.02,97.41 135.89,97.41 135.58,97.72 135.48,97.82 135.36,97.82 135.23,97.7 135.23,97.57 135.32,97.48 135.58,97.22 135.64,97.16 135.64,97.04 135.51,96.91 135.39,96.91 135.25,97.05 135.13,97.05 135,96.92 135,96.8 135.14,96.66 135.14,96.53 133.46,94.85 133.46,89.3 134.8,87.96 134.8,84.11 136.02,82.88 v1(136.4,82.88)
M_A_DQ33: length 29.1
  TOP w0.076: v1(137.27,101.07) 137.27,101.07 136.59,101.76 136.59,103.83 136.7,103.95 136.7,104.44 U26.AB2
  TOP w0.102: v1(136.32,83.51) 135.9,83.09 CN1.174
  L8_IN3 w0.076: 136.5,97.48 137.41,98.4 137.41,100.92 v1(137.27,101.07)
  L8_IN3 w0.089: 136.5,97.48 133.75,94.73 133.75,89.44 135.1,88.09 135.1,87.85 135.1,84.97 135.1,84.73 135.22,84.62 135.22,84.49 135.11,84.38 135.11,84.25 135.23,84.13 135.36,84.13 135.54,84.31 135.77,84.31 135.84,84.24 135.84,84.11 135.59,83.86 135.59,83.73 135.72,83.61 135.84,83.61 136.31,84.07 136.46,84.07 136.57,83.96 136.57,83.77 v1(136.32,83.51)
