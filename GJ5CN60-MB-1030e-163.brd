# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEX_RXN2: length 19.2
  TOP w0.089: U26.D23 123.62,120.01 123.41,119.8 v1(123.29,119.8)
  BOTTOM w0.076: v1(123.29,119.8) 123.29,119.64 123.21,119.56 122.78,119.56 122.63,119.71 121.87,119.71 121.49,120.1 120.46,120.1 120.44,120.11 120.43,120.11
  BOTTOM w0.114: 120.43,120.11 116.05,120.11 109.61,113.68 108.42,113.68 108.28,113.82 108.28,114.01 108.39,114.13 C826.1
PEX_RXN3: length 22.4
  TOP w0.089: U26.F22 124.8,119.41 124.59,119.2 v1(124.59,119.01)
  BOTTOM w0.076: 120.43,119.26 120.44,119.26 120.46,119.24 120.57,119.24 120.85,118.95 121.96,118.95 122.34,118.57 122.84,118.57 123.29,119.02 123.4,119.02 123.78,119.4 124.2,119.4 v1(124.59,119.01)
  BOTTOM w0.114: 120.43,119.26 116.33,119.26 109.73,112.66 106.77,112.66 C828.1
PEX_RXN4: length 19.5
  TOP w0.089: U26.D21 123.62,118.43 123.41,118.23 v1(123.29,118.23)
  BOTTOM w0.076: v1(123.29,118.23) 123.33,118.18 123.33,117.99 123.26,117.91 122.9,117.91 122.73,118.09 121.84,118.09 121.47,118.46 120.5,118.46
  BOTTOM w0.114: C829.1 108.38,111.74 108.38,111.51 108.5,111.39 109.61,111.39 116.72,118.51 120.45,118.51 120.5,118.46
PEX_RXN5: length 22.6
  TOP w0.089: v1(124.59,117.44) 124.59,117.61 124.82,117.83 U26.F20
  BOTTOM w0.076: 120.43,117.63 120.44,117.63 120.45,117.62 120.45,117.61 120.53,117.54 121.63,117.54 122.17,116.99 122.84,116.99 123.27,117.43 123.39,117.43 123.79,117.83 124.12,117.83 124.12,117.83 124.21,117.83 124.59,117.44 v1(124.59,117.44)
  BOTTOM w0.114: 120.43,117.63 116.99,117.63 109.78,110.42 106.73,110.42 C831.1
PEX_RXN6: length 19.9
  TOP w0.089: U26.D19 123.58,117.01 123.58,116.77 123.45,116.64 123.32,116.64 v1(123.29,116.67)
  BOTTOM w0.076: 120.43,116.84 120.56,116.84 120.79,117.07 121.33,117.07 122.03,116.38 123.28,116.38 123.38,116.48 123.38,116.58 v1(123.29,116.67)
  BOTTOM w0.114: 120.43,116.84 117.26,116.84 109.51,109.1 108.56,109.1 108.41,109.25 108.41,109.48 C833.1
PEX_RXN7: length 22.6
  TOP w0.076: v1(124.62,115.85) 124.62,116.09 124.78,116.26 U26.F18
  BOTTOM w0.076: 120.43,116.13 120.44,116.13 120.64,115.93 121.39,115.93 121.49,116.03 123.53,116.03 123.74,116.23 124.11,116.23 124.49,115.85 v1(124.62,115.85)
  BOTTOM w0.114: 120.43,116.13 117.59,116.13 109.59,108.13 106.73,108.13 C834.1
PEX_RXN8: length 20
  TOP w0.076: U26.E17 124.27,115.4 v1(123.94,115.08)
  BOTTOM w0.076: v1(123.94,115.08) 123.9,115.08 123.33,115.65 122.31,115.65 122.05,115.39 120.43,115.39
  BOTTOM w0.114: C847.1 108.53,107.09 109.54,107.09 117.84,115.39 120.43,115.39
PEX_RXN9: length 23.4
  TOP w0.076: v1(124.58,115.07) 124.27,114.76 U26.E16
  BOTTOM w0.076: v1(124.58,115.07) 124.58,114.83 124.5,114.76 124.19,114.76 123.96,114.53 121.42,114.53 121.17,114.28 120.5,114.28 120.45,114.32 120.43,114.32
  BOTTOM w0.114: C851.1 106.5,106 106.83,105.67 110,105.67 110.96,106.63 110.96,107.52 117.76,114.32 120.43,114.32
PEX_RXN10: length 21.8
  TOP w0.089: v1(124.59,113.5) 124.47,113.5 124.27,113.71 U26.E15
  BOTTOM w0.076: v1(124.59,113.5) 124.39,113.7 124.39,113.84 124.08,114.15 121.8,114.15 121.42,113.77 120.79,113.77 120.51,113.49 120.45,113.49 120.43,113.48
  BOTTOM w0.114: C853.1 108.79,104.54 110,104.54 111.66,106.2 111.66,107.23 117.79,113.36 120.32,113.36 120.43,113.48
PEX_RXN11: length 24.6
  TOP w0.089: U26.E14 124.55,112.82 v1(124.55,112.72)
  BOTTOM w0.076: v1(124.55,112.72) 124.73,112.72 124.85,112.6 124.85,112.42 124.7,112.27 124.34,112.27 123.68,112.93 121.63,112.93 121.3,112.6 120.5,112.6 120.45,112.65 120.43,112.65
  BOTTOM w0.114: C855.1 106.45,103.56 106.7,103.31 109.75,103.31 112.36,105.91 112.36,106.94 118.06,112.65 120.43,112.65
PEX_RXN12: length 21.6
  TOP w0.076: v1(123.94,111.93) 124.27,112.25 U26.E13
  BOTTOM w0.076: v1(123.94,111.93) 123.9,111.93 123.74,112.09 123.74,112.27 123.46,112.55 122.14,112.55 121.67,112.08 121.67,111.64 121.32,111.29 120.5,111.29 120.45,111.33 120.43,111.33
  BOTTOM w0.114: 120.43,111.33 117.73,111.33 113.05,106.65 113.05,105.63 109.71,102.28 108.77,102.28 C867.1
PEX_RXN13: length 24.6
  TOP w0.089: v1(124.59,111.14) 124.63,111.18 124.63,111.32 124.42,111.53 U26.E12
  BOTTOM w0.076: 120.43,110.61 120.45,110.61 120.5,110.57 121.4,110.57 121.79,110.96 123.4,110.96 123.58,111.14 123.91,111.14 124.43,111.65 124.6,111.65 124.78,111.48 124.78,111.33 v1(124.59,111.14)
  BOTTOM w0.114: 120.43,110.61 118,110.61 113.75,106.36 113.75,105.34 109.52,101.1 106.77,101.1 C1223.1
PEX_RXN14: length 22.1
  TOP w0.089: U26.E11 124.27,110.54 124.46,110.35 v1(124.59,110.35)
  BOTTOM w0.076: 120.43,109.6 120.44,109.6 120.45,109.59 120.45,109.59 120.53,109.52 121.49,109.52 121.91,109.93 122.92,109.93 123.33,110.34 123.37,110.34 123.8,110.77 124.08,110.77 124.5,110.35 v1(124.59,110.35)
  BOTTOM w0.114: 120.43,109.6 117.98,109.6 114.45,106.07 114.45,105.02 109.51,100.08 108.69,100.08 C1225.1
PEX_RXN15: length 24.3
  TOP w0.089: v1(123.94,109.57) 124.06,109.57 124.27,109.77 U26.E10
  BOTTOM w0.076: 120.43,108.86 120.45,108.86 120.5,108.81 121.17,108.81 121.28,108.93 121.66,108.93 122.19,109.45 123.46,109.45 123.53,109.52 123.53,109.75 123.58,109.8 123.94,109.8 123.99,109.75 123.99,109.62 v1(123.94,109.57)
  BOTTOM w0.114: 120.43,108.86 118.29,108.86 115.15,105.72 115.15,104.32 109.52,98.69 106.6,98.69 106.45,98.84 C1227.1
PEX_RXP0: length 18.9
  TOP w0.089: U26.E25 123.94,121.44 v1(123.94,121.38)
  BOTTOM w0.076: v1(123.94,121.38) 123.86,121.38 123.48,121.01 121.97,121.01 121.4,121.57 120.45,121.57 120.43,121.57
  BOTTOM w0.114: 120.43,121.57 115.18,121.57 109.33,115.72 108.68,115.72 C788.1
PEX_RXP1: length 22.3
  TOP w0.089: v1(123.94,120.59) 124.1,120.59 124.27,120.75 U26.E24
  BOTTOM w0.076: 120.43,120.61 121.73,120.61 122.3,120.04 122.92,120.04 123.1,120.22 124.12,120.22 124.21,120.3 124.21,120.47 124.08,120.59 v1(123.94,120.59)
  BOTTOM w0.114: 120.43,120.61 115.74,120.61 109.92,114.79 106.37,114.79 106.25,114.67 106.25,114.49 106.37,114.38 C821.1
PEX_RXP2: length 19.2
  TOP w0.089: U26.E23 124.18,120.19 123.94,119.96 v1(123.94,119.8)
  BOTTOM w0.076: 120.43,119.87 120.53,119.87 120.6,119.94 121.42,119.94 121.8,119.56 122.57,119.56 122.72,119.41 123.46,119.41 123.86,119.8 v1(123.94,119.8)
  BOTTOM w0.114: 120.43,119.87 116.15,119.87 109.71,113.44 108.68,113.44 C823.1
PEX_RXP3: length 22.4
  TOP w0.089: U26.E22 124.27,119.22 124.06,119.01 v1(123.94,119.01)
  BOTTOM w0.076: v1(123.94,119.01) 124.14,119.01 124.23,118.92 124.23,118.72 124.13,118.61 123.79,118.61 123.53,118.87 123.35,118.87 122.9,118.42 122.27,118.42 121.89,118.8 120.79,118.8 120.57,119.01 120.43,119.01
  BOTTOM w0.114: 120.43,119.01 116.43,119.01 109.83,112.42 106.77,112.42 C825.1
PEX_RXP4: length 19.5
  TOP w0.089: U26.E21 124.27,118.56 123.94,118.24 v1(123.94,118.23)
  BOTTOM w0.076: 120.43,118.27 120.58,118.27 120.62,118.31 121.4,118.31 121.78,117.94 122.67,117.94 122.86,117.75 123.43,117.75 123.91,118.23 v1(123.94,118.23)
  BOTTOM w0.114: 120.43,118.27 116.82,118.27 109.71,111.15 108.68,111.15 C789.1
PEX_RXP5: length 22.6
  TOP w0.089: v1(123.94,117.44) 124.07,117.44 124.27,117.63 U26.E20
  BOTTOM w0.076: v1(123.94,117.44) 124.14,117.44 124.22,117.36 124.22,117.14 124.12,117.04 123.74,117.04 123.5,117.27 123.34,117.27 122.9,116.84 122.11,116.84 121.56,117.39 120.43,117.39
  BOTTOM w0.114: C827.1 106.45,109.85 106.77,110.17 109.88,110.17 117.09,117.39 120.43,117.39
PEX_RXP6: length 19.9
  TOP w0.089: v1(123.94,116.65) 123.94,116.72 U26.E19
  BOTTOM w0.076: 120.43,116.6 120.53,116.6 120.6,116.67 120.85,116.92 121.27,116.92 121.97,116.22 123.45,116.22 123.88,116.65 v1(123.94,116.65)
  BOTTOM w0.114: 120.43,116.6 117.36,116.6 109.61,108.86 108.67,108.86 C830.1
PEX_RXP7: length 22.6
  TOP w0.076: v1(123.94,115.86) 124,115.86 124.27,116.13 U26.E18
  BOTTOM w0.076: 120.43,115.89 120.46,115.89 120.57,115.78 121.45,115.78 121.55,115.88 123.38,115.88 123.79,115.47 124.12,115.47 124.2,115.54 124.2,115.75 124.08,115.86 v1(123.94,115.86)
  BOTTOM w0.114: 120.43,115.89 117.69,115.89 109.69,107.89 106.82,107.89 C832.1
PEX_RXP8: length 20
  TOP w0.089: U26.D17 123.62,115.28 123.41,115.08 v1(123.29,115.08)
  BOTTOM w0.076: 120.49,115.2 120.53,115.24 122.11,115.24 122.37,115.5 123.24,115.5 123.41,115.33 123.41,115.19 v1(123.29,115.08)
  BOTTOM w0.114: C848.1 108.36,106.74 108.47,106.85 109.64,106.85 117.94,115.15 120.44,115.15 120.49,115.2
PEX_RXP9: length 23.4
  TOP w0.076: U26.F16 124.92,114.65 124.6,114.34 v1(124.63,114.34)
  BOTTOM w0.076: 120.43,114.08 120.45,114.08 120.5,114.13 121.23,114.13 121.49,114.38 124.03,114.38 124.25,114.6 124.55,114.6 124.63,114.53 v1(124.63,114.34)
  BOTTOM w0.114: 120.43,114.08 117.86,114.08 111.2,107.42 111.2,106.53 110.1,105.43 106.83,105.43 106.5,105.11 C846.1
PEX_RXP10: length 21.8
  TOP w0.089: U26.D15 123.73,113.89 123.97,113.66 123.97,113.53 v1(123.94,113.5)
  BOTTOM w0.076: 120.61,113.31 120.62,113.32 120.62,113.38 120.85,113.62 121.49,113.62 121.87,114 124.01,114 124.23,113.78 124.23,113.59 124.14,113.5 v1(123.94,113.5)
  BOTTOM w0.114: C854.1 108.82,104.3 110.1,104.3 111.9,106.1 111.9,107.13 117.89,113.12 120.42,113.12 120.61,113.31
PEX_RXP11: length 24.7
  TOP w0.089: v1(125.21,112.76) 125.13,112.76 124.92,112.98 U26.F14
  BOTTOM w0.076: 120.43,112.4 120.45,112.4 120.5,112.45 121.36,112.45 121.69,112.78 123.62,112.78 124.28,112.12 124.76,112.12 125,112.36 125,112.55 v1(125.21,112.76)
  BOTTOM w0.114: 120.43,112.4 118.16,112.4 112.6,106.84 112.6,105.81 109.85,103.07 106.7,103.07 C852.1
PEX_RXP12: length 21.6
  TOP w0.076: U26.D13 123.62,112.25 v1(123.29,111.93)
  BOTTOM w0.076: v1(123.29,111.93) 123.5,111.93 123.58,112.01 123.58,112.21 123.4,112.4 122.2,112.4 121.82,112.01 121.82,111.58 121.38,111.13 120.5,111.13 120.45,111.09 120.43,111.09
  BOTTOM w0.114: C868.1 108.45,101.75 108.74,102.04 109.81,102.04 113.3,105.53 113.3,106.55 117.83,111.09 120.43,111.09
PEX_RXP13: length 24.6
  TOP w0.089: v1(125.24,111.14) 125.1,111.14 124.92,111.32 U26.F12
  BOTTOM w0.076: 120.43,110.37 120.45,110.37 120.5,110.42 121.46,110.42 121.85,110.8 123.46,110.8 123.64,110.99 124.22,110.99 124.46,110.75 124.74,110.75 125.13,111.14 v1(125.24,111.14)
  BOTTOM w0.114: C859.1 106.77,100.86 109.62,100.86 113.99,105.24 113.99,106.26 118.1,110.37 120.43,110.37
PEX_RXP14: length 22.1
  TOP w0.089: v1(123.94,110.35) 123.94,110.58 123.78,110.74 U26.D11
  BOTTOM w0.076: 120.43,109.36 121.55,109.36 121.97,109.78 122.99,109.78 123.17,109.97 124.13,109.97 124.25,110.09 124.25,110.21 124.12,110.35 v1(123.94,110.35)
  BOTTOM w0.114: C1226.1 108.48,99.72 108.6,99.83 109.61,99.83 114.69,104.92 114.69,105.97 118.08,109.36 120.43,109.36
PEX_RXP15: length 24.3
  TOP w0.089: U26.F10 124.84,109.96 124.59,109.71 v1(124.59,109.57)
  BOTTOM w0.076: 120.43,108.61 120.45,108.61 120.5,108.66 121.23,108.66 121.34,108.77 121.72,108.77 122.25,109.3 123.68,109.3 123.81,109.17 124.2,109.17 v1(124.59,109.57)
  BOTTOM w0.114: 120.43,108.61 118.39,108.61 115.39,105.62 115.39,104.22 109.62,98.45 106.65,98.45 C1224.1
PEX_TERMP: length 2.7
  TOP w0.1: G1.BL44 95.62,110.88 95.96,110.54 97.03,110.54 v6(97.04,110.53)
  BOTTOM w0.1: v6(97.04,110.53) 97.42,110.15
  BOTTOM w0.102: 97.42,110.15 R2729.2
PEX_VCC_FB: length 11.5
  TOP w0.305: 83.39,55.32 84.02,55.32 84.29,55.59 U30.6
  TOP w0.508: C333.1 v1(83.64,64.34) ; 83.39,55.32 83.13,55.58 R215.1 R178.2 83.08,56.54 v1(83.64,57.1)
  L8_IN3 w0.508: v1(83.64,64.34) v1(83.64,57.1)
PEX_VDD: length 9.9
  TOP w0.508: v1(81.74,57.23) 82.17,56.8 R178.1
  BOTTOM w0.508: v1(85.04,64.85) 85.04,60.53 v1(81.74,57.23)
  vias: v3(95.96,89.61) v5(84.15,74.25) v5(85.17,74.25) v6(88.7,94.8) v6(88.69,92.86) v6(88.7,90.83) v6(88.8,105.53) v6(88.8,104.33) v6(88.8,103.43) v6(88.8,95.93) v6(88.8,93.83) v6(89.55,105.58) v6(89.55,104.28) v6(89.55,103.48) v6(89.55,95.88) v6(89.55,95.08) v6(89.55,93.78) v6(89.51,92.97) v6(89.55,91.68) v6(89.55,90.88) v6(90.25,105.58) v6(90.25,103.48)
PEX_VDD_ON_R: length 2.8
  TOP w0.102: R849.2 C1426.1 83.74,59.41 83.84,59.52 84.15,59.52 84.29,59.37 U30.5
PFM_+1.0VA: length 3
  TOP w0.254: R62.2 R87.1 88.34,45.93 87.83,45.41 U17.3
PFM_+3.3VA: length 2.7
  TOP w0.305: v1(177.37,13.8) 177.53,13.95 U12.3
  BOTTOM w0.305: v1(177.37,13.8) 177.44,13.87 R61.2 R68.1
PFM_VCCIO: length 3.9
  TOP w0.254: R70.1 99.8,164.09 99.8,162.87 R65.2 99.31,161.95 99.51,161.75 U18.3
PG_+1.0VA: length 100.9
  TOP w0.102: v1(137.95,6.19) 138.4,6.19 139.27,7.06 D3.3 138.25,8.08 136.22,10.11 D29.C
  TOP w0.203: v1(90.88,45.98) 90.75,45.85 R931.1
  TOP w0.254: R931.1 89.66,45.85 88.83,45.02 U17.1
  L6_IN2 w0.089: v1(90.88,45.98) 90.78,45.88 90.02,45.88 85.71,41.56 85.71,23.66 88.46,20.91 88.46,14.66 89.91,13.21 89.91,12.82 91.27,11.46 91.27,10.58 91.5,10.35 95.81,10.35 98.18,12.71 113.35,12.71 116.81,9.24 120.29,9.24 121.34,8.2 121.34,7.21 122.15,6.4 133.71,6.4 133.94,6.18 133.97,6.18 135.96,6.18 137.94,6.18 v1(137.95,6.19)
PG_+1.8VA: length 170.5
  TOP w0.102: v1(64.62,62.41) 64.38,62.17 U19.4 ; R63.2 175.13,13.16 174.61,13.16 171.45,10 171.45,7.19 166.54,2.29 v1(165.05,2.29)
  L6_IN2 w0.089: v1(165.05,2.29) 165.05,3.25 160.76,7.55 147.78,7.55 146.57,6.33 145.23,6.33 144.93,6.63 144.4,6.63 143.58,5.81 139.51,5.81 138.89,5.18 133.98,5.18 133.37,5.79 121.89,5.79 121.28,6.41 113.25,6.41 111.71,7.95 103.71,7.95 102.11,6.35 97.87,6.35 97.29,6.94 87.83,6.94 84.66,10.11 84.66,13.29 v1(84.4,13.54)
  L8_IN3 w0.089: v1(64.59,57.48) 65.08,57.97 68.51,57.97 70.12,56.36 70.12,54.08 75.74,48.47 75.89,48.47 77.16,47.2 77.16,44.02 78.56,42.62 78.56,40.72 84.54,34.74 84.54,16.58 84.93,16.18 84.93,14.81 84.4,14.28 v1(84.4,13.54)
  BOTTOM w0.102: v1(64.59,57.48) 64.62,57.51 v1(64.62,62.41) 64.31,62.11 R942.2
PG_+3.3VA: length 139.4
  TOP w0.102: v1(89.15,48.62) 89.18,48.59 90.17,48.59 R64.2 ; R889.1 v1(176.44,15.99)
  TOP w0.305: U12.1 176.84,14.95 R889.1
  L3_IN1 w0.089: v1(182.04,39.43) 179.62,37.01 179.62,32.79 177.1,30.27 177.1,19.11 176.44,18.45 v1(176.44,15.99)
  BOTTOM w0.102: v1(89.15,48.62) 89.18,48.59 89.61,48.59 89.64,48.62 89.64,49.26 88.57,50.33 88.57,50.96 87.81,51.72 87.81,52.76 91.26,56.21 97.48,56.21 99.01,54.69 100.77,54.69 100.9,54.56 102.58,54.56 102.96,54.94 126.07,54.94 129.69,51.32 129.69,49.69 134.17,45.22 144.02,45.22 144.68,45.88 156.21,45.88 157.59,44.5 171.38,44.5 176.32,39.55 181.92,39.55 v1(182.04,39.43)
PG_+5VA: length 192.3
  TOP w0.102: R93.2 v1(63.3,64.95)
  TOP w0.254: v1(192.18,96.73) 192.18,97.11 R225.1 191.67,97.21 191.67,96.65 191.36,96.35 190.94,96.35 190.68,96.09 U9.1
  L8_IN3 w0.089: v1(192.18,96.73) 192.1,96.73 191.16,95.79 191.16,85.88 188.92,83.65 188.92,65.74 184.73,61.55 184.73,47.83 184.23,47.32 184.23,46.43 184.71,45.95 184.71,45.44 v1(184.99,45.16)
  BOTTOM w0.102: v1(184.99,45.16) 184.73,45.16 183.72,44.15 175.18,44.15 172.29,47.04 164.44,47.04 154.35,57.13 132.83,57.13 129.68,60.28 108.58,60.28 105.91,62.94 102.69,62.94 102.44,62.69 99.26,62.69 96.47,65.48 91.9,65.48 90.5,66.88 84.4,66.88 83.39,65.87 78.94,65.87 78.43,66.37 64.72,66.37 v1(63.3,64.95)
PG_FBVDDQ: length 121.3
  TOP w0.102: D52.2 75.96,53.29 D4.2 74.81,55.13 75.51,55.83 v1(75.51,56.21) ; R3537.2 9.4,103.79 10.74,102.44 13.54,102.44 14.96,101.02 15.54,101.02 v1(15.82,101.3)
  TOP w0.254: U84.1 7.93,104.85 8.19,105.11 R3537.2
  L8_IN3 w0.089: v1(75.51,56.21) 75.49,56.24 75.49,63.99 70.2,69.27 55.42,69.27 55.04,68.89 54.31,68.89 53.02,67.6 30.86,67.6 28.68,69.78 28.48,69.78 27.85,70.41 22.96,70.41 21.2,72.16 14.41,72.16 13.67,72.9 13.67,77.39 15.12,78.84 15.12,100.59 v1(15.82,101.3)
PG_PEX_VDD: length 139
  TOP w0.102: v1(15.19,101.43) 15.19,101.93 14.93,102.19 14.93,103.43 15.92,104.42 15.92,105.39 15.8,105.51 13.77,105.51 13.03,106.25 13.03,107.23 12.61,107.65 10.71,107.65 9.5,108.85 D16.1 8.46,109.87 8.46,112.09 8.82,112.46 Q165.1 ; D52.1 80.28,53.48 v1(80.85,54.05) 81.08,54.28 81.08,58.83 81.61,59.36 82.96,59.36 83.08,59.49 R3536.2 83.13,59.82 83.74,59.82 83.82,59.74 84.68,59.74 84.79,59.63 U30.4
  L8_IN3 w0.089: v1(15.19,101.43) 15.19,101.3 14.92,101.03 14.92,78.92 13.47,77.47 13.47,72.82 14.33,71.96 21.11,71.96 22.87,70.2 27.77,70.2 28.4,69.57 28.6,69.57 30.77,67.4 53.1,67.4 54.39,68.68 55.12,68.68 55.5,69.07 69.65,69.07 74.5,64.21 74.5,56.41 75.35,55.56 76.41,55.56 77.91,54.05 v1(80.85,54.05)
PG_VCCIO: length 2.4
  TOP w0.254: R937.1 101.5,161.75 100.66,161.75 100.51,161.6 U18.1
PH1_NVD: length 28.3
  TOP w0.305: U722.24 17.73,118.32 17.47,118.57 14.63,118.57 C273.2
  TOP w0.508: R991.1 25.68,115.7 v1(25.22,116.16) ; C273.2 v1(14.5,119.71)
  BOTTOM w0.508: v1(22.68,124.41) 25.98,121.11 25.98,116.92 v1(25.22,116.16) 23.95,117.43 20.9,117.43 18.62,119.71 v1(14.5,119.71)
PH2_NVD: length 32.8
  TOP w0.305: 21.16,118.57 20.45,118.57 20.27,118.39 U722.19
  TOP w0.508: R990.1 25.68,113.82 v1(25.22,113.36) ; v1(21.54,118.19) 21.16,118.57 ; R1061.1 v1(21.03,137.62) ; C272.2 v1(23.19,116.79)
  L6_IN2 w0.508: v1(21.54,118.19) 22.43,118.19 23.19,117.43 v1(23.19,116.79) 23.19,115.4 v1(25.22,113.36)
  BOTTOM w0.508: v1(21.03,137.62) 20.01,137.62 19.25,136.86 19.25,122.51 21.03,120.73 21.03,118.7 v1(21.54,118.19)
PH3_NVD: length 56.2
  TOP w0.254: L11.1 21.68,153.94
  TOP w0.508: 21.68,153.94 R1064.1 22.6,149.94 R1066.1 ; R995.1 v1(25.68,111.94)
  L3_IN1 w0.508: v1(25.68,111.94) 23.95,113.67 23.95,117.55 23.32,118.19 23.32,121.87 22.3,122.89 20.65,122.89 18.74,124.79 18.74,147.65 21.03,149.94 v1(21.03,151.97)
  BOTTOM w0.254: 21.54,149.81 21.54,149.35 21.28,149.1 U32.8
  BOTTOM w0.508: v1(21.03,151.97) 21.54,151.46 21.54,149.81 ; R1066.1 v1(22.73,151.79)
PHASE_GCORE1: length 8.7
  TOP w0.381: 16.79,75.21 16.84,75.26
  TOP w0.508: 16.79,75.21 R973.2 17.86,73.61 18.36,74.12 v1(20.78,74.12)
  BOTTOM w0.203: U721.20 20.81,72.48 21.03,72.7
  BOTTOM w0.508: 21.03,72.7 21.41,73.08 C720.2 21.11,73.79 v1(20.78,74.12)
PID_2_PWR_LED0: length 2.3
  TOP w0.102: R316.2 C436.1 180.17,158.63 Q30.G
PIRQA#: length 6.7
  TOP w0.089: U28.BA36 v2(123.34,18.23)
  BOTTOM w0.102: v2(123.34,18.23) 123.34,17.8 123.29,17.75 123.29,17.2 123.52,16.97 123.52,15.95 123.19,15.62 123.19,14.98 122.96,14.75 122.96,13.59 123.7,12.86 R339.1
PLT_RST#: length 246.5
  TOP w0.089: v2(119.2,17.68) 119.4,17.88 119.4,19.53 U28.AV29
  TOP w0.102: v1(94.56,23.07) 94.99,23.07 R95.2 ; v1(174.57,32.21) 174.57,32.21 CNSSD2.50 ; v1(152.16,32.08) 151.57,31.5 CNSSD1.50 ; v1(97.61,63.33) 98.88,63.33 99.39,62.82 102.31,62.82 104.98,65.48 104.98,67.98 Q99.1 ; v1(93.8,48.34) 93.84,48.37 U1901.19 ; CNWLAN1.52 92.7,12.86 v1(92.56,13.01)
  L3_IN1 w0.089: v1(157.3,19.28) 157.68,19.66 157.68,22.81 157.36,23.13 155.08,23.13 153.49,24.72 153.49,28.02 152.16,29.35 v1(152.16,32.08)
  L6_IN2 w0.089: v1(157.3,19.28) 156.94,19.64 152.82,19.64 151.1,17.92 150.25,17.92 148.59,16.26 148.59,13.83 145.63,10.86 128.99,10.86 128.35,11.51 124.28,11.51 122.63,13.16 122.63,14.25 v2(119.2,17.68) 118.16,17.68 117.45,16.97 117.45,16.51 116.76,15.83 113.64,15.83 112.72,14.91 108.72,14.91 107.8,14 99.19,14 98.47,14.71 94.26,14.71 v1(92.56,13.01) ; v1(177.75,5.29) 177.11,4.65 166.19,4.65 163.75,7.09 163.75,7.7 164.77,8.72 167.33,8.72 167.92,9.3 167.92,10.04 166.35,11.6 166.35,14.98 164.43,16.9 164.43,18.48 v1(164.16,18.75)
  L8_IN3 w0.089: v1(174.57,32.21) 174.07,32.72 166.95,32.72 165.16,30.92 153.32,30.92 v1(152.16,32.08) ; v1(92.56,13.01) 92.56,15.9 93.06,16.41 93.06,21.57 v1(94.56,23.07) 95.99,24.49 95.99,35.53 97.52,37.06 97.52,43.99 93.8,47.7 v1(93.8,48.34) 93.8,49.48 91.13,52.15 91.1,52.15 90.53,52.71 90.53,53.11 90.63,53.2 90.63,54.31 92.73,56.41 94.79,56.41 96.55,58.17 98.77,58.17 99.36,58.76 99.36,61.96 99.01,62.31 98.06,62.31 97.72,62.65 97.72,63.22 v1(97.61,63.33)
  BOTTOM w0.102: R67.2 119.46,18.52 119.4,18.47 119.4,17.88 v2(119.2,17.68) ; CNDEG1.4 177.93,5.1 v1(177.75,5.29) ; v1(164.16,18.75) 164.12,18.71 U5.22 158.42,18.71 157.85,19.28 v1(157.3,19.28)
PM_CLKRUN#: length 36.7
  TOP w0.089: U28.AV32 121.13,19.69 v2(121.49,19.33)
  L3_IN1 w0.089: v2(121.49,19.33) 121.72,19.33 122.2,19.82 122.2,20.5 122.51,20.81 124.54,20.81 125.12,21.39 125.58,21.39 126.38,20.59 127.22,20.59 130.45,17.35 134.21,17.35 134.95,18.09 134.95,21.77 137.36,24.18 138.73,24.18 v1(140.54,25.99)
  BOTTOM w0.102: R273.1 121.87,19.71 v2(121.49,19.33) ; U5.93 145.82,25.91 144.98,26.75 142.19,26.75 141.43,25.99 v1(140.54,25.99)
PM_DOWN: length 184.4
  TOP w0.076: U28.AE2 106.12,25.84 v1(106,25.96)
  TOP w0.102: v1(174.83,126.95) 174.83,127.33 172.97,129.19 168.5,129.19 R21.1
  L3_IN1 w0.089: v1(106,25.96) 107.14,27.1 107.86,27.1 108.22,27.46 109.69,27.46 112.23,30 112.68,30 113.69,31.01 116.72,31.01 117.67,31.96 118.95,31.96 120.14,30.76 125.86,30.76 127.58,29.04 128.35,29.04 128.85,28.53 129.36,28.53 130.28,29.44 130.28,36 130.8,36.52 130.8,46.55 145.83,61.59 165.47,61.59 169.11,65.22 181.31,65.22 183.86,67.78 183.86,73.1 181.32,75.65 181.32,80.95 181.67,81.3 181.67,83.12 183.34,84.79 183.34,85.55 181.72,87.16 181.72,95.65 178,99.38 178,103.48 182.75,108.23 182.75,113.9 175.6,121.04 175.6,125.97 174.83,126.75 v1(174.83,126.95)
PM_DOWN_R: length 8.4
  TOP w0.076: 164.3,128 163.69,127.39 163.69,126.78 162.83,125.92 161.28,125.92 160.99,126.21 U26.BP31
  TOP w0.102: R21.2 165.41,129.11 164.3,128
PM_RSMRST#: length 29
  TOP w0.076: 131.14,16.24 130.89,16.49 130.89,17.17 130.45,17.6 128.99,17.6 128.97,17.59 128.76,17.59 128.58,17.77 U28.BA47
  TOP w0.102: 134.49,13.29 R285.2 133.6,14.34 132.92,15.03 132.92,15.45 132.66,15.7 131.68,15.7 131.14,16.24 ; 134.49,13.29 R311.1 ; 134.49,13.29 R299.2 133.6,12.35 133.96,11.99 134.97,11.99 135.46,11.51 v1(135.46,9.12)
  BOTTOM w0.102: v1(135.46,9.12) 137.16,9.12 141.45,13.41 144.86,13.41 146.55,15.11 U5.66
PM_SLP_S3#: length 331
  TOP w0.076: U28.BF42 126.08,15.55 126.36,15.27 126.36,14.27 126.44,14.2 126.44,13.69 v1(126.8,13.33)
  TOP w0.102: R172.2 190.3,103.48 v1(190.07,103.48) ; v1(178.64,135.84) 178.76,135.84 179.15,136.22 U23.2
  L3_IN1 w0.089: v1(112.39,127.1) 113,127.71 113,131.47 114.2,132.67 v1(114.2,133.45) 114.2,134.45 112.97,135.68 112.97,148.31 110.23,151.04 110.23,158.12 107.75,160.61 102.31,160.61 101.8,161.12 98.12,161.12 96.72,162.51 v1(94.69,162.51)
  L6_IN2 w0.089: v1(114.2,133.45) 114.81,134.06 119.58,134.06 121.49,132.16 143.08,132.16 144.35,130.89 153.87,130.89 154.13,130.64 154.63,130.64 154.76,130.76 155.78,130.76 155.81,130.73 156.38,130.73 156.51,130.86 159.17,130.86 159.75,130.27 161.73,130.27 162.38,129.62 163.52,129.62 163.91,130 172.29,130 178.13,135.84 v1(178.64,135.84) ; v1(126.8,13.33) 126.99,13.33 127.81,14.15 133.2,14.15 134.26,13.08 141.75,13.08 144.71,16.04 144.71,17.2 149.03,21.52 149.09,21.52 150.5,22.94 152.08,22.94 v1(152.34,23.2) 152.67,23.53 158.33,23.53 160.09,25.29 161.78,25.29 162.06,25.01 171.56,25.01 172.59,26.04 177.16,26.04 179.5,28.37 180.84,28.37 181.93,29.47 182.54,29.47 185.26,32.19 v1(185.26,42.61)
  L8_IN3 w0.089: v1(185.26,42.61) 184.88,42.99 181.7,42.99 180.26,44.43 180.26,45.19 180.16,45.29 180.16,46.11 181.91,47.86 181.91,62.28 186.71,67.09 186.71,76.48 185.57,77.62 185.57,98.14 190.07,102.64 v1(190.07,103.48) 190.41,103.83 190.41,104.92 191.26,105.77 191.26,107.16 191.92,107.82 191.92,130.71 186.78,135.84 v1(178.64,135.84)
  BOTTOM w0.089: U24.2 97.87,160.1 97.74,160.23 97.74,161.24 96.47,162.51 v1(94.69,162.51)
  BOTTOM w0.102: U5.109 153.62,24.33 152.48,23.2 v1(152.34,23.2) ; R3377.1 111.45,128.12 112.04,128.12 112.39,127.77 v1(112.39,127.1)
PM_SLP_S4#: length 332.1
  TOP w0.076: v1(126.82,13.89) 126.82,14.43 126.53,14.72 126.53,15.61 126.09,16.06 U28.BE42
  TOP w0.102: R156.1 190.93,101.6 190.55,101.22 v1(187.86,101.22)
  L3_IN1 w0.089: v1(149.55,22.56) 149.68,22.69 149.68,24.53 144.7,29.51 144.7,33.59 142.14,36.15 142.14,43.97 v1(142.57,44.4)
  L6_IN2 w0.089: 105.95,89.32 108.67,92.03 108.67,108.92 110.62,110.87 110.62,118.15 ; v1(126.82,13.89) 127.61,14.68 128.25,14.68 128.76,15.19 131.01,15.19 131.77,14.43 133.3,14.43 134.44,13.29 141.67,13.29 144.49,16.11 144.49,17.29 149.23,22.03 149.23,22.23 v1(149.55,22.56) 150.32,23.32 151.9,23.32 v1(152.35,23.77) 152.58,24.01 154.3,24.01 154.57,23.73 158.22,23.73 159.98,25.49 162.41,25.49 162.69,25.21 171.42,25.21 172.7,26.5 v1(174.07,26.5) 176.42,26.5 178.5,28.58 180.75,28.58 181.85,29.67 182.46,29.67 184.86,32.08 184.86,44.25 185.52,44.91 185.52,46.28 185.24,46.56 v1(184.86,46.56)
  L6_IN2 w0.102: 110.62,118.15 111.35,118.89 111.35,121.67 v1(110.06,122.96) ; v1(109.04,53.42) 109.04,55.88 105,59.92 105,61.3 104.81,61.5 104.81,61.5 104.32,61.99 104.32,78.51 105.95,80.15 105.95,89.32
  L8_IN3 w0.089: v1(174.07,26.5) 174.07,25.89 174.37,25.58 174.37,17.47 172.98,16.08 v1(172.71,16.08) ; v1(187.86,101.22) 187.86,100.82 185.37,98.33 185.37,77.41 186.51,76.27 186.51,67.18 181.7,62.37 181.7,48.06 179.86,46.21 v1(179.86,44.76)
  BOTTOM w0.102: v1(152.35,23.77) 153.22,24.64 U5.108 ; v1(109.04,53.42) 125.03,53.42 133.85,44.61 142.37,44.61 v1(142.57,44.4) ; v1(172.71,16.08) 172.68,16.05 171.59,16.05 U106.3 ; v1(110.06,122.96) 110.87,123.78 R3372.1 ; U104.5 172.27,56.96 172.16,56.85 172.16,54.82 173.52,53.45 173.52,46.38 175.14,44.76 v1(179.86,44.76) 180.06,44.56 181.84,44.56 183.84,46.56 v1(184.86,46.56)
PM_SLP_S5#: length 6.9
  TOP w0.076: 125.6,13.41 125.6,13.51 125.51,13.6 125.51,14.8 125.45,14.87 125.45,15.24 125.61,15.4 125.61,16.27 125.73,16.4 125.73,16.68 125.74,16.69 U28.BC42
  TOP w0.102: 125.6,13.41 125.6,12.86 125.83,12.63 125.83,11.41 125.45,11.03 TP29.1
PM_SLP_SUS#: length 2.8
  TOP w0.076: U28.BD39 124.22,16.65 124.37,16.5 124.39,16.5 124.51,16.39 124.51,16.12 124.35,15.95 124.35,15 124.41,14.94 v1(124.42,14.94)
  BOTTOM w0.102: v1(124.42,14.94) 124.92,14.94 TP30.1
PM_SYNC: length 187.4
  TOP w0.102: U26.BM34 160.02,128.16 v1(160.02,128.23)
  L3_IN1 w0.089: v1(174.25,126.89) 174.25,126.77 175.21,125.81 175.21,120.88 182.35,113.74 182.35,108.42 177.6,103.67 177.6,99.22 181.33,95.49 181.33,88.73 180.51,87.91 180.51,84.85 181.27,84.09 181.27,81.46 180.92,81.11 180.92,75.48 183.47,72.94 183.47,67.94 181.15,65.62 168.48,65.62 164.84,61.98 141.73,61.98 128.78,49.03 128.78,36.52 128.95,36.34 128.95,35.95 128.93,35.93 128.93,35.84 128.35,35.26 128.35,33.48 127.33,32.46 124.79,32.46 124.15,31.83 122.12,31.83 121.74,31.45 120.98,31.45 120.5,31.93 119.73,31.93 119.32,32.35 117.44,32.35 116.49,31.4 113.53,31.4 112.58,30.45 112.12,30.45 109.77,28.1 v1(108.74,28.1)
  L6_IN2 w0.089: v1(174.25,126.89) 173.43,127.71 172.6,127.71 170.83,129.49 164.41,129.49 163.27,128.35 162.51,128.35 161.24,129.62 160.48,129.62 160.02,129.16 v1(160.02,128.23)
  BOTTOM w0.102: R91.1 v1(108.74,28.1)
PRDY#_PCH: length 4.8
  TOP w0.076: U28.AM5 107.55,22.72 106.28,22.72 105.85,23.16 104.69,23.16 v1(104.09,22.56)
  BOTTOM w0.102: TP54.1 103.83,22.3 v1(104.09,22.56)
PREQ#_PCH: length 5.2
  TOP w0.076: U28.AL2 106.02,23.32 104.09,23.32 103.96,23.19
  TOP w0.102: 103.96,23.19 102.4,23.19 102.08,22.88 102.08,22.84 TP53.1
PROC_AUDIO_SDO_R: length 3.9
  TOP w0.076: U26.G29 125.57,124.86 v1(125.25,124.54)
  BOTTOM w0.102: v1(125.25,124.54) 125.25,123.6 124.66,123.02 R7.2
PROCHOT#: length 240
  TOP w0.102: R3320.2 73.74,42.24 v1(74.12,42.62) ; v1(191.85,136.22) 191.77,136.3 R28.1 R47.1 190.21,136.41 Q3.3 190.21,138.02 191.08,138.89 191.59,138.89 Q1.D 192.48,140.59 R29.1
  L6_IN2 w0.089: v1(74.12,42.62) 74.75,43.26 74.75,43.98 82.24,51.47 v1(82.24,52.15)
  L8_IN3 w0.089: v1(191.85,136.22) 191.85,135.52 194.52,132.84 194.52,99.99 193.9,99.37 193.9,94.97 192.99,94.06 192.99,76.1 189.93,73.03 189.93,64.66 185.64,60.37 185.64,49.12 186.13,48.63 186.13,45.09 v1(186.26,44.96) ; v1(96.04,62.56) 96.32,62.28 96.32,61.01 96.09,60.79 95.83,60.79 95.56,60.51 95.56,58.6 94.38,57.43 92.32,57.43 90.44,55.54 89.88,55.54 87.19,52.85 84.77,52.85 84.31,52.39 82.49,52.39 v1(82.24,52.15)
  BOTTOM w0.102: v1(186.26,44.96) 185.98,44.96 184.68,43.67 175.09,43.67 172.12,46.63 163.59,46.63 153.5,56.72 132.66,56.72 129.51,59.87 108.41,59.87 105.75,62.54 103.15,62.54 102.89,62.28 97.9,62.28 97.48,62.69 96.21,62.69 96.09,62.56 v1(96.04,62.56)
PROCHOT#_R: length 33.5
  TOP w0.076: 164.88,128 164.7,128 163.85,127.16 163.85,126.71 162.9,125.76 162.07,125.76 161.79,125.48 U26.BR30
  TOP w0.102: R47.2 190.32,134.7 189.79,134.17 187.04,134.17 186.59,133.71 185.67,133.71 182.6,130.63 v1(182.07,130.63) ; v1(172.29,128.7) 172.26,128.7 172.21,128.65 169.32,128.65 169.26,128.7 165.58,128.7 164.88,128
  L6_IN2 w0.089: v1(172.29,128.7) 174.55,128.7 176.48,130.64 182.07,130.64 v1(182.07,130.63)
PROCHOT_#: length 6.3
  TOP w0.203: U97.10 67.79,41.34 68.05,41.07 68.68,41.07 68.91,41.3 68.91,41.68 R3320.1 69.47,42.42 69.82,42.78 71.47,42.78 72.01,43.31 R3323.2
PROCPWRGD_CPU: length 189.3
  TOP w0.076: 163.73,128 163.52,127.8 163.52,126.85 162.92,126.24 U26.BT31 ; U28.AE3 106.99,25.97 v1(107.14,26.11)
  TOP w0.102: v1(175.46,126.88) 175.46,127.39 173.26,129.59 165.32,129.59 163.73,128
  L3_IN1 w0.089: v1(107.14,26.11) 107.14,26.29 107.56,26.71 108.03,26.71 108.29,26.98 109.77,26.98 112.38,29.59 112.83,29.59 113.85,30.62 116.89,30.62 117.46,31.19 118.31,31.19 119.14,30.37 122.73,30.37 123.5,29.6 126.46,29.6 127.43,28.63 128.12,28.63 128.88,27.86 130.12,27.86 130.67,28.41 130.67,35.83 131.19,36.35 131.19,46.39 145.99,61.19 165.84,61.19 169.47,64.83 181.47,64.83 184.26,67.61 184.26,73.27 182.86,74.66 182.86,81.86 183.74,82.73 183.74,85.71 182.12,87.33 182.12,96.6 181.63,97.08 181.63,106.43 183.14,107.93 183.14,114.06 176,121.21 176,126.34 v1(175.46,126.88)
PS_NVVDD_COMP: length 5.3
  TOP w0.254: U722.12 20.27,113.11 21.28,112.09 23.01,112.09 C2549.1 R955.2
PS_NVVDD_EN: length 191.9
  TOP w0.102: Q125.G 25.28,105.04 25.55,105.31 v1(25.55,106.4) ; v1(78.13,33.37) 77.44,34.06 77.44,36.15 76,37.6 76,40.3 75.36,40.93 75.36,43.6 D51.1 74.18,47.06 R977.2 C1427.1
  TOP w0.254: U722.3 v1(15.57,116.03)
  L6_IN2 w0.089: v1(25.55,106.4) 25.79,106.64 25.79,109.11 21.41,113.49 17.35,113.49 15.57,115.27 v1(15.57,116.03)
  L8_IN3 w0.089: v1(15.57,116.03) 15.57,115.9 14.81,115.14 14.81,108.44 11.89,105.52 11.89,88.31 10.92,87.35 10.92,79.89 8.6,77.57 8.6,74.01 8.58,73.99 8.58,67.64 8.49,67.55 8.49,64.3 8.25,64.06 8.25,63.95 8.85,63.35 8.85,58.35 6.37,55.87 6.37,50.33 9.99,46.71 9.99,41.38 13.55,37.82 25.53,37.82 27.27,39.57 30.56,39.57 32.13,38.01 33.81,38.01 34.29,38.49 34.29,39.15 35.14,40 46.32,40 47.16,39.16 54.13,39.16 59.48,33.81 77.7,33.81 v1(78.13,33.37)
PS_NVVDD_GNDSNS_R: length 5.2
  TOP w0.254: C799.2 16.15,111.69 R976.1 R3541.2 R998.2 14.68,110.52 C797.2
PS_NVVDD_PGOOD_PCH: length 1.7
  TOP w0.254: R972.2 22.73,116.03 U722.16
PS_NVVDD_PSI: length 2.9
  TOP w0.254: R943.2 R945.1 U722.4
PS_NVVDD_PVCC: length 3.2
  TOP w0.305: U722.21 19.25,119.03 C1362.2 20.05,119.83 R970.1
PS_NVVDD_VID: length 133
  TOP w0.102: v1(17.47,103.2) 17.47,103.58 16.74,104.32 16.74,105.72 16.11,106.35 14.32,106.35 14.17,106.51 14.17,109.93 13.79,110.32 12.52,110.32 12.14,110.7 12.14,113.36 13,114.23 14.35,114.23 C800.1 ; R2938.2 v1(87.58,71.45)
  TOP w0.254: C800.1 15.14,115.01 U722.5
  L8_IN3 w0.089: v1(17.47,103.2) 17.35,103.2 16.33,102.19 16.33,101.04 15.32,100.03 15.32,78.75 13.87,77.31 13.87,72.99 14.49,72.37 21.28,72.37 23.04,70.61 27.94,70.61 28.57,69.98 28.76,69.98 30.94,67.8 52.93,67.8 54.22,69.09 54.95,69.09 55.34,69.47 70.92,69.47 71.8,68.58 75.88,68.58 78.59,65.87 83.39,65.87 87.58,70.06 v1(87.58,71.45)
PS_NVVDD_VREF: length 3
  TOP w0.254: U722.8 18.24,111.76 C803.2 R935.2
PS_NVVDD_VREF_L: length 9.4
  TOP w0.254: R974.1 R933.1 13.41,110.87 C797.1 12.78,110.82 v1(12.65,110.95) ; R936.1 v1(17.73,108.59)
  BOTTOM w0.254: v1(12.65,110.95) 12.9,110.7 15.19,110.7 17.3,108.59 v1(17.73,108.59)
PS_NVVDD_VSNS: length 64.9
  TOP w0.254: R1002.1 20.22,109.88 v1(20.19,109.91) ; v1(22.17,146.62) 22.17,146.64 22.94,147.4 C807.1 ; C809.1 v1(26.36,159.46) ; C805.1 20.52,132.03 v1(20.4,132.16)
  L8_IN3 w0.254: v1(26.36,159.46) 28.4,159.46 29.16,158.7 29.16,150.83 24.97,146.64 22.19,146.64 v1(22.17,146.62) 22.15,146.64 21.79,146.64 19.89,144.73 19.89,132.67 v1(20.4,132.16) 19.87,131.64 19.87,118.66 21.74,116.79 21.74,110.75 20.9,109.91 v1(20.19,109.91)
PS_NVVDDS_COMP: length 4.7
  TOP w0.203: v1(17.36,70.49) 17.38,70.52 17.38,71.29 16.92,71.76 C2551.2
  BOTTOM w0.203: R958.1 17.09,71.83 17.38,71.55 17.38,70.52 v1(17.36,70.49) 17.63,70.49 18.09,70.04 U721.12
PS_NVVDDS_PVCC: length 5.5
  BOTTOM w0.203: 20.01,72.72 U721.18
  BOTTOM w0.381: 20.01,72.72 19.89,72.85 C1361.2
  BOTTOM w0.508: R969.2 17.84,74.63 C817.1 19.83,73.85 C1361.2
PS_NVVDDS_VID: length 109.9
  TOP w0.102: G1.BE4 90.9,82.53 90.9,80.7 91.12,80.48 91.25,80.48 92.18,79.56 92.18,77.83 91.64,77.3 R2815.2 91.46,77.12 91.13,76.79 91.13,73.87 91.52,73.49 v1(91.64,73.49)
  L8_IN3 w0.089: v1(28.52,68.53) 29.06,68.53 30.61,66.98 52.28,66.98 52.89,66.37 64.13,66.37 64.73,65.76 69.25,65.76 69.27,65.74 72.19,62.82 72.19,61.67 72.94,60.91 73.61,60.91 74.09,60.43 74.09,56.24 75.26,55.07 76.2,55.07 77.82,53.45 81.17,53.45 82.31,54.59 84.27,54.59 86.18,56.5 87.99,56.5 89.38,57.89 90.65,57.89 91.57,58.81 91.57,59.73 93.4,61.56 93.4,63.56 95.99,66.14 95.99,70.41 95.62,70.77 93.34,70.77 91.9,72.22 91.9,73.23 v1(91.64,73.49)
  BOTTOM w0.102: R949.1 26.9,69.04 27.08,68.86 27.08,68.46 27.38,68.15 28.14,68.15 v1(28.52,68.53)
PS_NVVDDS_VREF: length 4.5
  BOTTOM w0.203: U721.8 20.01,67.85 C1364.2 R967.1 18.95,67.19 19.18,66.96 R928.2 18.67,66.25 C816.1
PSYS_H: length 265.6
  TOP w0.102: R3309.1 v1(74.25,41.23)
  TOP w0.203: v1(182.07,155.52) 181.98,155.52 R513.2 ; U97.9 67.68,40.94 68.02,40.59 69.16,40.59 69.47,40.9 C3565.2 69.47,41.41 69.77,41.71 72.44,41.71 R3309.1
  L6_IN2 w0.089: v1(74.25,41.23) 74.25,41.74 75.26,42.75 75.26,43.93 83.1,51.77 83.1,52.95 82.8,53.25 v1(82.75,53.25)
  L8_IN3 w0.089: v1(182.07,155.52) 182.16,155.52 182.17,155.53 188.04,155.53 190.83,152.73 190.83,139.85 191.37,139.31 191.37,135.44 194.13,132.68 194.13,100.75 193.31,99.92 193.31,97 191.85,95.54 191.85,76.11 189.53,73.8 189.53,64.85 185.25,60.56 185.25,48.96 185.62,48.58 185.62,44.86 v1(186.22,44.26) ; v1(82.75,53.25) 82.95,53.44 86.94,53.44 89.63,56.14 90.19,56.14 92.08,58.02 94.14,58.02 94.86,58.75 94.86,60.96 94.95,61.05 v1(95.83,61.93)
  BOTTOM w0.102: v1(186.22,44.26) 185.22,43.26 174.92,43.26 171.95,46.22 163.42,46.22 153.33,56.31 132.18,56.31 129.03,59.46 108.25,59.46 105.58,62.13 103.32,62.13 103.06,61.87 97.16,61.87 97.1,61.93 v1(95.83,61.93)
PWM3_NVD: length 33.6
  TOP w0.254: v1(18.24,121.11) 17.86,120.73 R308.2
  L8_IN3 w0.254: v1(23.96,148) 23.04,148.92 21.54,148.92 20.78,148.16 20.78,147.02 18.86,145.1 18.86,121.73 v1(18.24,121.11)
  BOTTOM w0.254: v1(23.96,148) 23.96,148 23.86,148.1 U32.3
PWM3_NVD_R: length 2.5
  TOP w0.305: R99.2 U722.22
  TOP w0.508: R308.1 R99.2
PWM_EDP: length 5.5
  BOTTOM w0.102: CNEDP1.27 69.8,158.13 S14.1 69.48,157.5 69.29,157.31 68.86,157.31 C465.1 68.4,156.75 R1022.2 68.86,155.4 68.86,155.04 v3(69.29,154.61)
PWR LED N: length 441.7
  TOP w0.102: v1(178.64,166.83) 178.64,166.58 178.64,162.13 177.24,160.73 176.1,160.73 175.84,160.48 R13.1 C4115.1 176.94,159.59 Q30.D v1(177.88,158.58) ; v1(138.76,9.22) v4(142.11,9.22) 143.04,9.22 144.77,7.5 149.19,7.5 150.06,6.62 150.38,6.3 153.16,6.3 157.12,2.34 163.12,2.34 164.2,3.42 CN9.4 v1(164.2,7.57)
  L3_IN1 w0.089: v1(189.56,39.58) 183.59,39.58 181.53,41.64 181.53,47.39 182.03,47.89 182.03,49.54 183.71,51.22 183.71,59.71 190.33,66.33 190.33,77.14 191.27,78.09 191.27,91.73 188.36,94.64 188.36,99.62 192.72,103.98 192.72,133.53 190.3,135.95 190.3,147.98 190.49,148.17 190.49,152.11 191.57,153.19 191.57,154.11 186.86,158.83 184.86,158.83 183.34,160.35 181.81,160.35 180.29,158.83 178.13,158.83 v1(177.88,158.58)
  L6_IN2 w0.089: v1(164.2,7.57) 164.29,7.57 165.05,8.33 167.24,8.33 168.12,9.22 168.12,10.12 166.55,11.69 166.55,13.6 168.02,15.07 169.11,15.07 169.87,14.3 170.79,14.3 171.42,14.94 173.37,14.94 178.58,20.15 179.27,20.15 189.32,30.2 189.32,39.34 v1(189.56,39.58)
  L8_IN3 w0.089: v1(10.49,69.87) 11.35,69.87 12.97,68.25 13.29,68.25 13.87,67.66 17.27,67.66 17.28,67.67 18.99,67.67 19.28,67.97 25.46,67.97 27.44,65.99 28.43,65.99 29.69,64.74 30.18,64.74 30.18,64.74 31.2,64.74 31.95,63.99 38.56,63.99 39.32,64.74 46.98,64.74 47.79,63.93 56.51,63.93 57.12,63.33 57.12,61.51 60.46,58.18 68.59,58.18 70.32,56.44 70.32,54.16 75.6,48.89 83.17,48.89 84.74,47.32 84.74,16.66 85.14,16.27 85.14,14.73 85.01,14.6 85.01,9.61 87.79,6.83 95.45,6.83 95.82,7.2 97.28,7.2 98.1,6.38 102.04,6.38 103.79,8.12 113.1,8.12 113.72,8.74 118.79,8.74 119.65,9.6 123.98,9.6 124.35,9.24 129.87,9.24 130.39,8.72 138.25,8.72 v1(138.76,9.22)
  BOTTOM w0.102: v1(10.49,69.87) 10.12,69.5 9.51,69.5 9.37,69.36 CN12.41 ; v1(178.64,166.83) 178.57,166.89 170.06,166.89 165.95,171.01 SW6.L2
PWR_B_LED_GND: length 12.6
  TOP w0.508: 24.59,162.39 24.59,161.75 v1(24.46,161.62)
  BOTTOM w0.508: R3624.1 18.08,157.05 17.91,157.23 17.91,160.33 19.86,162.28 LED4.C 23.95,162.28 24.46,161.77 v1(24.46,161.62)
PWR_LED#: length 197.5
  TOP w0.102: R316.1 181.56,156.26 v1(181.58,156.24)
  L6_IN2 w0.089: v1(181.58,156.24) 181.89,155.93 190.8,155.93 193.93,152.8 193.93,138.59 193.53,138.19 193.53,137.55 194.95,136.13 194.95,100.21 193.88,99.14 193.88,92.8 193.52,92.44 193.52,75.68 192.87,75.03 192.87,59.22 193.52,58.57 193.52,32.26 179.81,18.55 179.81,5.48 178.38,4.04 165.82,4.04 162.91,6.95 162.91,12.55 v1(163.73,13.36)
  BOTTOM w0.102: U5.31 163.61,15.11 163.93,14.79 163.93,13.57 v1(163.73,13.36)
PWR_LED+: length 12.7
  TOP w0.508: v1(177.11,165.31) 177.42,165 R585.1
  BOTTOM w0.508: v1(177.11,165.31) 176.86,165.56 168.41,165.56 166.88,167.09 SW6.L1
PWR_LED_5V: length 2.7
  TOP w0.102: Q50.D 177.88,163.96 R585.2 177.27,164.09 R15.2
PWR_USB#: length 293.1
  TOP w0.102: v1(140.45,168.78) U27.4 ; v1(102.56,164.54) 102.65,164.46 U733.4 ; v1(115.09,169.75) 115.72,169.12 116.41,169.12 116.86,168.66 R623.2 117.21,168.95 U31.4
  L3_IN1 w0.089: v1(140.45,168.78) 140.83,168.78 141.3,169.24 144.22,169.24 144.6,168.86 170.6,168.86 175.94,163.53 177.62,163.53 180.03,161.12 183.59,161.12 185.37,159.34 186.64,159.34 191.78,154.2 191.78,153.11 190.7,152.03 190.7,147.92 190.5,147.72 190.5,136.03 192.92,133.61 192.92,103.9 189.56,100.54 189.56,97.74 189.05,97.23 189.05,94.44 191.49,92 191.49,77.7 190.53,76.74 190.53,66.07 183.97,59.52 183.97,50.37 182.34,48.74 182.34,46.97 v1(182.19,46.82) ; v1(102.56,164.54) 103.2,163.91 107.26,163.91 109.55,166.2 109.55,168.66 110.44,169.55 114.88,169.55 v1(115.09,169.75)
  L6_IN2 w0.089: v1(182.19,46.82) 182.14,46.76 182.14,40.34 180.41,38.61 180.41,33 175.79,28.37 168.61,28.37 167.8,29.19 149.57,29.19 142.4,22.02 142.4,22.02 142.32,21.93 v1(142.32,21.9)
  BOTTOM w0.102: U5.83 146.42,21.91 146.31,21.8 R143.1 144.25,21.36 142.77,21.36 142.32,21.82 v1(142.32,21.9) ; v1(115.09,169.75) 115.01,169.83 115.01,171.53 116.15,172.67 122.5,172.67 123.14,172.04 123.14,168.86 123.49,168.51 129.97,168.51 130.38,168.1 133.04,168.1 133.55,168.61 134.44,168.61 134.7,168.86 134.7,169.88 134.95,170.13 139.09,170.13 v1(140.45,168.78)
PWRBTN#: length 43.8
  TOP w0.076: U28.BE46 127.65,15.59 v2(127.48,15.59)
  L6_IN2 w0.089: v2(127.48,15.59) 127.79,15.91 134.08,15.91 136.08,17.9 141.47,17.9 142.51,18.95 143.89,18.95 144.49,19.55 144.49,20.44 145.27,21.21 146.16,21.21 148.99,24.04 151.75,24.04 152.25,24.54 155.16,24.54 155.34,24.36 v1(155.52,24.36)
  BOTTOM w0.102: U5.21 158.54,19.11 155.4,22.25 155.4,24.24 v1(155.52,24.36)
PWRON#: length 431.5
  TOP w0.102: v1(162.51,7.57) 162.6,7.48 CN9.2 ; v4(122.83,8.16) 122.45,8.16 v1(122.15,7.85) 121.77,7.85 121.49,7.57 R125.1 ; C3989.1 183.97,167.07 R31.2 ; C3989.1 183.51,165.76 183.34,165.94 v1(183.34,166.32) ; C3989.1 184.78,165.76 184.96,165.59 184.96,162.84 R203.2 C641.1 Q47.2 184.48,160.23 184.86,159.85 186.89,159.85 187.15,159.59 Q116.5 187.07,158.94 R218.1 v1(187.07,157)
  L3_IN1 w0.089: v1(187.07,157) 186.31,157 185.62,157.69 181.43,157.69 v1(180.8,157.05)
  L6_IN2 w0.089: v1(112.01,13.96) 112.1,14.06 113.85,14.06 115.99,11.92 118.54,11.92 119.2,11.26 119.2,10.54 119.73,10.01 120.39,10.01 122.15,8.25 v1(122.15,7.85) 122.3,7.85 123.14,7.01 140.55,7.01 141.2,7.67 142.88,7.67 144.06,8.84 146.25,8.84 148.11,10.7 158.14,10.7 160.35,12.91 162.13,12.91 162.64,12.4 162.64,7.7 v1(162.51,7.57) 162.51,7.06 165.73,3.84 178.46,3.84 180.02,5.39 180.02,18.47 193.72,32.18 193.72,58.65 193.07,59.31 193.07,74.95 193.72,75.6 193.72,92.32 194.22,92.82 194.22,99.1 195.15,100.03 195.15,114.93 195.17,114.94 195.17,136.2 193.73,137.64 193.73,138.11 194.13,138.51 194.13,152.89 190.73,156.29 187.78,156.29 v1(187.07,157)
  L8_IN3 w0.089: v1(10.33,70.87) 11.38,70.87 12.07,70.18 15.64,70.18 16.94,68.88 18.3,68.88 18.61,68.58 25.72,68.58 27.69,66.6 28.69,66.6 29.94,65.35 30.01,65.35 31.45,65.35 32.21,64.6 33.98,64.6 34.74,65.35 51.61,65.35 52.22,64.74 56.97,64.74 57.73,63.98 57.73,61.77 60.72,58.78 68.84,58.78 70.93,56.69 70.93,55.87 77.31,49.5 83.52,49.5 85.35,47.67 85.35,16.92 85.79,16.48 85.79,14.39 85.62,14.22 85.62,10.6 86.77,9.45 107.5,9.45 v1(112.01,13.96)
  BOTTOM w0.102: SW2.2 181.14,157.4 v1(180.8,157.05) ; v1(183.34,166.32) 182.83,165.81 181.81,165.81 181.14,165.14 SW2.1 181.3,164.37 S111.1 ; CN12.43 9.55,70.36 10.06,70.87 10.21,70.87 10.21,70.87 v1(10.33,70.87)
PWRSW: length 167.4
  TOP w0.102: v1(182.19,159.92) R216.1 183.83,160.92 Q47.3
  L3_IN1 w0.089: v1(181.26,41.15) 181.32,41.22 181.32,47.47 181.78,47.93 181.78,49.57 183.51,51.3 183.51,59.89 190.12,66.51 190.12,77.23 191.07,78.17 191.07,91.65 188.16,94.56 188.16,99.99 190.91,102.74 190.91,103.66 191.97,104.73 191.97,105.24 191.59,105.62 191.59,107.9 192.51,108.82 192.51,133.45 190.09,135.86 190.09,148.06 190.29,148.26 190.29,152.19 191.37,153.27 191.37,154.03 186.82,158.58 184.35,158.58 183.01,159.92 v1(182.19,159.92)
  L6_IN2 w0.089: v1(160.86,29.8) 161.26,29.39 167.88,29.39 168.7,28.58 175.7,28.58 180.21,33.08 180.21,38.88 181.26,39.93 v1(181.26,41.15)
  BOTTOM w0.102: v1(160.86,29.8) 160.48,29.8 160.02,29.34 U5.125
PWRSW_0: length 3.8
  TOP w0.381: Q47.6 185.13,157.9 R359.2 R297.1 184.05,158.14 184.48,158.58 Q47.5
QKEY0#: length 49.4
  TOP w0.102: R131.1 123.52,8.16 123.52,8.84 v1(123.49,8.87)
  L6_IN2 w0.089: v1(152.86,17.17) 152.73,17.04 152.73,16.34 151.73,15.34 150.28,15.34 149.81,14.87 149.81,13.32 145.94,9.45 141.55,9.45 140.13,8.03 128.55,8.03 127.72,8.87 v1(123.49,8.87)
  BOTTOM w0.102: U5.95 147.88,26.71 148.95,25.64 148.95,25.19 150.7,23.45 150.7,19.33 v1(152.86,17.17)
QKEY1#: length 388
  TOP w0.102: C296.1 v3(168.22,7.45) 168.22,6.06 CN9.9 ; R3514.2 v1(166.45,9.73) R3702.2
  L6_IN2 w0.089: v1(155.14,16.46) 155.27,16.34 159.59,16.34 159.87,16.62 162.38,16.62 163.84,15.16 165.11,15.16 165.74,14.53 165.74,13.17 165.74,13.1 165.74,11.35 166.45,10.65 v1(166.45,9.73)
  L8_IN3 w0.089: v1(146,22.94) 146,24.59 145.74,24.84 145.11,24.84 143.71,23.45 142.75,23.45 139.01,19.71 139.01,11.38 137.33,9.7 136.77,9.7 136.61,9.86 134.19,9.86 133.94,9.61 130.07,9.61 130.04,9.64 124.52,9.64 124.15,10.01 119.48,10.01 118.62,9.15 113.36,9.15 112.77,8.56 103.65,8.56 101.92,6.84 98.22,6.84 97.33,7.72 95.58,7.72 95.1,7.24 87.95,7.24 85.41,9.78 85.41,14.39 85.54,14.52 85.54,16.44 85.15,16.83 85.15,47.58 83.43,49.3 75.77,49.3 70.73,54.33 70.73,56.61 68.76,58.58 60.63,58.58 57.53,61.68 57.53,63.89 56.89,64.54 52.65,64.54 52.46,64.34 47.95,64.34 47.15,65.15 34.82,65.15 34.07,64.39 32.12,64.39 31.37,65.15 30.01,65.15 30.01,65.15 29.86,65.15 29.82,65.19 29.74,65.27 28.61,66.4 27.61,66.4 25.63,68.37 18.52,68.37 18.22,68.68 16.85,68.68 15.55,69.98 11.97,69.98 11.48,70.47 10.06,70.47 9.93,70.6 9.93,71.06 10.23,71.36 10.23,71.7 9.84,72.09 v1(9.82,72.09) 9.82,72.44 9.93,72.55 9.93,76.29 13.28,79.64 13.28,102.78 15.53,105.03 20.09,105.03 22.14,107.08 22.14,107.97 23.75,109.58 25.73,109.58 27.59,111.44 27.59,114.59 27.15,115.03 27.15,122.5 30.45,125.8 30.45,150.06 31.95,151.56 31.95,156.16 v1(31.32,156.8)
  BOTTOM w0.102: CN12.47 9.55,72.36 v1(9.82,72.09) ; v3(168.22,7.45) 168.22,7.85 166.45,9.63 v1(166.45,9.73) ; v1(155.14,16.46) 154.76,16.46 154.45,16.15 152.44,16.15 149.88,18.7 149.88,21.47 148.64,22.71 U5.85 146.36,22.71 146.13,22.94 v1(146,22.94) ; SW3.3 16.08,163.52 15.56,162.99 S110.1 15.63,162.84 15.63,160.16 16.08,159.71 SW3.4 16.08,154.2 C8.1 30.25,154.13 C3988.1 31.32,155.1 v1(31.32,156.8) 30.43,157.69 30.43,162.35 29.25,163.53 SW1.1 29.25,166.04 30.3,166.04 31.56,167.3 31.56,167.34 31.56,169.23 v3(31.57,169.24) 31.57,169.51 29.25,171.83 SW1.2
QKEY2#: length 350.1
  TOP w0.102: R3512.2 167.33,9.76 v3(167.21,9.63) 167.21,9.6 167.33,9.48 R313.2 ; R3625.1 v1(29.62,162.21) ; C292.1 v1(169.11,7.45) 169.11,6.15 CN9.10
  L6_IN2 w0.089: v3(167.21,9.63) 167.21,10.17 165.94,11.44 165.94,11.6 165.94,13.17 165.94,14.62 165.2,15.36 163.92,15.36 162.46,16.82 159.57,16.82 159.46,16.72 155.52,16.72 v1(155.14,17.1)
  L8_IN3 w0.089: 9.78,71.53 9.47,71.22 9.47,69.78 9.8,69.45 10.63,69.45 10.83,69.64 11.28,69.64 12.88,68.04 13.2,68.04 13.79,67.46 19.14,67.46 19.45,67.76 25.38,67.76 27.35,65.79 28.34,65.79 29.29,64.85 29.6,64.55 29.61,64.54 30.26,64.54 31.11,64.54 31.87,63.78 38.65,63.78 39.4,64.54 46.89,64.54 47.7,63.73 56.43,63.73 56.92,63.24 56.92,61.43 60.38,57.97 63.83,57.97 64.19,57.61 64.19,57.32 64.43,57.08 64.72,57.08 65.72,56.09 69.04,56.09 69.92,55.2 69.92,54 75.06,48.86 75.06,37.98 76.29,36.74 78.73,36.74 83.93,31.54 83.93,17.35 82.53,15.95 82.53,14.05 84.05,12.54 84.05,11.33 83.65,10.93 83.65,10.11 87.53,6.22 95.86,6.22 96.31,5.77 103.21,5.77 104.28,6.84 105.28,6.84 106.09,6.02 112.37,6.02 112.62,6.28 112.62,6.78 113.56,7.72 116.55,7.72 117.22,7.05 124.17,7.05 124.66,7.53 126.37,7.53 126.98,8.15 128.08,8.15 128.7,7.53 136.24,7.53 137.22,8.51 138.61,8.51 139.22,9.11 139.22,19.62 142.66,23.07 144.35,23.07 v1(145.49,24.21) ; 9.78,71.53 9.42,71.88 9.42,72.33 9.71,72.61 9.71,76.36 13.07,79.72 13.07,104.2 14.11,105.24 19.92,105.24 21.92,107.24 21.92,108.16 23.57,109.81 25.67,109.81 27.39,111.53 27.39,114.51 26.94,114.95 26.94,122.58 30.24,125.89 30.24,150.14 30.54,150.44 30.54,161.29 v1(29.62,162.21) ; 9.78,71.53 v1(9.83,71.53)
  BOTTOM w0.102: v1(155.14,17.1) 155.02,17.1 154.27,16.36 152.52,16.36 150.09,18.79 150.09,22.66 148.84,23.91 U5.88 146.55,23.91 146.25,24.21 v1(145.49,24.21) ; v1(169.11,7.45) 167.21,9.35 v3(167.21,9.63) ; CN12.46 9.39,71.86 9.72,71.53 v1(9.83,71.53)
REGOUT_LAN: length 6.5
  TOP w0.203: U1901.24 95.84,49.18 96.04,48.97 97.86,48.97 98.58,48.26 R213.1
  TOP w0.381: L54.1 101.1,47.97 R213.1
ROM_CS#: length 24
  TOP w0.1: G1.BJ4 94.37,82.55 v6(94.41,82.55)
  TOP w0.102: U83.1 106.73,79.56 104.22,77.04 102.95,77.04 102.44,76.53 102.44,74.81 R2875.1 100.91,73.36 100.46,73.82 99.06,73.82 98.88,73.99 98.88,74.76 99.14,75.01 v1(99.14,75.52)
  L8_IN3 w0.089: v1(99.14,75.52) 98.37,75.52 96.85,77.04 96.85,79.07 95.45,80.47 95.45,81.61 94.51,82.55 v6(94.41,82.55)
ROM_SCLK: length 20.2
  TOP w0.1: v6(94.43,81.9) 94.71,82.18 G1.BK3
  TOP w0.102: v1(96.21,72.6) 97.03,72.6 R820.1 R825.2 97.79,70.95 99.14,70.95 100.15,71.96 101.21,71.96 102.22,72.98 R2865.1
  L8_IN3 w0.089: v6(94.43,81.9) 94.66,81.9 95.2,81.36 95.2,80.22 96.6,78.82 96.6,76.41 96.85,76.15 96.85,73.1 96.35,72.6 v1(96.21,72.6)
ROM_SCLK_R: length 2
  TOP w0.102: U83.6 104.19,73.84 104.04,73.69 R2865.2
ROM_SI: length 12.7
  TOP w0.102: R2876.1 99.69,72.85 99.32,72.85 98.12,74.05 R822.2 98.12,74.25 98.63,74.76 98.63,75.9 98.32,76.2 R824.1 97.71,76.61 97.71,77.45 95.58,79.58 94.82,79.58 94.44,79.95 94.44,81.18 G1.BK2
ROM_SI_R: length 3.2
  TOP w0.102: U83.5 102.92,74.48 101.5,73.05 101.5,72.98 R2876.2
ROM_SO: length 21.6
  TOP w0.102: U83.2 105.46,78.79 104.09,77.42 102.95,77.42 102.18,76.66 102.18,75.14 101.29,74.25 R823.2 100.48,74.76 99.86,74.76 99.64,74.97 99.64,75.7 R821.1 98.83,76.2 98.63,76.41 98.63,79.07 97.74,79.96 95.76,79.96 95.14,80.58 95.14,82.56 94.82,82.88 G1.BK4
RT8237E_BOOT_GDDR: length 2.3
  TOP w0.254: R838.2 9.57,100.78 8.11,100.78 7.93,100.96 U84.10
RT8237E_CS_GDDR: length 3.7
  TOP w0.254: U84.2 7.43,105.4 C668.1 R836.1
RT8237E_FB_GDDR: length 9.3
  TOP w0.254: C556.1 R124.1 R1125.1 ; C556.1 6.43,105.3 U84.4 ; C556.1 5.23,106.45 4.77,106 C559.2 C151.2 2.87,105.06 R127.2
RT8237E_LX_GDDR: length 20.1
  TOP w0.254: 8.71,99.9 8.58,99.77 7.7,99.77 6.93,100.54 U84.8
  TOP w0.508: v1(10.49,99.27) 10.16,99.6 C665.2 8.71,99.9
  L3_IN1 w0.508: v1(10.49,99.27) 13.44,96.32 13.44,88.83 12.01,87.4 v1(12.01,85.93)
RT8237E_RF_GDDR: length 2.6
  TOP w0.254: R835.1 C673.1 4.95,104.85 5.66,104.85 5.93,104.58 U84.5
RT8237E_VDD_GDDR: length 5.5
  TOP w0.254: C663.1 7.62,99.22 6.43,100.4 U84.7
  TOP w0.508: R837.1 10.22,98.39 9.4,99.22 C663.1
RTC_X1: length 9.8
  TOP w0.076: U28.BA49 130.72,18.05 131.14,17.63
  TOP w0.102: Y1.1 137.49,16.46 137.31,16.28 R353.1 135.56,16.01 134.06,16.01 C281.2 133.22,16.84 132.5,16.84 131.71,17.63 131.14,17.63
RTC_X2: length 11
  TOP w0.076: U28.BA48 129.22,17.84 129.29,17.77 130.52,17.77 131.14,17.15
  TOP w0.102: 131.14,17.15 131.51,17.15 132.37,16.29 132.83,16.29 133.43,15.7 133.43,15.24 C280.2 134.06,15.52 135.68,15.52 R353.2 137.39,15.37 137.49,15.27 Y1.2
RTCRST#: length 71.5
  TOP w0.076: U28.BE47 128.41,16.39 v2(128.57,16.55)
  TOP w0.102: v1(177.62,28.78) 177.62,28.4 179.91,26.11 180.29,26.11 180.8,25.61 180.8,23.7 179.17,22.08 177.72,22.08 R149.2 176.58,21.85 R269.1 175.21,21.85 C253.1 174.73,22.23 174.01,22.23 173.81,22.43 173.3,22.43 173.02,22.15 JP1.1
  L6_IN2 w0.089: v2(128.57,16.55) 128.6,16.58 128.97,16.58 129.73,17.34 132.04,17.34 132.54,16.84 134.07,16.84 135.8,18.58 140.43,18.58 142.31,20.46 143.55,20.46 145.04,21.95 145.81,21.95 148.58,24.72 151.47,24.72 152.98,26.22 163.98,26.22 164.31,25.89 165.58,25.89 166.19,26.5 171.43,26.5 172.42,27.49 176.33,27.49 v1(177.62,28.78)
RUN_ON: length 219.4
  L3_IN1 w0.089: v1(152.98,44.78) 154.38,43.39 154.38,34.2 155.7,32.89 v1(155.7,32.34)
  L6_IN2 w0.089: v1(180.92,45.04) 180.92,43.72 179.6,42.39 179.6,33.34 175.68,29.42 v1(174.57,29.42) 168.72,29.42 167.32,30.81 157.56,30.81 156.03,32.34 v1(155.7,32.34)
  L6_IN2 w0.102: v1(110.06,123.57) 109.65,123.17 109.65,122 109.96,121.69 109.96,110.59 108.46,109.1 108.46,92.27 105.73,89.55 105.73,80.24 104.1,78.6 104.1,61.9 104.59,61.41 104.79,61.21 104.79,59.71 108.15,56.34 108.15,53.83 v1(108.41,53.57)
  L8_IN3 w0.089: v1(174.57,29.42) 174.57,17.22 173.18,15.83 v1(173.18,15.73)
  BOTTOM w0.102: v1(152.98,44.78) 152.96,44.81 133.93,44.81 124.81,53.93 108.76,53.93 v1(108.41,53.57) ; U5.118 157.22,29.76 156.51,30.46 156.51,31.52 v1(155.7,32.34) ; R3376.1 110.46,126.65 109.63,125.81 109.63,124.01 v1(110.06,123.57) ; U104.3 173.07,54.35 173.72,53.7 173.72,46.62 175.29,45.05 178.56,45.05 178.81,45.29 180.54,45.29 180.8,45.04 v1(180.92,45.04) ; v1(173.18,15.73) 173.18,15.45 172.8,15.07 172.29,15.07 172.11,15.24 171.59,15.24 U106.5
