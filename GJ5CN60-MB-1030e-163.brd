# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RUN_ON_CPU_1.00V: length 2.8
  BOTTOM w0.102: U105.5 113.04,126.16 112.8,126.39 112.04,126.39 R3376.2 R3377.2
S_GND_R: length 11.3
  TOP w0.508: AR25.1 18.38,54.32 18.36,54.31 v1(18.36,53.93)
  BOTTOM w0.508: v1(18.36,53.93) 18.36,53.8 v3(17.4,52.84) 14.68,50.12 10.11,50.12
SA0_DIM0: length 9.2
  TOP w0.102: R175.1 R180.2 109.24,83.14 114.88,83.14 115.39,82.62 CN1.256
SA0_DIM1: length 19.9
  TOP w0.102: CN11.256 115.39,67.37 114.98,66.96 112.67,66.96 109.93,64.21 109.93,60.91 109.83,60.81 106.25,57.23 104.8,57.23 R184.1 R183.2
SA1_DIM0: length 7.4
  TOP w0.102: R169.1 R167.2 109.17,82.63 113.56,82.63 114.39,81.8 CN1.260
SA1_DIM1: length 18.1
  TOP w0.102: R188.1 R195.2 106.37,57.99 109.41,61.03 109.41,64.35 112.34,67.29 114.13,67.29 114.39,67.55 CN11.260
SA2_DIM0: length 4.8
  TOP w0.102: v1(137.45,79.18) 138.02,79.75 138.02,80.03 137.9,80.15 CN1.166
  BOTTOM w0.102: R173.1 R205.2 136.65,78.38 v1(137.45,79.18)
SA2_DIM1: length 6.8
  TOP w0.102: v1(136.09,66.75) 136.09,66.37 136.35,66.12 137.11,66.12 137.9,66.91 CN11.166
  BOTTOM w0.102: R211.2 R227.1 135.76,65.03 136.09,65.36 v1(136.09,66.75)
SAFTY_PROTECT: length 344.3
  TOP w0.102: v1(75.92,34.22) 74.07,34.22 R3325.1
  L3_IN1 w0.089: v1(47.12,157.41) 45.87,156.16 34.22,156.16 32.41,154.36 32.41,154.34 32.33,154.26 32.33,125.12 27.76,120.55 27.76,105.36 23.95,101.55 16.84,101.55 14.43,99.14 14.43,84.2 9.35,79.12 9.35,68.15 10.24,67.26 v1(10.24,65.87)
  L8_IN3 w0.089: v1(10.24,65.87) 9.98,65.87 8.69,64.58 8.69,63.79 9.05,63.43 9.05,58.27 6.58,55.79 6.58,50.41 10.2,46.79 10.2,41.46 13.63,38.03 25.44,38.03 27.19,39.77 30.65,39.77 32.21,38.21 33.73,38.21 34.08,38.56 34.08,39.23 35.05,40.2 46.4,40.2 47.24,39.36 54.25,39.36 59.6,34.01 75.64,34.01 75.84,34.22 v1(75.92,34.22) 76.12,34.01 78.06,34.01 79.85,32.22 79.85,13.69 81.05,12.49 81.05,9.65 82.46,8.24 82.46,7.26 86.6,3.13 94.5,3.13 94.95,2.68 97.41,2.68 97.82,3.08 109.55,3.08 110.21,3.74 117.97,3.74 119.21,4.98 137.83,4.98 141.16,8.31 141.16,10.77 145.15,14.76 147.38,14.76 151.97,19.35 151.97,21.87 151.82,22.01 151.82,24.83 154.38,27.38 v1(155.02,27.38)
  BOTTOM w0.102: U5.112 154.82,27.58 v1(155.02,27.38)
  BOTTOM w0.254: R3326.2 46.48,156.67 47.12,157.31 v1(47.12,157.41)
SATA_PWR_EN: length 89.3
  TOP w0.102: v1(132.03,20.78) 131.88,20.78 131.45,21.21 129.67,21.21 128.85,20.4 128.13,20.4 127.89,20.15 U28.AU46
  L6_IN2 w0.089: v1(175.34,49.74) 175.34,47.86 171.96,44.49 171.96,40.52 170.22,38.78 149.52,38.78 148.03,37.29 148.03,35.13 143.97,31.07 138.63,31.07 132.16,24.59 132.16,20.91 v1(132.03,20.78)
  BOTTOM w0.102: v1(175.34,49.74) 179.68,54.08 179.68,58.91 181.16,60.39 181.16,67.17 182.32,68.33 R1014.1
SATA_RXN0: length 96.6
  TOP w0.076: U28.C45 127.48,36.62 127.23,36.62 v2(127.03,36.42)
  L3_IN1 w0.102: v2(158.87,64.47) 159.1,64.23 159.1,62.97 158.77,62.64 138.33,62.64 127.84,52.15 127.84,39.74 126.69,38.59 126.69,37 127.03,36.66 v2(127.03,36.42)
  BOTTOM w0.114: C18.2 183.84,84.61 183.27,84.61 179.39,80.72 160.86,80.72 158.44,78.31 158.44,68.57 158.98,68.04 158.98,64.58 v2(158.87,64.47)
SATA_RXN0_C: length 1.4
  BOTTOM w0.114: C18.1 185.19,84.53 185.5,84.53 185.7,84.74 CNHDD1.5
SATA_RXP0: length 96.6
  TOP w0.076: v2(127.48,37.14) 127.76,36.86 U28.C46
  L3_IN1 w0.102: v2(159.81,64.47) 159.31,63.97 159.31,62.89 158.86,62.44 138.41,62.44 128.04,52.06 128.04,39.65 126.9,38.51 126.9,37.09 127,36.98 127.32,36.98 v2(127.48,37.14)
  BOTTOM w0.114: v2(159.81,64.47) 159.66,64.47 159.22,64.91 159.22,68.14 158.69,68.67 158.69,78.21 160.96,80.48 179.49,80.48 183.37,84.37 183.55,84.37 C19.2
SATA_RXP0_C: length 1.4
  BOTTOM w0.114: C19.1 184.94,83.93 185.3,84.29 185.57,84.29 185.62,84.24 CNHDD1.6
SATA_TXN0: length 102.6
  TOP w0.076: 124.67,40.49 124.67,40.42 124.71,40.38 124.71,39.7 124.41,39.4 124.41,38.93 123.9,38.42 123.9,37.27 U28.B38
  TOP w0.114: 124.67,40.49 124.67,42.17 125.18,42.69 125.18,43.54 125.08,43.64 125.08,43.94 125.18,44.04 125.18,44.35 125.08,44.45 125.08,44.75 125.18,44.85 125.18,45.16 125.08,45.26 125.08,45.56 125.18,45.66 125.18,46.02 124.89,46.31 v2(124.68,46.31)
  L3_IN1 w0.102: v2(158.03,63.45) 157.94,63.55 157.94,64.49 157.38,65.05 155.8,65.05 154.28,63.53 137.95,63.53 124.87,50.45 124.87,46.49 v2(124.68,46.31)
  BOTTOM w0.114: v2(158.03,63.45) 157.83,63.45 157.47,63.82 157.47,64.76 158.33,65.62 158.33,67.88 157.8,68.42 157.8,78.97 160.18,81.36 177.49,81.36 177.86,81.73 177.86,84.05 178.74,84.93 180.05,84.93 181.81,86.69 182.47,86.69 183.04,86.12 183.58,86.12 C17.2
SATA_TXN0_C: length 1.4
  BOTTOM w0.114: CNHDD1.3 185.62,85.74 185.43,85.93 185.19,85.93 C17.1
SATA_TXP0: length 102.6
  TOP w0.076: 124.91,40.49 124.91,39.62 124.61,39.32 124.61,38.85 124.1,38.34 124.1,37.18 124.1,37.13 123.84,36.85 U28.C38
  TOP w0.114: 124.91,40.49 124.91,42.07 125.42,42.59 125.42,46.11 v2(125.62,46.31)
  L3_IN1 w0.102: v2(125.62,46.31) 125.4,46.31 125.07,46.64 125.07,50.36 138.03,63.33 154.36,63.33 155.89,64.85 157.29,64.85 157.73,64.41 157.73,63.88 157.3,63.45 v2(157.09,63.45)
  BOTTOM w0.114: C16.2 183.82,86.36 183.14,86.36 182.57,86.93 181.71,86.93 179.95,85.17 178.64,85.17 177.62,84.15 177.62,81.83 177.39,81.6 160.08,81.6 157.56,79.07 157.56,68.32 158.09,67.78 158.09,65.72 157.22,64.86 157.22,63.58 v2(157.09,63.45)
SATA_TXP0_C: length 1.4
  BOTTOM w0.114: CNHDD1.2 185.62,86.24 185.57,86.19 185.3,86.19 184.94,86.55 C16.1
SD_RCOMP_1P8: length 1.9
  TOP w0.254: U28.BE5 107.87,16.16 v2(108.14,16.43)
  BOTTOM w0.102: R354.1 108.58,15.99 v2(108.14,16.43)
SD_RCOMP_3P3: length 2.1
  TOP w0.254: v2(107.64,15.56) 107.32,15.88 U28.BE4
  BOTTOM w0.102: v2(107.64,15.56) 107.64,15.43 R358.1
SENBAT_V: length 164.5
  TOP w0.102: R191.2 32.4,35.45 30.17,37.67 v1(30.17,37.75)
  L8_IN3 w0.089: v1(30.17,37.75) 30.17,37.67 31.06,36.78 43.26,36.78 44.6,38.12 53.31,38.12 58.87,32.56 76.48,32.56 76.98,32.06 77.84,32.06 79.04,30.86 79.04,13.35 80.24,12.15 80.24,7.39 81.02,6.6 81.02,4.53 83.4,2.16 92.99,2.16 93.67,1.48 117.43,1.48 119.71,3.76 145.97,3.76 147.63,5.42 147.63,8.19 v1(148.67,9.22)
  BOTTOM w0.102: U5.56 152.02,11.98 149.26,9.22 v1(148.67,9.22)
SENSEA: length 3.1
  TOP w0.203: U7.13 25.52,62.99 26.38,63.85 AR5.1 AR17.1
SKL_CNL_N: length 4.2
  TOP w0.102: U26.BN1 160.28,104 162.04,102.24
  TOP w0.381: R24.2 162.38,101.12 162.38,101.89 162.04,102.24
SLP_LAN: length 108
  TOP w0.076: U28.BF40 124.67,15.61 124.71,15.57 124.71,15.51 124.71,15.51 124.71,15.31 124.79,15.23 124.79,13.67 124.54,13.41 124.41,13.41
  TOP w0.102: R256.2 90.68,56.54 v1(90.16,57.06) ; 124.41,13.41 124.26,13.26 124.26,10.72 124.15,10.62 121.23,10.62 120.62,10.01 v1(119.46,8.84)
  L6_IN2 w0.089: v1(119.46,8.84) 119.46,8.08 118.82,7.45 117.75,7.45 114.65,10.54 108.35,10.54 106.21,8.4 104.6,8.4 104.55,8.36 103.55,8.36 101.95,6.76 98.04,6.76 97.35,7.45 92.91,7.45 92.3,8.05 87.38,8.05 85.11,10.33 85.11,16.81 83.62,18.3 83.62,22.58 83.5,22.7 83.5,35.91 78.51,40.9 78.51,41.92 77.8,42.62 77.8,45.42 83.69,51.31 85.09,51.31 85.29,51.51 85.29,52.73 89.63,57.06 v1(90.16,57.06)
SM_INTRUDER#: length 66.8
  TOP w0.089: v2(127.18,17.66) U28.BB44
  TOP w0.102: v3(176.22,32.97) 177.04,32.16 R142.2
  L6_IN2 w0.089: v3(176.22,32.97) 175.86,32.61 172.48,32.61 171.76,33.33 163.29,33.33 162.04,34.59 154.6,34.59 153.56,33.55 153.56,32.65 152.11,31.19 149.94,31.19 144.11,25.37 142.66,25.37 138.04,20.75 134.74,20.75 132.66,18.67 128.74,18.67 127.9,17.83 127.88,17.83 127.88,17.83 127.35,17.83 v2(127.18,17.66)
SMBALERT#: length 4.5
  TOP w0.076: U28.BE25 117.55,15.95 117.18,15.59 117.18,15.22 117.03,15.07 117.03,14.42 v1(117.42,14.02)
  BOTTOM w0.102: v1(117.42,14.02) 117.32,13.92 117.04,13.92 116.28,13.16 116.15,13.16 115.9,12.91 R137.2
SMBCLK_EC: length 257.1
  TOP w0.076: U28.BF27 118.93,15.49 118.93,14.9 v1(119.73,14.1)
  TOP w0.102: v1(188.92,148.16) 188.75,148.16 188.35,147.76 U3.33
  L3_IN1 w0.089: v1(150.95,16.59) 151.71,17.35 151.71,24.13 152.73,25.15 152.73,27.73 151.35,29.11 151.35,32.89 148.19,36.05 148.19,49.62 v1(148.33,49.76)
  L6_IN2 w0.089: v1(119.73,14.1) 119.75,14.09 119.78,14.09 120.16,13.71 120.16,13.31 120.65,12.82 120.83,12.82 121.71,11.94 122.51,11.94 124.85,9.6 137.32,9.6 137.98,10.26 145.6,10.26 149,13.66 149,15.21 150.07,16.28 150.65,16.28 v1(150.95,16.59) 151.21,16.84 151.21,17.42 152.91,19.13 153.75,19.13 v1(154.13,18.75)
  L8_IN3 w0.089: v1(188.92,148.16) 189.97,147.12 189.97,139.56 190.56,138.97 190.56,134.87 193.32,132.11 193.32,103.5 189.41,99.59 189.41,98.21 190.35,97.27 190.35,86.43 188.11,84.19 188.11,66.51 183.71,62.11 183.71,53.06 183.33,52.68 183.33,46.06 184.02,45.37 184.02,44.61 184.68,43.95 185.34,43.95 187.4,41.89 187.4,40.72 v1(187.02,40.34)
  BOTTOM w0.102: v1(187.02,40.34) 186.46,40.9 185.79,40.9 184.04,42.65 174.66,42.65 171.8,45.51 163.15,45.51 159.56,49.1 149,49.1 v1(148.33,49.76) 148.33,52.05 148.07,52.32 Q58.6 146.11,52.32 C334.2 R475.1 ; v1(154.13,18.75) 154.52,19.14 154.52,25.36 156.02,26.87 156.02,27.9 156.02,27.91 U5.115
SMBCLK_KB: length 12.3
  TOP w0.102: Q60.1 126.76,8.1 R488.1 125.96,7.52 124.87,7.52 124.23,8.16 124.23,9.05 123.73,9.55 120.83,9.55 119.06,7.78 119.06,7.25 R122.1
SMBDAT_EC: length 257.7
  TOP w0.076: U28.BE27 118.74,16.02 118.54,15.82 118.54,15.55 118.77,15.32 118.77,14.83 119.18,14.43 119.18,13.95 119.56,13.57 119.74,13.57 v1(119.76,13.54)
  TOP w0.102: v1(188.7,147.53) 188.29,147.53 188.13,147.36 U3.32
  L3_IN1 w0.089: v1(149.25,49.94) 148.39,49.08 148.39,36.13 151.55,32.97 151.55,29.2 152.98,27.77 152.98,25.12 151.94,24.08 151.94,16.71 v1(151.57,16.34)
  L6_IN2 w0.089: v1(119.76,13.54) 119.76,12.89 120.03,12.62 120.75,12.62 121.79,11.58 121.79,11.03 123.55,9.26 130.32,9.26 130.95,8.64 139.64,8.64 141.06,10.06 145.69,10.06 149.2,13.57 149.2,15.12 150.16,16.08 151.31,16.08 v1(151.57,16.34) 151.57,17.5 152.82,18.75 153.49,18.75 153.89,18.35 154.49,18.35 v1(154.76,18.62)
  L8_IN3 w0.089: v1(188.7,147.53) 188.8,147.53 189.76,146.56 189.76,139.48 190.35,138.89 190.35,134.69 193.12,131.93 193.12,103.58 188.52,98.99 188.52,94.84 190.14,93.22 190.14,86.51 187.91,84.28 187.91,66.6 183.51,62.2 183.51,53.14 183.1,52.74 183.1,44.1 183.45,43.75 185.26,43.75 186.89,42.11 v1(186.89,41.1)
  BOTTOM w0.102: v1(154.76,18.62) 154.76,25.1 156.42,26.75 U5.116 ; Q58.3 149.36,51.03 C335.2 R482.1 150.52,49.94 v1(149.25,49.94) 149.07,49.76 149.07,49.41 149.17,49.3 159.76,49.3 163.25,45.82 171.78,45.82 174.75,42.85 184.12,42.85 185.88,41.1 v1(186.89,41.1)
SMBDAT_KB: length 16.6
  TOP w0.102: CNKB1.31 119.26,7.7 119.97,8.41 v4(120.39,8.41) 121.33,9.35 123.65,9.35 124.03,8.97 124.03,8.08 124.79,7.32 125.75,7.32 R487.1 126.52,6.48 126.82,6.18 128.6,6.18 129.22,6.8 Q60.4
SMC_WAKE_SCI#: length 60.3
  TOP w0.076: U28.BB24 117.8,16.66 117.8,15.57 117.8,15.47 118.08,15.2 118.08,14.39 118.24,14.23 118.32,14.23 v1(118.37,14.18)
  L6_IN2 w0.089: v1(164.93,13.36) 164.86,13.36 164.46,13.76 161.71,13.76 161.11,13.16 150.22,13.16 146.11,9.05 141.72,9.05 140.29,7.62 128.3,7.62 127.57,8.35 126.9,8.35 126.23,7.68 123.58,7.68 121.58,9.68 121.58,11.5 120.66,12.42 119.07,12.42 118.37,13.12 v1(118.37,14.18)
  BOTTOM w0.102: v1(164.93,13.36) 164.95,13.34 R114.2 165.61,13.29 R126.1
SMI#: length 4.9
  TOP w0.076: 131.14,32.34 131.01,32.21
  TOP w0.089: 131.01,32.21 129.74,30.94 129.49,30.94 128.98,30.44 U28.T48
  TOP w0.102: R336.1 132.03,33.23 131.14,32.34
SML0ALERT#: length 3
  TOP w0.076: U28.BF24 117.02,15.41 116.86,15.25 116.86,13.41
  TOP w0.102: R112.2 116.86,12.93 116.86,13.41
SML0CLK: length 3.6
  TOP w0.089: v1(117.68,13.49) 117.8,13.62 117.8,14.45 117.79,14.47 117.79,14.96 117.79,15.15 117.79,15.25 117.55,15.48 U28.BF25
  BOTTOM w0.102: R314.2 116.79,13.31 116.97,13.49 v1(117.68,13.49)
SML0DATA: length 3.9
  TOP w0.076: U28.BE24 116.86,15.94 116.81,15.9 116.81,15.48 116.67,15.33 116.67,13.55 116.53,13.41
  TOP w0.102: 116.53,13.41 115.98,12.86 R286.2
SML1ALERT#: length 4.3
  TOP w0.102: U28.BD33 121.2,16.18 121.2,14.52 121.16,14.49 121.16,14.48 121.06,14.37 121.05,14.37 120.34,13.67 120.34,12.98 R309.2
SPI0_CS1#: length 2.2
  TOP w0.089: U28.AW48 129,19.24 129.13,19.12 129.77,19.12 v1(130,19.35)
  BOTTOM w0.102: TP19.1 v1(130,19.35)
SPI0_CS2#: length 1.3
  TOP w0.102: v2(124.73,20.05) U28.AT40
  BOTTOM w0.102: TP25.1 124.66,20.12 v2(124.73,20.05)
SPI_CE#: length 12.7
  TOP w0.102: v1(149.99,26.94) 149.99,26.41 149.94,26.36 149.94,25.35 148.39,23.8 144.32,23.8 143.71,23.19 143.71,21.16
  BOTTOM w0.102: v1(149.99,26.94) 149.99,27.49 150.42,27.92 U5.101
SPI_CLK: length 7.2
  TOP w0.102: v1(150.85,26.5) 150.85,27.43 150.13,28.15 149.3,28.15 148.84,28.6 C227.1 B2.1
  BOTTOM w0.102: U5.105 152.02,28.04 151.62,27.64 151.43,27.64 151.13,27.33 151.13,26.78 v1(150.85,26.5)
SPI_CLK_EC: length 2.5
  TOP w0.102: B2.2 146.89,28.65 146.25,28.02 146.25,26.5
SPI_HOLD#: length 2
  TOP w0.102: U8.7 144.98,28.2 R168.1
SPI_SI: length 5.7
  TOP w0.102: v1(150.44,27.26) 150.44,27.38 149.99,27.84 148.23,27.84 147.52,27.13 U8.5
  BOTTOM w0.102: U5.102 150.82,27.81 150.44,27.44 v1(150.44,27.26)
SPI_SO: length 12.3
  TOP w0.102: v1(150.44,26.11) 150.44,25.48 148.51,23.55 145.06,23.55 144.73,23.22 144.73,22.81 144.98,22.56 144.98,21.16
  BOTTOM w0.102: U5.103 151.22,27.75 150.85,27.38 150.85,27.09 150.44,26.68 v1(150.44,26.11)
SPI_WP#: length 2
  TOP w0.102: R171.1 146.25,19.43 146.25,21.16
SPK_L+: length 14.1
  TOP w0.508: v1(80.61,41.1) 80.62,41.09 C258.1
  BOTTOM w0.508: AB12.2 74.93,47.44 80.61,41.76 v1(80.61,41.1) ACN1.4
SPK_L-: length 14.4
  TOP w0.508: v1(79.36,41.1) 79.35,41.09 C256.1
  BOTTOM w0.508: AB11.2 70.31,47.2 71.07,46.43 74.73,46.43 79.36,41.81 v1(79.36,41.1) ACN1.3
SPK_R+: length 14.7
  TOP w0.508: v1(76.86,41.1) 76.83,41.08 C225.1
  BOTTOM w0.508: AB8.2 67.51,47.32 70.18,44.66 74.12,44.66 76.86,41.92 v1(76.86,41.1) ACN1.1
SPK_R-: length 14.5
  TOP w0.508: C240.1 78.1,41.1 v1(78.11,41.1)
  BOTTOM w0.508: AB9.2 68.91,47.2 70.56,45.55 74.35,45.55 78.11,41.79 v1(78.11,41.1) ACN1.2
SPKL1+: length 56.2
  TOP w0.203: v1(22.05,55.65) 22.05,55.81 22.32,56.08 U7.40
  L8_IN3 w0.508: v1(22.05,55.65) 22.05,56.49 23.04,57.48 48.34,57.48 54.18,51.64 69.54,51.64 v2(71.7,49.48)
  BOTTOM w0.508: AB12.1 v2(71.7,49.48)
SPKL1-: length 53.6
  TOP w0.203: U7.41 22.72,55.72 v1(22.78,55.65)
  L8_IN3 w0.508: v2(70.31,49.48) 70.31,49.99 69.26,51.03 53.92,51.03 48.08,56.87 23.47,56.87 22.78,56.19 v1(22.78,55.65)
  BOTTOM w0.508: AB11.1 v2(70.31,49.48)
SPKR1+: length 47.7
  TOP w0.203: v1(24.74,55.22) 24.74,55.68 24.32,56.1 U7.45
  L8_IN3 w0.508: v2(67.51,49.48) 67.49,49.51 53.04,49.51 47.19,55.35 24.87,55.35 v1(24.74,55.22)
  BOTTOM w0.508: AB8.1 v2(67.51,49.48)
SPKR1-: length 49.7
  TOP w0.203: v1(24.15,55.55) 24.15,55.76 23.92,55.99 U7.44
  L8_IN3 w0.508: v2(68.91,49.48) 68.27,50.12 53.29,50.12 47.45,55.96 24.56,55.96 v1(24.15,55.55)
  BOTTOM w0.508: AB9.1 v2(68.91,49.48)
SRTCRST#: length 59.5
  TOP w0.076: v2(127.85,16.91) 128.02,16.73 U28.BD46
  TOP w0.102: v1(170.38,27.38) 170.38,24.84 170.9,24.33 Q16.3 173.95,24.33 174.07,24.21 JP2.1 174.07,23.57 174.45,23.19 175.67,23.19 C259.1 R138.2
  L6_IN2 w0.089: v1(170.38,27.38) 170.29,27.48 164.72,27.48 164.06,26.82 162.55,26.82 161.27,28.1 153.61,28.1 152.39,26.88 152.09,26.88 150.82,25.61 149.68,25.61 149.43,25.86 147.87,25.86 144.47,22.46 144.47,22.05 143.35,20.93 142.12,20.93 141.08,19.89 135.32,19.89 133.23,17.81 129.53,17.81 128.78,17.05 128.34,17.05 128.26,16.96 128.24,16.96 128.24,16.96 127.91,16.96 v2(127.85,16.91)
SS_+1.0VA: length 3.1
  TOP w0.254: C88.2 91.52,45.82 90.5,44.81 90.5,44.28 90.23,44 U17.23
SS_+3.3VA: length 3
  TOP w0.305: C87.2 176.94,16.77 177.24,16.46 178.76,16.46 179.05,16.18 U12.23
SS_+5VA: length 3.5
  TOP w0.254: U9.23 191.49,95.31 192.68,96.5 192.68,97.31 C1315.1
SS_VCCIO: length 3
  TOP w0.254: U18.23 101.42,160.49 101.42,161.17 102,161.75 102.56,161.75 102.95,162.13 C89.2
SSD1_DEVSLP4: length 29.2
  TOP w0.102: v3(147.73,32.46) 148.57,31.62 CNSSD1.38 ; v1(132.66,20.76) 132.01,21.42 129.6,21.42 129.22,21.03 128.51,21.03 128.26,20.78 U28.AR47
  L6_IN2 w0.089: v3(147.73,32.46) 145.74,32.46 143.84,30.56 138.76,30.56 132.66,24.46 v1(132.66,20.76)
SSD2_DEVSLP1: length 55.2
  TOP w0.089: U28.AH35 122.47,24.22 v2(122.48,23.8)
  TOP w0.102: CNSSD2.38 v3(171.57,32.17)
  L8_IN3 w0.089: v2(122.48,23.8) 123.14,24.46 124.28,24.46 125.55,25.73 126.41,25.73 127.2,26.53 128.69,26.53 129.36,25.86 132.92,25.86 135.89,28.83 138.46,28.83 140.35,30.72 170.12,30.72 v3(171.57,32.17)
STRAP0: length 9.3
  TOP w0.102: G1.BL3 95.76,81.87 96.24,81.87 97,81.11 97.36,81.11 99.01,79.45 99.01,78.57 99.64,77.93 99.64,76.58 R818.1 R398.1
STRAP1: length 8.8
  TOP w0.102: G1.BL4 95.83,82.5 97.36,82.5 99.26,80.6 99.26,78.62 R787.1 R790.2
STRAP2: length 6.5
  TOP w0.102: R815.2 R791.1 99.52,80.14 99.52,80.72 97.36,82.88 G1.BM4
STRAP3: length 5.7
  TOP w0.102: R819.2 R792.1 99.39,81.36 97.48,83.26 96.6,83.26 96.28,83.58 G1.BM5
STRAP4: length 10.9
  TOP w0.102: R816.1 v1(95.45,75.64) R817.2 ; G1.BK5 v1(94.43,83.9)
  L8_IN3 w0.089: v1(94.43,83.9) 93.67,83.14 93.67,81.74 94.06,81.36 94.06,79.95 94.94,79.06 94.94,76.28 95.45,75.77 v1(95.45,75.64)
STRAP5: length 13.9
  TOP w0.102: v1(96.21,73.23) R860.1 97.28,74.12 R861.2 ; G1.BJ5 94.07,83.58 v6(94.39,83.26)
  L8_IN3 w0.089: v1(96.21,73.23) 96.21,74.37 95.96,74.63 95.96,76.29 96.21,76.55 96.21,78.06 95.93,78.34 94.31,79.96 94.31,81.48 93.93,81.87 93.93,82.88 94.31,83.26 v6(94.39,83.26)
SUSACK#: length 4
  TOP w0.076: U28.BE35 122,15.67 122,14.3 121.49,13.8 121.49,13.41
  TOP w0.102: R300.2 121.49,12.98 121.49,13.41
SUSWARN#: length 6.5
  TOP w0.076: 122.88,13.41 122.82,13.48 122.82,13.5 122.8,13.52 122.8,14.71 123.25,15.17 123.25,15.36 123.55,15.66 123.55,16.43 123.54,16.44 123.54,16.68 123.55,16.69 U28.BC37
  TOP w0.102: R300.1 122.05,11.94 122.88,12.78 122.88,13.41
SW_1.2VS: length 19.1
  TOP w0.254: v1(188.19,101.73) 188.72,102.26 R3202.2 ; v1(179.88,108.54) 180.22,108.88 L13.1
  BOTTOM w0.254: v1(179.88,108.54) 179.78,108.44 179.78,107.42 182.32,104.88 182.32,102.77 183.01,102.09 183.46,102.09 185.04,103.66 187.5,103.66 187.91,103.25 187.91,102.01 v1(188.19,101.73)
SYS_PWROK: length 73
  TOP w0.076: U28.AU3 106.63,20.07 106.4,20.31 106.34,20.31 105.76,20.88 103.96,20.88
  TOP w0.102: v1(137.11,10.11) 137.49,9.73 138.89,9.73 139.14,9.99 139.14,10.7 R302.2 140.36,11.92 141.18,11.92 144.47,8.63 144.47,8.37 145.07,7.78 146.58,7.78 v1(148.67,9.86) ; 103.96,20.88 102.28,20.88 v1(102.06,20.65) 101.62,20.65 101.37,20.91 R293.2
  L8_IN3 w0.089: v1(102.06,20.65) 102.93,21.52 105.72,21.52 106.58,20.66 106.58,20.45 107.06,19.97 110.11,19.97 111.11,18.98 113.55,18.98 114.86,17.66 114.86,16.2 113.27,14.61 113.27,13.12 113.64,12.75 113.64,12.75 116.77,9.61 118.51,9.61 119.31,10.42 122.68,10.42 123.14,10.87 136.22,10.87 136.98,10.11 v1(137.11,10.11)
  BOTTOM w0.102: U5.57 151.62,11.87 149.6,9.86 v1(148.67,9.86)
SYS_RESET#: length 5.4
  TOP w0.076: U28.AU2 106.16,20.1 105.99,20.28 105.99,20.37 105.7,20.65 103.96,20.65
  TOP w0.102: R294.1 102.11,20.07 102.69,20.65 103.96,20.65
SYS_TEMP_EC: length 3.9
  BOTTOM w0.102: U5.67 144.93,15.51 RT10.2 144.62,14.11 R170.1
T/P LED_PWM: length 9.7
  TOP w0.102: v1(164.29,13.36) 165.56,12.09 167.54,12.09 168.22,12.78 169.04,12.78 R2665.2
  BOTTOM w0.102: U5.30 163.72,15.51 164.29,14.94 v1(164.29,13.36)
TBTA_CC1: length 3.9
  TOP w0.089: v3(152.32,180.09) 151.92,180.09 151.59,180.42 151.59,181.12 151.74,181.28 151.81,181.28 152.06,181.52 CON3.A5
  BOTTOM w0.102: v3(152.32,180.09) 152.65,179.76 R632.2
TBTA_CC2: length 5.6
  TOP w0.102: CON3.B5 150.31,182.77 150.67,182.4 v1(150.67,182.38)
  L3_IN1 w0.089: v1(150.67,182.38) 150.67,180.39 v1(150.44,180.17)
  BOTTOM w0.102: R793.2 151.76,179.48 151.33,179.91 150.7,179.91 v1(150.44,180.17)
TEMP_MPS: length 5.3
  TOP w0.203: R533.1 R532.1 C1170.1 183.13,153.01 183.13,150.57 183.48,150.23 U3.45
TMDSB_CLK+: length 4
  TOP w0.102: C404.2 64.17,168.66 64.17,170.68 R425.2 64.21,171.07 64.21,171.53 64.42,171.74 L25.4
TMDSB_CLK-: length 4
  TOP w0.102: C365.2 63.74,168.66 63.74,170.68 R427.2 63.78,171.15 63.78,171.7 63.62,171.86 L25.1
TMDSB_D0+: length 4
  TOP w0.102: L27.4 71.98,171.8 71.79,171.62 71.79,170.22 R426.2 71.79,169.79 71.79,168.66 C409.2
TMDSB_D0-: length 4
  TOP w0.102: L27.1 71.18,171.8 71.36,171.62 71.36,170.22 R429.2 71.36,169.79 71.36,168.66 C408.2
TMDSB_D1+: length 4
  TOP w0.102: C369.2 66.84,168.66 66.84,169.79 R418.2 66.8,170.26 66.8,171.71 66.96,171.87 L26.4
TMDSB_D1-: length 4
  TOP w0.102: L26.1 66.16,171.86 66.37,171.65 66.37,170.19 R428.2 66.41,169.79 66.41,168.66 C403.2
TMDSB_D2+: length 4
  TOP w0.102: L24.4 69.49,171.85 69.28,171.64 69.28,171.08 R408.2 69.25,170.68 69.25,168.66 C414.2
TMDSB_D2-: length 4
  TOP w0.102: C411.2 68.82,168.66 68.82,170.68 R424.2 68.85,171.14 68.85,171.72 68.69,171.88 L24.1
TON_+1.0VA: length 1.7
  TOP w0.254: U17.6 86.33,45.27 85.8,45.8 R1397.2
TON_+3.3VA: length 2
  TOP w0.305: R879.2 177.32,11.71 178.06,12.45 U12.6
TON_+5VA: length 1.2
  TOP w0.254: U9.6 188.18,97.23 R224.2
TP20: length 5.2
  TOP w0.102: TP20.1 99.39,95.99 98.87,96.51 95.16,96.51 94.79,96.88 G1.BK24
TP23: length 5
  TOP w0.1: 99.59,94.49 98.21,95.87 96,95.87 95.69,96.18 G1.BL23
  TOP w0.102: 99.59,94.49 TP23.1
TP32: length 5.1
  TOP w0.102: TP32.1 99.47,95.33 98.61,96.18 G1.BM23
TP34: length 4.9
  TOP w0.102: TP34.1 100.53,97.19 96.45,97.19 G1.BM24
TP35: length 9.6
  TOP w0.1: G1.BL24 95.56,96.88 96.06,97.39 100.96,97.39 101.27,97.08 101.27,95.86 101.78,95.35 TP35.1
  TOP w0.102: R2799.1 101.98,94.62 102.36,95 TP35.1
TP36: length 8.3
  TOP w0.102: G1.BK23 95,96.18 95.36,95.83 95.67,95.83 95.83,95.67 98.04,95.67 100.03,93.68 TP36.1 R2800.1
TP_CLK: length 91.3
  TOP w0.102: R1000.2 107.26,8.84 106.95,9.15 106.95,9.3 107.14,9.48 107.71,9.48 109.62,7.57 112.06,7.57 112.75,6.88 112.75,4.39 113.92,3.22 115.85,3.22 116.31,2.76 116.31,2.16 v1(116.15,2.01) ; L48.2 153.6,11.45 R472.2 153.41,11.69 153.87,12.14 153.87,13.34 C297.1 153.36,13.92 153.87,14.43 153.87,16.97 154.76,17.86 156.03,17.86 v1(156.29,17.61)
  L8_IN3 w0.089: v1(116.15,2.01) 116.33,2.19 116.33,2.4 116.78,2.85 118.22,2.85 119.55,4.17 145.8,4.17 147.22,5.59 147.22,9.69 148.79,11.26 153.49,11.26 156.09,13.86 156.09,16.02 156.29,16.21 v1(156.29,17.61)
  BOTTOM w0.102: v1(156.29,17.61) 155.07,17.61 154.03,16.56 152.61,16.56 150.29,18.87 150.29,22.74 148.73,24.31 U5.89
TP_DATA: length 96.1
  TOP w0.102: v1(116.73,2.01) 116.51,2.23 116.51,2.84 115.93,3.42 114.01,3.42 112.95,4.47 112.95,6.96 112.14,7.78 109.7,7.78 107.8,9.68 107.05,9.68 106.75,9.38 106.75,9.17 R940.2 ; L48.3 154.4,11.45 R460.2 154.58,11.69 154.13,12.14 154.13,13.34 C298.1 154.58,13.85 154.13,14.3 154.13,16.84 154.89,17.61 155.65,17.61 156.16,17.1 156.79,17.1 157.3,17.61 v1(157.3,18.37)
  L8_IN3 w0.089: v1(157.3,18.37) 157.3,16.84 156.54,16.08 156.54,13.92 153.62,11 148.92,11 147.43,9.51 147.43,5.5 145.89,3.97 119.63,3.97 118.31,2.64 116.9,2.64 116.58,2.33 116.58,2.16 v1(116.73,2.01)
  BOTTOM w0.102: U5.90 148.62,24.71 150.49,22.83 150.49,18.96 152.69,16.76 153.94,16.76 155.55,18.37 v1(157.3,18.37)
TP_INT#: length 37.2
  TOP w0.102: v1(127.08,23.07) 127.08,22.9 U28.AM45 ; v1(111.84,9.12) 111.3,8.59 109.42,8.59 107.96,10.05 106.06,10.05 105.49,9.48 R3521.2
  L3_IN1 w0.089: v1(127.08,23.07) 127.35,22.79 127.35,21.36 127.05,21.06 126.26,21.06 125.58,21.75 125.02,21.75 124.64,22.13 124.05,22.13 122.93,21.01 122.42,21.01 122,20.58 122,20.2 121.66,19.87 121.42,19.87 121.06,19.51 121.06,18.83 121.73,18.16 121.73,15.08 122.01,14.79 122.01,14.39 121.49,13.86 121.49,12.91 120.9,12.32 115.57,12.32 113.87,10.62 113.23,10.62 112.47,9.86 112.47,9.76 v1(111.84,9.12)
TP_LED_PWM_OUT: length 3.9
  TOP w0.102: v4(174.85,9.68) 174.47,9.68 R2667.2 174.42,8.67 CN42.6
TP_P: length 5.6
  TOP w0.305: CN17.8 v1(106.35,4.88)
  BOTTOM w0.102: v3(107.14,7.62) R3523.2
  BOTTOM w0.305: R253.2 R3523.2 106.91,6.51 C291.1 106.12,5.11 v1(106.35,4.88)
TR0+: length 9.6
  TOP w0.102: v1(87.11,169.98) 87.19,169.98 87.45,170.25 87.45,171.15 87.15,171.45 LT2.17
  L8_IN3 w0.076: CN34.1 83.93,175.06 84.36,175.06 84.58,174.84 84.58,174.3 87.55,171.33 87.55,170.1 87.43,169.98 v1(87.11,169.98)
TR0-: length 9.6
  TOP w0.102: v1(88.18,169.98) 88.05,169.98 87.88,170.14 87.88,171.12 88.15,171.39 LT2.16
  L8_IN3 w0.076: v1(88.18,169.98) 88.08,169.98 87.86,170.2 87.86,171.46 84.89,174.42 84.89,174.97 84.75,175.1 CN34.2
TR1+: length 10.3
  TOP w0.102: LT2.14 90.4,171.54 90.4,171.1 90.07,170.77 89.6,170.77 89.2,170.37 89.2,169.73 v1(89.1,169.62)
  L8_IN3 w0.076: v1(89.1,169.62) 89.27,169.79 89.27,171.57 88,172.84 88,173.44 86.57,174.87 CN34.3
TR1-: length 10.3
  TOP w0.102: LT2.13 90.84,171.49 90.84,170.93 90.25,170.34 89.78,170.34 89.64,170.19 89.64,169.8 v1(89.81,169.62)
  L8_IN3 w0.076: v1(89.81,169.62) 89.57,169.87 89.57,171.69 88.3,172.96 88.3,173.53 88.67,173.9 88.67,175.81 CN34.6
TR2+: length 12.3
  TOP w0.102: v1(81.11,169.98) 81.43,170.3 81.43,170.7 81.15,170.99 LT2.23
  L6_IN2 w0.076: CN34.4 86.79,175.15 86.65,175 86.65,174.11 86.18,173.65 83.03,173.65 81.36,171.97 81.36,170.22 v1(81.11,169.98)
TR2-: length 12.2
  TOP w0.102: v1(82.18,169.98) 81.86,170.3 81.86,170.7 82.15,170.99 LT2.22
  L6_IN2 w0.076: v1(82.18,169.98) 82.11,169.98 81.65,170.44 81.65,171.85 83.15,173.35 86.3,173.35 86.94,173.99 86.94,174.88 87.07,175.01 87.68,175.01 CN34.5
TR3+: length 13.8
  TOP w0.102: LT2.20 84.15,170.99 84.43,170.7 84.43,170.3 v1(84.11,169.98)
  L6_IN2 w0.076: CN34.7 90.04,175.06 90.72,175.06 91.05,174.74 91.05,173.58 89.98,172.52 85.38,172.52 84.54,171.68 84.54,170.41 v1(84.11,169.98)
TR3-: length 13.8
  TOP w0.102: LT2.19 85.15,170.99 84.86,170.7 84.86,170.3 v1(85.18,169.98)
  L6_IN2 w0.076: v1(85.18,169.98) 84.83,170.32 84.83,171.55 85.5,172.22 90.1,172.22 91.34,173.46 91.34,174.86 90.87,175.32 CN34.8
TS_VREF: length 9.6
  TOP w0.102: G1.BF12 91.95,88.42 92.28,88.09 96.47,88.09 97.23,88.85 TP21.1
TYPC_RX1+: length 8.9
  TOP w0.102: CON3.B11 153.81,182.93 153.64,182.77 v1(153.64,182.4)
  TOP w0.114: v2(155.09,180.07) 154.74,179.72 154.74,179.23 154.87,179.1 ESD2.6 ESD2.5 154.87,177.48 154.74,177.35 154.74,176.99 154.93,176.8 154.93,176.18 155.21,175.9 L37.1
  BOTTOM w0.114: v1(153.64,182.4) 153.64,182.21 153.5,182.07 153.49,181.66 154.02,181.13 154.31,181.13 154.74,180.7 154.74,180.42 v2(155.09,180.07)
TYPC_RX1-: length 8.9
  TOP w0.102: v1(153.08,182.4) 153.31,182.63 CON3.B10
  TOP w0.114: L37.4 154.41,175.88 154.69,176.16 154.69,176.7 154.5,176.89 154.5,177.38 154.37,177.51 ESD2.4 ESD2.7 154.37,179.1 154.5,179.23 154.5,179.72 v2(154.15,180.07)
  BOTTOM w0.114: v1(153.08,182.4) 153.08,182.23 153.25,182.05 153.25,181.56 153.92,180.89 154.21,180.89 154.5,180.6 154.5,180.42 v2(154.15,180.07)
TYPC_RX2+: length 7
  TOP w0.114: L38.4 149.1,175.93 149.38,176.21 149.38,176.54 150.08,177.24 150.08,177.4 149.95,177.53 ESD1.6 ESD1.5 149.95,179.1 150.08,179.23 150.08,179.46 149.18,180.35 149.18,181.15 149.06,181.28 CON3.A11
TYPC_RX2-: length 7
  TOP w0.114: CON3.A10 149.55,181.28 149.43,181.15 149.43,180.45 150.32,179.56 150.32,179.23 150.45,179.1 ESD1.4 ESD1.7 150.45,177.53 150.32,177.4 150.32,177.14 149.62,176.44 149.62,176.23 149.9,175.96 L38.1
TYPC_TX1+: length 6.4
  TOP w0.114: L45.1 153.46,175.88 153.18,176.16 153.18,176.76 153.24,176.82 153.24,177.38 153.37,177.51 ESD2.2 ESD2.9 153.37,179.1 153.24,179.23 153.24,179.71 153.43,179.89 153.43,181.15 153.55,181.28 CON3.A2
TYPC_TX1-: length 6.4
  TOP w0.114: CON3.A3 153.06,181.28 153.18,181.15 153.18,179.99 153,179.81 153,179.23 152.87,179.1 ESD2.10 ESD2.1 152.87,177.48 153,177.35 153,176.92 152.94,176.86 152.94,176.18 152.66,175.9 L45.4
TYPC_TX2+: length 7.5
  TOP w0.102: v1(148.97,182.4) 148.97,182.78 148.8,182.95 CON3.B2
  BOTTOM w0.114: L44.1 147.1,177.35 147.41,177.66 147.41,177.98 147.59,178.16 147.59,178.34 147.44,178.5 ESD3.10 ESD3.1 147.44,180.09 147.57,180.22 147.57,180.68 147.93,181.04 148.45,181.04 149.13,181.72 149.13,181.99 148.97,182.15 v1(148.97,182.4)
TYPC_TX2-: length 7.5
  TOP w0.102: v1(149.53,182.4) 149.5,182.4 149.31,182.6 CON3.B3
  BOTTOM w0.114: L44.4 147.9,177.33 147.65,177.57 147.65,177.88 147.83,178.06 147.83,178.39 147.94,178.5 ESD3.9 ESD3.2 147.94,180.09 147.81,180.22 147.81,180.58 148.03,180.8 148.55,180.8 149.37,181.62 149.37,182.01 149.53,182.17 v1(149.53,182.4)
TYPE_C_D1+: length 6.8
  TOP w0.114: L36.1 151.68,175.93 151.51,176.1 151.51,176.53 151.85,176.87 151.85,177.38 151.95,177.48 ESD1.10 ESD1.1 151.95,178.91 151.81,179.05 151.81,179.51 151.21,180.12 151.21,181.18 151.39,181.37 151.39,181.37 151.55,181.53 CON3.A6
TYPE_C_D1-: length 6.8
  TOP w0.114: CON3.A7 151.06,181.38 150.96,181.28 150.96,180.02 151.57,179.41 151.57,179.01 151.45,178.89 ESD1.2 ESD1.9 151.45,177.51 151.61,177.35 151.61,176.97 151.27,176.63 151.27,176.29 150.88,175.9 L36.4
TYPE_C_D2+: length 8.4
  TOP w0.102: v1(151.23,182.34) 151.23,182.53 150.8,182.95 CON3.B6
  BOTTOM w0.114: v1(151.23,182.34) 151.23,182.22 151.48,181.97 151.48,181.62 150.76,180.9 149.52,180.9 149.07,180.44 149.07,180.06 148.94,179.93 ESD3.4 ESD3.7 148.94,178.5 149.07,178.37 149.07,178.04 149.17,177.93 149.17,177.6 148.95,177.38 L34.1
TYPE_C_D2-: length 8.3
  TOP w0.102: CON3.B7 151.81,183.05 151.63,182.87 151.63,182.54 151.81,182.35 v1(151.84,182.35)
  BOTTOM w0.114: v1(151.84,182.35) 151.72,182.23 151.72,181.52 150.86,180.65 149.62,180.65 149.31,180.34 149.31,180.03 149.44,179.9 ESD3.5 ESD3.6 149.44,178.5 149.31,178.37 149.31,178.14 149.41,178.03 149.41,177.69 149.75,177.35 L34.4
TYPE_C_OC#: length 248.8
  TOP w0.089: U28.AH36 v1(123.12,23.81)
  TOP w0.102: U27.5 v1(141.77,168.78)
  L3_IN1 w0.089: v1(141.77,168.78) 141.93,168.61 170.56,168.61 176.05,163.13 176.05,159.84 179.23,156.65 180.98,156.65 181.81,157.48 185.54,157.48 186.22,156.8 186.61,156.8 187.37,156.04 187.69,156.04 188.57,155.15 188.57,150.54 190.09,149.03 190.09,148.43 189.89,148.24 189.89,135.78 192.31,133.36 192.31,109.25 190.07,107.01 190.07,105.36 190.7,104.73 190.7,102.82 187.15,99.27 187.15,95.28 190.86,91.57 190.86,78.25 189.92,77.31 189.92,66.68 183.31,60.07 183.31,51.39 181.58,49.66 181.58,48.57 179.05,46.05 v1(175.64,46.05)
  L6_IN2 w0.089: v1(175.64,46.05) 175.18,46.05 172.37,43.24 172.37,40.35 170.39,38.37 161.1,38.37 158.25,35.51 153.2,35.51 144.75,27.05 143.31,27.05 138.52,22.26 135.3,22.26 133,19.95 131.24,19.95 130.66,20.53 130.66,20.84 127.63,23.88 125.45,23.88 124.89,24.44 123.75,24.44 v1(123.12,23.81)
  BOTTOM w0.102: R81.2 123.21,23.9 v1(123.12,23.81)
UART2_DEBUG_RXD: length 41.6
  TOP w0.076: v1(114.25,14.68) 114.68,14.68 114.99,15 114.99,15.3 115.27,15.57 115.27,15.75 115.39,15.87 115.39,16.39 115.28,16.5 U28.BD20
  TOP w0.102: v1(142.06,8.21) 141.53,8.21 141.05,7.72 TP2.1 141.24,7.7 141.71,7.23 141.71,5.87 R327.2 141.28,5.23 CNDEG2.3
  L6_IN2 w0.089: v1(114.25,14.68) 114.47,14.68 115.01,14.14 115.01,13.96 116.08,12.89 118.02,12.89 118.9,12.01 120.49,12.01 121.18,11.33 121.18,9.51 123.45,7.24 126.36,7.24 127.07,7.95 127.4,7.95 128.13,7.22 140.46,7.22 141.45,8.21 v1(142.06,8.21)
UART2_DEBUG_TXD: length 40.5
  TOP w0.076: U28.BE20 115.18,15.9 115.1,15.82 115.1,15.67 v1(114.63,15.19)
  TOP w0.102: v1(142.86,8.21) 142.86,7.99 142.57,7.7 TP1.1 142.32,7.7 141.91,7.29 141.91,5.93 142.32,5.53 R329.2 142.08,5.1 CNDEG2.4
  L6_IN2 w0.089: v1(142.86,8.21) 142.46,8.61 141.57,8.61 140.38,7.42 128.21,7.42 127.48,8.15 126.98,8.15 126.28,7.45 123.53,7.45 121.38,9.59 121.38,11.41 120.58,12.21 118.99,12.21 118.11,13.09 116.17,13.09 115.26,13.99 115.26,14.18 114.63,14.81 v1(114.63,15.19)
UG1_NVD: length 27.7
  TOP w0.305: U722.2 15.95,116.54 v1(15.7,116.79)
  TOP w0.508: PQ42.1 12.19,131.19 v1(12.39,131.4) ; v1(17.22,131.4) R1060.2 18.67,130.81 18.16,130.31 PQ43.1
  L3_IN1 w0.508: v1(12.39,131.4) 13.79,130 16.08,130 17.22,131.14 v1(17.22,131.4)
  BOTTOM w0.508: v1(15.7,116.79) 13.38,119.1 13.38,125.07 12.39,126.06 v1(12.39,131.4)
UG2_NVD: length 37.8
  TOP w0.305: v1(22.55,116.67) 22.43,116.54 U722.17
  TOP w0.508: v1(8.2,138) 8.23,138.03 PQ41.1 ; v1(14.17,138) 14.2,138.03 PQ40.1 ; R1061.2 v1(17.98,137.62)
  L6_IN2 w0.508: v1(8.2,138) v1(14.17,138) 17.6,138 v1(17.98,137.62) 18.24,137.37 18.24,124.92 19.38,123.78 19.38,121.87 20.14,121.11 20.14,118.44 21.92,116.67 v1(22.55,116.67)
UG3_NVD: length 22.5
  TOP w0.508: v1(18.53,157.69) 18.03,157.18 PQ48.1 ; v1(24.33,149.77) 24.03,150.07 R1066.2 ; v1(13.41,157.69) 12.86,157.69 PQ49.1
  L6_IN2 w0.508: v1(13.41,157.69) v1(18.53,157.69) 18.62,157.6 18.62,152.1 21.41,149.3 23.82,149.3 24.29,149.77 v1(24.33,149.77)
  BOTTOM w0.254: U32.1 23.42,149.43 23.95,149.43 24.29,149.77 v1(24.33,149.77)
UG_MEM: length 19
  TOP w0.254: v1(8.08,100.26) 8.05,100.28 7.82,100.28 7.43,100.67 U84.9
  TOP w0.508: PQ53.1 5.36,91.29 v1(5.41,91.34) ; v1(11.12,91.27) 11.2,91.19 PQ52.1
  L3_IN1 w0.508: v1(5.41,91.34) 5.49,91.27 v1(11.12,91.27) 11.12,94.19 8.08,97.23 v1(8.08,100.26)
USB1_5V:
  vias: v1(107.26,167.21) v1(107.9,167.21) v1(108.53,167.21)
USB3_TX1_N_C: length 3.4
  TOP w0.076: U28.F9 109.9,34.76 v2(109.9,34.65)
  BOTTOM w0.114: C261.2 109.55,37.04 109.35,36.83 109.35,35.82 109.7,35.46 109.7,34.85 v2(109.9,34.65)
USB3_TX1_P_C: length 3.4
  TOP w0.076: U28.F7 109.14,35.19 109.14,34.93 v2(109.09,34.88)
  BOTTOM w0.114: C498.2 109.1,36.64 109.1,35.72 109.46,35.36 109.46,35.07 109.33,34.93 109.15,34.93 v2(109.09,34.88)
USB3_TX3_N_C: length 3.6
  TOP w0.089: v2(111.2,35.02) 111.19,35.02 111.04,35.16 U28.F11
  BOTTOM w0.114: v2(111.2,35.02) 111.24,35.06 111.52,35.06 111.52,35.06 111.7,35.23 111.7,35.44 111.04,36.1 111.04,36.57 110.51,37.09 C268.2
USB3_TX3_P_C: length 3.6
  TOP w0.089: U28.G12 111.61,34.5 v2(111.63,34.52)
  BOTTOM w0.114: v2(111.63,34.52) 111.72,34.61 111.72,34.92 111.94,35.13 111.94,35.54 111.28,36.2 111.28,37.04 C271.2
USB3_TX5_N_C: length 4.1
  TOP w0.076: v2(113.08,38.94) 112.75,38.61 112.75,37.71 112.34,37.3 112.34,36.83 112.42,36.75 112.53,36.75 112.62,36.85 U28.B15
  BOTTOM w0.114: C270.2 112.81,39.59 112.81,39.11 112.98,38.94 v2(113.08,38.94)
USB3_TX5_P_C: length 4.1
  TOP w0.076: v2(112.32,38.94) 112.6,38.66 112.6,37.77 112.19,37.37 112.19,36.7 U28.C15
  BOTTOM w0.114: v2(112.32,38.94) 112.57,39.2 112.57,39.58 112.27,39.88 C275.2
USB3_TX6_N_C: length 4.8
  TOP w0.114: C269.2 115.34,39.88 115.01,39.55 115.01,38.48 114.71,38.18 113.7,38.18 113.23,37.71 113.23,36.91 U28.C17
USB3_TX6_P_C: length 4.8
  TOP w0.114: C262.2 114.77,39.61 114.77,38.59 114.6,38.42 113.6,38.42 112.99,37.81 U28.C16
USB31_1_RX_N: length 179.6
  TOP w0.076: 110.72,39.32 110.72,37.52 110.78,37.45 110.78,37.04 110.99,36.82 110.99,36.35 110.88,36.24 U28.D11
  TOP w0.114: v2(111.71,41.35) 111.5,41.35 111.12,40.97 111.12,40.52 110.76,40.16 110.76,39.39 110.72,39.35 110.72,39.32 ; v2(155.14,171.15) 155.14,171.57 154.61,172.1 154.61,173.18 154.41,173.38 L37.3
  L8_IN3 w0.102: v2(111.71,41.35) 112.14,41.79 112.59,41.79 112.9,42.1 112.9,45.3 114.38,46.77 114.38,62.94 112.34,64.98 112.34,70.54 110.79,72.09 110.79,86.57 111.69,87.47 111.69,105.05 112.11,105.47 112.11,125.53 111.91,125.74 111.91,127.82 112.29,128.2 112.29,137.91 117.19,142.81 117.19,152.91 120.8,156.52 120.8,166.58 124.23,170.01 141.43,170.01 142.24,169.19 151.79,169.19 154.46,171.86 155.09,171.86 155.27,171.68 155.27,171.28 v2(155.14,171.15)
USB31_1_RX_P: length 179.6
  TOP w0.076: 110.52,39.4 110.52,39.24 110.57,39.19 110.57,37.45 110.63,37.39 110.63,36.97 110.79,36.81 U28.C11
  TOP w0.114: 110.52,39.4 110.52,40.26 110.88,40.62 110.88,41.07 111.17,41.37 111.17,41.58 v2(111.58,41.99) ; L37.2 155.21,173.38 154.85,173.02 154.85,172.2 155.52,171.53 v2(155.78,171.53)
  L8_IN3 w0.102: v2(111.58,41.99) 112.51,41.99 112.7,42.18 112.7,45.38 114.17,46.85 114.17,62.86 112.14,64.89 112.14,70.46 110.59,72.01 110.59,86.65 111.49,87.55 111.49,105.13 111.91,105.56 111.91,125.45 111.71,125.65 111.71,127.9 112.09,128.28 112.09,137.99 116.99,142.89 116.99,153 120.6,156.61 120.6,166.66 124.15,170.21 141.51,170.21 142.32,169.4 151.71,169.4 154.37,172.06 155.18,172.06 155.71,171.53 v2(155.78,171.53)
USB31_1_TX_N: length 179.1
  TOP w0.114: v2(152.66,172.8) 152.73,172.8 152.96,173.03 152.96,173.33 152.66,173.63 L45.3
  L8_IN3 w0.102: v2(152.66,172.8) 152.77,172.8 153.24,172.33 153.24,172.05 152.87,171.68 149.99,171.68 148.82,172.85 142.97,172.85 142.26,172.14 135.28,172.14 134.8,171.66 123.64,171.66 119.5,167.52 118.75,167.52 118.1,167.52 115.24,164.66 115.24,150.1 114.48,149.34 114.48,147.48 114.48,145.63 114.48,142.32 110.72,138.56 110.72,128.85 110.34,128.47 110.34,125.08 110.54,124.88 110.54,106.13 110.11,105.7 110.11,88.12 109.22,87.22 109.22,71.44 110.72,69.94 110.72,64.37 112.47,62.62 112.47,47.09 111.33,45.95 111.33,44.05 109.22,41.95 109.22,41.06 108.29,40.13 107.95,40.13 107.78,40.3 v1(107.78,40.49)
  BOTTOM w0.114: v1(107.78,40.49) 107.89,40.39 108.4,40.39 108.66,40.13 108.66,39.25 109.19,38.71 109.19,38.33 109.52,38 C261.1
USB31_1_TX_P: length 179.1
  TOP w0.114: v2(153.49,172.8) 153.36,172.8 153.2,172.96 153.2,173.4 153.46,173.66 L45.2
  L8_IN3 w0.102: v1(107.54,39.83) 107.64,39.93 108.38,39.93 109.42,40.97 109.42,41.86 111.53,43.97 111.53,45.87 112.67,47.01 112.67,62.71 110.92,64.46 110.92,70.02 109.42,71.52 109.42,87.14 110.32,88.03 110.32,105.62 110.74,106.04 110.74,124.96 110.54,125.17 110.54,128.38 110.92,128.77 110.92,138.47 114.68,142.23 114.68,145.63 114.68,147.48 114.68,149.25 115.44,150.01 115.44,164.57 118.18,167.31 118.67,167.31 119.58,167.31 123.72,171.45 134.88,171.45 135.36,171.94 142.34,171.94 143.05,172.65 148.73,172.65 149.9,171.48 152.96,171.48 153.44,171.96 153.44,172.75 v2(153.49,172.8)
  BOTTOM w0.114: C498.1 108.74,38 108.91,38.18 108.91,38.21 108.95,38.24 108.95,38.61 108.42,39.15 108.42,40.03 108.3,40.15 108.14,40.15 107.97,39.98 107.69,39.98 v1(107.54,39.83)
USB31_3_RX_N: length 177.1
  TOP w0.076: v2(109.3,40.11) 109.3,40.06 109.73,39.63 110.01,39.63 110.21,39.42 110.21,37.04 110.29,36.96 110.42,36.96 U28.B10
  TOP w0.114: L38.2 149.9,173.63 149.44,173.17 149.44,170.74 149.64,170.54 150.21,170.54 150.34,170.67 v2(150.34,170.91)
  L8_IN3 w0.102: v2(109.3,40.11) 109.65,39.75 109.9,39.75 110.87,40.72 110.87,42.58 112.01,43.72 112.01,45.67 113.16,46.81 113.16,62.91 111.4,64.66 111.4,70.22 109.9,71.73 109.9,86.94 110.8,87.83 110.8,105.42 111.23,105.84 111.23,125.16 111.02,125.37 111.02,128.18 111.4,128.57 111.4,138.27 115.16,142.03 115.16,149.05 115.92,149.81 115.92,164.37 118.38,166.83 119.8,166.83 123.94,170.97 141.72,170.97 142.61,170.08 148.96,170.08 149.42,170.54 149.97,170.54 v2(150.34,170.91)
USB31_3_RX_P: length 177.2
  TOP w0.076: v2(109.3,39.35) 109.42,39.47 109.94,39.47 110.06,39.36 110.06,36.9 110.27,36.69 U28.C10
  TOP w0.114: v2(150.34,169.97) 150.02,170.3 149.54,170.3 149.2,170.64 149.2,173.54 149.1,173.63 L38.3
  L8_IN3 w0.102: v2(109.3,39.35) 109.5,39.55 109.98,39.55 111.07,40.64 111.07,42.5 112.22,43.64 112.22,45.58 113.36,46.72 113.36,62.99 111.61,64.74 111.61,70.31 110.11,71.81 110.11,86.85 111,87.75 111,105.33 111.43,105.76 111.43,125.25 111.23,125.45 111.23,128.1 111.61,128.48 111.61,138.19 115.37,141.95 115.37,148.97 116.13,149.73 116.13,164.29 118.47,166.63 119.88,166.63 124.02,170.77 141.63,170.77 142.52,169.88 149.05,169.88 149.5,170.34 149.98,170.34 v2(150.34,169.97)
USB31_3_TX_N: length 178.6
  L8_IN3 w0.102: v2(145.74,173.43) 145.19,173.99 144.88,173.99 144.78,173.89 144.48,173.89 144.38,173.99 143.96,173.99 143.86,173.89 143.56,173.89 143.46,173.99 142.7,173.99 141.33,172.62 135.06,172.62 134.63,172.19 122.54,172.19 120.1,169.75 119.65,169.75 114.76,164.86 114.76,150.3 113.99,149.54 113.99,144.71 110.23,140.95 110.23,129.05 109.55,128.36 109.55,88.24 108.73,87.42 108.73,71.24 110.23,69.74 110.23,64.17 111.84,62.57 111.84,47.14 110.84,46.15 110.84,44.26 109.37,42.78 108.4,42.78 107.03,41.41 107.03,39.3 108.15,38.18 109.82,38.18 110.23,38.59 110.23,38.71 111.33,39.8 v2(111.33,39.96)
  BOTTOM w0.114: C268.1 110.59,38.15 110.59,39.44 110.85,39.69 111.06,39.69 v2(111.33,39.96) ; L44.3 147.9,175.08 147.78,174.96 147.78,174.32 146.89,173.43 v2(145.74,173.43)
USB31_3_TX_P: length 178.6
  L8_IN3 w0.102: v2(111.45,39.2) 111.01,39.2 110.44,38.63 110.44,38.51 109.9,37.98 108.07,37.98 106.83,39.21 106.83,41.5 108.31,42.98 109.28,42.98 110.64,44.34 110.64,46.23 111.63,47.22 111.63,62.49 110.03,64.09 110.03,69.66 108.53,71.16 108.53,87.51 109.35,88.32 109.35,128.45 110.03,129.13 110.03,141.03 113.79,144.79 113.79,149.62 114.55,150.38 114.55,164.94 119.57,169.95 120.01,169.95 122.45,172.39 134.54,172.39 134.97,172.82 141.25,172.82 142.62,174.2 v2(145.74,174.2)
  BOTTOM w0.114: L44.2 147.1,174.82 147.21,174.7 147.41,174.7 147.52,174.59 147.52,174.41 146.79,173.68 146.26,173.68 v2(145.74,174.2) ; C271.1 110.83,38.5 110.83,39.33 110.95,39.45 111.2,39.45 v2(111.45,39.2)
USB31_5_RX_N: length 151
  TOP w0.102: U28.K13 111.62,33.3 v2(111.25,33.3)
  TOP w0.114: L67.2 114.39,169.64 114.22,169.47 114.22,168.7 113.8,168.28 113.51,168.28 v2(113.28,168.05)
  L8_IN3 w0.102: v2(111.25,33.3) 111.19,33.37 110.52,33.37 110.01,33.88 109.66,33.88 109.37,34.17 108.74,34.17 108.43,34.47 107.34,34.47 106.93,34.88 106.93,37.93 105.99,38.87 105.81,38.87 105.23,39.44 105.23,41.86 105.56,42.19 106.56,42.19 108.03,43.67 109,43.67 109.96,44.62 109.96,46.52 110.74,47.31 110.74,61.84 108.91,63.67 108.91,69.8 107.11,71.61 107.11,79.08 107.85,79.82 107.85,87.79 108.66,88.61 108.66,128.73 109.35,129.42 109.35,141.39 113.11,145.15 113.11,149.9 113.87,150.67 113.87,165.22 114.17,165.53 114.17,168.02 113.88,168.3 113.53,168.3 v2(113.28,168.05)
USB31_5_RX_P: length 151
  TOP w0.102: U28.J13 111.08,33.86 v2(110.95,33.99)
  TOP w0.114: L67.3 113.59,169.64 113.98,169.26 113.98,168.8 113.7,168.52 113.54,168.52 113.25,168.81 v2(113.15,168.81)
  L8_IN3 w0.102: v2(110.95,33.99) 110.95,33.73 110.78,33.57 110.6,33.57 110.09,34.08 109.75,34.08 109.46,34.37 108.82,34.37 108.52,34.67 107.42,34.67 107.14,34.96 107.14,38.01 106.08,39.07 105.89,39.07 105.43,39.53 105.43,41.78 105.65,41.99 106.64,41.99 108.11,43.46 109.08,43.46 110.16,44.54 110.16,46.43 110.95,47.22 110.95,61.93 109.12,63.76 109.12,69.89 107.31,71.69 107.31,79 108.05,79.73 108.05,87.71 108.86,88.52 108.86,128.65 109.55,129.33 109.55,141.3 113.31,145.06 113.31,149.82 114.07,150.58 114.07,165.14 114.38,165.45 114.38,168.1 113.97,168.51 113.54,168.51 113.24,168.81 v2(113.15,168.81)
USB31_5_TX_N: length 142.7
  TOP w0.114: v2(110.95,168.45) 110.51,168.01 110.04,168.01 109.39,168.66 109.39,169.11 109.55,169.27 109.85,169.27 109.95,169.37 L66.2
  L8_IN3 w0.102: v2(108.53,44.91) 108.33,44.71 108.07,44.71 107.75,45.04 107.75,45.27 108.53,46.05 108.53,49.19 110.06,50.72 110.06,61.39 107.49,63.96 107.49,70.21 106.58,71.12 106.58,74.47 106.32,74.72 106.32,86.95 108.18,88.81 108.18,128.93 108.86,129.62 108.86,143.73 112.24,147.11 112.24,158.14 113.38,159.28 113.38,165.43 113.66,165.7 113.66,166.91 112.29,168.28 111.12,168.28 v2(110.95,168.45)
  BOTTOM w0.114: C270.1 113,40.9 113,42.56 110.81,44.75 108.69,44.75 v2(108.53,44.91)
USB31_5_TX_P: length 142.7
  TOP w0.114: v2(111.02,167.69) 110.94,167.77 109.94,167.77 109.15,168.56 L66.3
  L8_IN3 w0.102: v2(111.02,167.69) 111.02,167.81 111.29,168.07 112.21,168.07 113.46,166.82 113.46,165.79 113.18,165.51 113.18,159.36 112.04,158.22 112.04,147.19 108.66,143.82 108.66,129.7 107.97,129.02 107.97,88.89 106.12,87.04 106.12,74.64 106.37,74.39 106.37,71.04 107.29,70.12 107.29,63.87 109.85,61.31 109.85,50.8 108.33,49.28 108.33,46.14 107.54,45.35 107.54,44.95 107.99,44.5 108.18,44.5 v2(108.47,44.21)
  BOTTOM w0.114: v2(108.47,44.21) 108.56,44.21 108.86,44.51 110.71,44.51 112.76,42.46 112.76,41.49 112.65,41.38 112.47,41.38 112.22,41.12 C275.1
USB31_6_RX_N: length 155.6
  TOP w0.076: U28.G14 112.4,34.6 112.64,34.6 113.11,34.13 113.11,33.81 113.49,33.43 v1(113.49,33.35)
  TOP w0.114: v2(133.53,169.22) 133.25,169.5 133.25,169.6 133.56,169.91 L23.2
  L8_IN3 w0.102: v2(133.53,169.22) 133.5,169.19 133.5,167.63 130.36,164.49 123.21,164.49 122.81,164.09 122.81,155.83 119.1,152.12 119.1,141.8 114.96,137.66 114.96,133.23 114.2,132.46 114.2,131.07 114.3,130.97 114.3,124.84 114.02,124.56 114.02,104.68 113.59,104.26 113.59,90.73 115.33,89 115.33,80.96 114.34,79.97 114.34,79.62 115.72,78.24 115.72,70.65 114.86,69.79 114.86,65.18 116.28,63.76 116.28,43.19 114.86,41.77 114.86,35.71 114.5,35.35 114.5,33.99 114.12,33.61 113.74,33.61 v1(113.49,33.35)
USB31_6_RX_P: length 155.6
  TOP w0.076: U28.F14 112.29,34.8 112.65,34.8 113.4,34.05 v1(113.47,34.05)
  TOP w0.114: L23.3 132.76,169.91 133.01,169.66 133.01,169.48 v2(132.74,169.22)
  L8_IN3 w0.102: v2(132.74,169.22) 132.74,169.17 133.08,168.82 133.2,168.82 133.3,168.72 133.3,167.72 130.28,164.7 123.13,164.7 122.6,164.17 122.6,155.92 118.9,152.21 118.9,141.89 114.76,137.75 114.76,133.31 113.99,132.55 113.99,130.98 114.1,130.88 114.1,124.93 113.82,124.65 113.82,104.77 113.39,104.34 113.39,90.65 115.12,88.92 115.12,81.04 114.14,80.06 114.14,79.53 115.52,78.15 115.52,70.74 114.65,69.87 114.65,65.1 116.08,63.68 116.08,43.27 114.66,41.85 114.66,35.8 114.3,35.44 114.3,34.07 114.04,33.81 113.66,33.81 113.47,34 v1(113.47,34.05)
USB31_6_TX_N: length 143.9
  TOP w0.114: C269.1 115.29,40.9 115.29,43.34 114.83,43.79 114.22,43.79 v2(114.12,43.89) ; v2(128.98,169.12) 128.71,169.39 128.71,169.63 128.99,169.91 L29.2
  L8_IN3 w0.102: v2(114.12,43.89) 113.97,43.74 113.65,43.74 113.59,43.8 113.59,45.01 115.06,46.49 115.06,63.25 113.03,65.28 113.03,67.82 113.61,68.41 113.61,70.24 111.48,72.38 111.48,86.28 112.37,87.18 112.37,104.76 112.8,105.19 112.8,125.07 113.08,125.35 113.08,125.65 113.08,129.9 112.98,130 112.98,137.62 117.88,142.52 117.88,152.63 121.49,156.24 121.49,166.29 123.58,168.38 128.2,168.38 128.94,169.12 v2(128.98,169.12)
USB31_6_TX_P: length 143.9
  TOP w0.114: v2(113.99,43.23) 114.22,43.23 114.54,43.55 114.73,43.55 115.05,43.24 115.05,41.34 C262.1 ; L29.3 128.19,169.86 128.47,169.58 128.47,169.37 v2(128.22,169.12)
  L8_IN3 w0.102: v2(113.99,43.23) 113.69,43.54 113.56,43.54 113.38,43.72 113.38,45.1 114.86,46.57 114.86,63.17 112.83,65.2 112.83,67.91 113.41,68.49 113.41,70.16 111.27,72.29 111.27,86.37 112.17,87.27 112.17,104.85 112.6,105.27 112.6,125.15 112.88,125.43 112.88,125.65 112.88,129.81 112.77,129.92 112.77,137.71 117.68,142.61 117.68,152.71 121.28,156.32 121.28,166.38 123.49,168.58 128.12,168.58 128.22,168.68 v2(128.22,169.12)
USB32_OC#: length 283.1
  TOP w0.102: U733.5 v1(106.87,164.46) ; v1(125.81,23.47) 125.58,23.47 125.21,23.11 U28.AL40
  L3_IN1 w0.089: v1(125.81,23.47) 126.82,23.47 128.95,25.61 131.56,25.61 133.21,27.26 133.21,47 146.41,60.2 166.73,60.2 170.21,63.68 181.97,63.68 185.25,66.96 185.25,73.68 183.85,75.07 183.85,81.45 184.73,82.32 184.73,96.78 182.62,98.88 182.62,105.99 184.97,108.33 184.97,130.3 180.69,134.57 180.69,138.89 183.39,141.59 186.31,141.59 186.99,142.27 186.99,149.08 187.55,149.63 187.55,153.65 186,155.2 183.01,155.2 182.22,155.98 181.9,155.98 181.75,155.84 179.47,155.84 178.03,157.28 174.83,157.28 174.34,157.76 174.34,159 165.14,168.21 142.08,168.21 141.71,167.84 120.64,167.84 118.58,169.9 117.92,169.9 116.93,170.89 114.88,170.89 113.74,169.75 110.12,169.75 109.34,168.97 109.34,166.3 107.5,164.46 v1(106.87,164.46)
  BOTTOM w0.102: v1(125.81,23.47) 128.24,23.47 R77.2
USB32_RX_N_IN: length 6.6
  TOP w0.114: L67.1 114.39,171.92 114.13,172.19 114.13,172.46 114.18,172.51 D60.1 114.55,172.97 114.55,173.73 113.47,174.81 113.47,175.26 114.19,175.97 114.19,176.27 114.46,176.55 CN32.5
USB32_RX_P_IN: length 6.6
  TOP w0.114: L67.4 113.59,171.89 113.89,172.19 113.89,172.43 113.81,172.51 D60.2 113.81,172.73 113.23,173.31 113.23,175.36 113.95,176.07 113.95,176.49 113.76,176.67 113.15,176.67 CN32.6
USB32_TX_N_IN: length 6.8
  TOP w0.114: CN32.8 108.27,176.55 108.15,176.44 108.15,176.25 109.05,175.35 109.05,174.86 110.18,173.73 110.18,172.92 D62.1 109.86,171.7 L66.1
USB32_TX_P_IN: length 6.8
  TOP w0.114: CN32.9 107.8,176.55 107.91,176.44 107.91,176.15 108.81,175.25 108.81,174.72 108.53,174.44 108.53,173.56 D62.2 109.49,172.22 109.15,171.88 L66.4
USB33_OC#: length 267.4
  TOP w0.089: U28.AJ44 126.95,24.08 127.08,24.21 v1(127.08,24.41)
  TOP w0.102: v1(120.09,168.95) U31.5
  L3_IN1 w0.089: v1(120.09,168.95) 121,168.04 141.62,168.04 141.99,168.41 170.48,168.41 175.84,163.05 175.84,159.75 179.15,156.45 181.06,156.45 181.9,157.28 185.45,157.28 186.14,156.59 186.53,156.59 187.29,155.83 187.6,155.83 188.37,155.06 188.37,150.44 189.28,149.53 189.28,148.36 189.69,147.96 189.69,135.7 192.11,133.28 192.11,109.69 189.81,107.39 189.81,104.98 190.47,104.33 190.47,102.87 186.89,99.3 186.89,95.25 190.66,91.48 190.66,78.34 189.72,77.4 189.72,66.86 183.1,60.25 183.1,51.54 178.24,46.67 v1(175.6,46.67)
  L6_IN2 w0.089: v1(127.08,24.41) 127.24,24.24 127.55,24.24 130.87,20.93 130.87,20.61 131.32,20.16 132.91,20.16 135.22,22.46 138.19,22.46 140.5,24.78 140.5,25.39 140.98,25.86 141.23,25.86 142.63,27.26 144.66,27.26 153.12,35.72 158.16,35.72 161.02,38.57 170.31,38.57 172.17,40.43 172.17,43.32 175.52,46.67 v1(175.6,46.67)
  BOTTOM w0.102: v1(127.08,24.41) 127.08,24.31 127.18,24.21 R86.2
USB33_RX_N_IN: length 6
  TOP w0.114: CN23.5 134.62,176.55 133.67,175.6 133.67,174.82 133.81,174.68 133.81,173.4 133.42,173.01 133.37,173.01 133.35,172.99 D38.1 133.28,172.92 133.28,172.3 133.56,172.02 L23.1
USB33_RX_P_IN: length 6
  TOP w0.114: CN23.6 133.61,176.55 133.8,176.36 133.8,176.07 133.43,175.7 133.43,175.09 132.66,174.32 132.66,173.27 132.92,173.01 132.95,173.01 D38.2 133.04,172.92 133.04,172.43 132.76,172.15 L23.4
USB33_TX_N_IN: length 6.5
  TOP w0.114: L29.1 128.99,172.15 128.7,172.44 128.7,172.92 D39.1 128.8,173.01 128.85,173.01 129.36,173.52 129.36,174.32 128.76,174.92 128.76,175.62 128.3,176.08 128.3,176.56 128.42,176.69 128.99,176.69 CN23.8
USB33_TX_P_IN: length 6.5
  TOP w0.114: L29.4 128.19,172.13 128.46,172.4 128.46,172.93 D39.2 128.38,173.01 128.21,173.01 127.96,173.26 127.96,174.1 128.52,174.66 128.52,175.52 128.06,175.98 128.06,176.49 127.94,176.61 127.19,176.61 CN23.9
USB_PN1: length 189.3
  TOP w0.076: v1(104.98,34.12) 104.95,34.09 104.95,33.93 105.13,33.76 106.69,33.76 106.8,33.65 U28.J3
  L8_IN3 w0.102: v2(148.28,173.54) 148.21,173.54 147.75,173.99 147.47,173.99 146.73,174.73 142.58,174.73 141.08,173.23 134.75,173.23 134.31,172.8 122.28,172.8 120.23,170.74 111.21,170.74 110.35,169.88 110.35,165.88 111.25,164.97 111.25,159.49 110.62,158.86 110.62,147.78 107.24,144.41 107.24,130.29 106.55,129.61 106.55,109.43 105.07,107.95 105.07,93.26 105,93.19 105,93.08 104.7,92.77 104.7,73.87 104.8,73.77 104.8,70 105.87,68.93 105.87,62.04 106.88,61.02 106.88,46.79 106.12,46.02 106.12,44.94 103.45,42.26 103.45,41.24 103.09,40.88 103.09,40.88 102.34,40.12 102.34,36.92 103.11,36.15 104.25,36.15 104.75,35.65 104.75,34.82 104.63,34.7 104.63,34.46 104.98,34.12 v1(104.98,34.12)
  BOTTOM w0.114: L34.3 149.75,174.04 149.4,173.69 148.54,173.69 148.39,173.54 v2(148.28,173.54)
