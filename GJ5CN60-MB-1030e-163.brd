# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_BQ24781S: length 22.5
  TOP w0.203: v1(62.31,43.13) 62.5,42.94 U97.22 ; v1(68.27,42.88) 68.02,42.88 67.68,42.54 U97.13
  TOP w0.381: v1(61.8,43.39) 61.92,43.51 C3580.1 ; R3309.2 71.2,41.23 v1(71.07,41.1) 70.94,41.23 C3565.1 ; C3537.1 70.81,39.2 v1(71.07,39.45) ; C3557.1 v1(71.07,40.08) ; C3576.1 v1(61.04,43.39) ; R3328.2 60.15,43.31 v1(60.2,43.26) C3579.2 PJP28.1
  TOP w0.508: v1(65.75,35.42) 65.73,35.4 65.73,35.31 64.95,34.52 C3535.1 ; v1(60.53,36.91) 60.53,35.26 61.29,34.5 C3536.2 ; C3572.1 v1(59.24,41.61) ; v1(58.24,45.55) 59.51,46.82 C3559.1 ; C3560.1 v1(67.46,45.72)
  vias: v1(64.21,42.62) v1(64.21,41.74) v1(64.21,40.85) v1(65.1,42.62) v1(65.1,41.74) v1(65.1,40.85) v1(65.99,42.62) v1(65.99,41.74) v1(65.99,40.85)
VCC_+1.0VA: length 3
  TOP w0.254: U17.21 90.44,43 C83.2 92.02,43.69 R924.1
VCC_+3.3VA: length 2.5
  TOP w0.305: U12.21 180.05,16.21 179.58,16.69 179.58,16.69 C82.2 R881.1
VCC_DRV_NVD: length 4.1
  BOTTOM w0.254: C257.1 19.52,148.1 U32.6
  BOTTOM w0.508: R278.1 18.38,149.01 R280.1 19,147.78 19.33,148.11 C257.1
VCC_VCCIO: length 4.5
  TOP w0.254: R941.1 104.77,160.91 104.49,160.63 102.87,160.63 102.61,160.38 C86.2 102.44,160.1 101.67,159.33 U18.21
VCCDPHY_1P24: length 2.2
  TOP w0.254: U28.AK23 116.77,23.27 v2(116.4,22.9) 116.37,22.9 U28.AK22 ; U28.AJ23 116.78,24.04 v2(116.4,23.66) 116.02,24.04 U28.AJ22
VCCDSW_PCH: length 3.9
  TOP w0.254: U28.BG45 U28.BG46
  TOP w0.381: U28.BG46 128.01,14.85 128.35,14.52 C285.2
VCCGT_SENSE: length 44.9
  TOP w0.203: v1(141.93,131.09) 141.59,130.75 U26.AH38 ; v1(180.54,140.16) R539.1
  L6_IN2 w0.203: v1(146.38,133.05) 146.51,132.92 164.16,132.92 165.3,134.06 173.43,134.06 179.02,139.65 180.03,139.65 v1(180.54,140.16)
  BOTTOM w0.203: v1(141.93,131.09) 142.52,131.09 142.9,131.47 142.9,132.77 143.31,133.18 143.56,133.18 143.92,133.53 R50.1 143.99,133.53 144.45,133.07 146.35,133.07 v1(146.38,133.05)
VCCIO_ON: length 304
  L3_IN1 w0.089: v1(182.81,41.65) 182.79,41.67 182.79,48.07 184.35,49.63 184.35,58.98 191.04,65.66 191.04,76.55 191.72,77.24 191.72,92.46 190.38,93.81 190.38,97.82 192.46,99.91 192.46,102.93 193.12,103.59 193.12,133.7 190.7,136.12 190.7,147.27 191.34,147.91 191.34,150.2 192.15,151.01 192.15,154.33 187.27,159.21 187.27,160.35 186.15,161.48 180.05,161.48 177.68,163.85 175.9,163.85 170.68,169.07 145.17,169.07 144.47,169.77 140.88,169.77 139.36,168.25 123.49,168.25 121.64,170.1 118,170.1 117.01,171.09 114.79,171.09 113.66,169.95 110.04,169.95 109.14,169.05 109.14,166.38 107.93,165.18 101.8,165.18 v1(101.17,164.54) ; v1(145.62,22.43) 145.11,22.94 145.11,23.35 140.31,28.15 140.31,34.16 139.04,35.43 v1(139.04,49.23)
  BOTTOM w0.102: v1(101.17,164.54) 100.76,164.14 100.76,163.43 R3820.1 ; U5.84 145.74,22.31 v1(145.62,22.43) ; v1(139.04,49.23) 141.68,49.23 142.19,48.72 159.65,48.72 163.06,45.31 171.72,45.31 175.37,41.65 v1(182.81,41.65)
VCCIO_ON_R: length 4.6
  TOP w0.254: R3494.2 v1(101.17,163.91)
  BOTTOM w0.254: v1(101.17,163.91) 101.04,163.78 101.04,162.82 R3821.2 100.23,161 100.48,160.75 U24.4
VCCIO_SENSE: length 76.2
  TOP w0.102: v1(125.93,112.73) 126.27,113.06 U26.H14
  TOP w0.254: v1(98.4,163.93) R3369.2 97.18,163.27 R3366.2 C3669.1
  L3_IN1 w0.254: v1(116.15,133.3) 116.15,133.94 113.25,136.84 113.25,148.43 110.52,151.16 110.52,158.24 107.77,160.99 105.23,160.99 104.6,161.62 103.96,161.62 103.45,161.12 103.07,161.12 102.56,161.62 100.71,161.62 v1(98.4,163.93)
  L6_IN2 w0.254: v1(116.15,133.3) 118.82,133.3 122.25,129.87 122.25,128.6 123.14,127.71 124.41,127.71 126.95,125.17 126.95,123.52 127.2,123.27 127.84,123.27 128.35,122.76 128.35,120.48 127.84,119.97 126.95,119.97 126.57,119.59 126.57,113.36 v1(125.93,112.73)
  BOTTOM w0.254: R54.1 116.28,133.43 v1(116.15,133.3)
VCCMPHY_SENSE: length 81.4
  TOP w0.076: U28.K47 128.76,33.13 129.67,34.04
  TOP w0.203: 129.67,34.04 131.77,34.04 132.16,34.42 132.38,34.42 R370.2 133.6,35.59 134.26,34.93 135.67,34.93 136.3,34.3 136.3,34.29 v1(136.47,34.12) ; R3395.1 86.23,50.37 86.23,50.43 v1(86.34,50.54)
  L3_IN1 w0.203: v1(134.82,45.8) 134.7,45.67 134.7,36.66 136.47,34.88 v1(136.47,34.12)
  BOTTOM w0.203: v1(134.82,45.8) 134.82,46.07 130.25,50.64 130.25,51.55 126.3,55.5 102.73,55.5 102.37,55.15 101.45,55.15 101.33,55.27 99.32,55.27 97.81,56.77 90.55,56.77 86.57,52.79 86.57,50.77 v1(86.34,50.54)
VCCSA_SENSE: length 71.5
  TOP w0.203: v1(183.85,139.67) 183.87,139.67 184.1,139.91 R536.1 ; v1(125.12,133.94) R55.1 126.16,133.48 126.16,132.72 126.57,132.31 128.35,132.31 128.99,131.66 U26.M38
  L6_IN2 w0.203: v1(183.85,139.67) 183.94,139.76 183.94,140.05 183.64,140.35 183.02,140.35 181.05,138.38 179.63,138.38 173.98,132.73 165.8,132.73 164.8,131.73 150.34,131.73 149.92,131.31 145.5,131.31 144.33,132.48 127.01,132.48 125.55,133.94 v1(125.12,133.94)
VCCST_PG_EN: length 3.3
  TOP w0.381: Q2.2 183.84,135.72 183.59,135.97 182.57,135.97 182.18,135.57 U23.4
VCCST_PWRGD: length 70.8
  TOP w0.203: v1(178.89,131.65) 180.8,133.56 183.59,133.56 184.49,134.46 Q2.3 185.49,135.01 R33.1
  L3_IN1 w0.203: v1(132.13,112.19) 133.07,113.13 150.62,113.13 151.03,112.73 162.13,112.73 162.64,113.24 170.76,113.24 173.18,115.65 173.18,126.57 178.26,131.65 v1(178.89,131.65)
  BOTTOM w0.102: R20.1 131.47,111.53 v1(132.13,112.19)
VCCST_PWRGD_R: length 5.4
  TOP w0.102: v1(125.87,111.94) 125.89,111.94 U26.H13
  BOTTOM w0.102: v1(125.87,111.94) 125.9,111.97 127.71,111.97 127.96,111.71 129.62,111.71 129.82,111.51 R20.2
VCCST_PWRON_R: length 3
  BOTTOM w0.102: U105.3 112.11,125.36 C3623.1 111.73,124.67 R3372.2
VDD33_MPS: length 4.2
  TOP w0.203: U3.44 183.88,150.26 183.72,150.42 183.72,151.13 C216.1 183.97,151.39 184.4,151.39 185.42,152.4 R560.2
VIN: length 68.4
  TOP w0.203: v1(62.05,36.78) 62.05,35.69 62.33,35.41 C3536.1 62.69,35.44 C3532.1 R3298.2
  TOP w0.254: R345.1 10.74,58.5 v1(10.62,58.37) ; R344.2 37.92,53.8 v1(37.29,53.8)
  TOP w0.381: R297.2 183.13,157.38 v1(183.72,156.8) ; R218.2 v1(187.98,156.85)
  TOP w0.508: 91.77,158.32 88.85,158.32 87.97,159.2 82.19,159.2 81.92,158.93 81.04,158.93 80.78,159.2 B7.1 ; R199.2 v1(188.04,164.04) ; v1(46.56,63.96) 46.63,63.96 R899.1 ; v1(178.43,155.96) R558.1
  L8_IN3 w0.203: v1(37.29,53.8) 37.41,53.67 37.41,49.98 40.83,46.56 62.69,46.56 63.32,45.93 63.32,37.54 62.56,36.78 v1(62.05,36.78)
  BOTTOM w0.254: v1(10.62,58.37) 10.74,58.5 10.74,58.96 R1091.2
  vias: v1(12.78,61.8) v1(13.41,61.8) v1(145.24,171.22) v1(145.87,171.2) v1(146.58,171.22) v1(147.22,171.22) v1(147.85,171.2) v1(148.54,171.17) v1(181.63,4.65) v1(181.61,4.09) v1(181.63,3.51) v1(182.19,4.65) v1(182.19,4.07) v1(182.19,3.51) v1(182.83,4.65) v1(182.83,4.07) v1(182.83,3.51) v1(190.47,114.91) v1(190.47,114.28) v1(190.47,113.64) v1(190.47,113.01) v1(190.47,112.37) v1(190.47,111.81) v1(191.16,114.94) v1(191.16,114.3) v1(191.16,113.67) v1(191.16,113.03) v1(191.16,112.4) v1(191.16,111.76) v5(3.71,41.53) v5(3.76,45.27) v5(3.76,44.35) v5(3.76,43.41) v5(3.76,42.45) v5(4.75,45.27) v5(4.75,44.35) v5(4.72,43.39) v5(4.72,42.47) v5(4.7,41.53) v5(5.79,45.29) v5(5.79,44.28) v5(5.79,43.26) v5(5.79,42.24) v5(5.79,41.23) v5(6.81,62.18) v5(6.81,61.17) v5(6.81,60.15) v5(6.81,59.13) v5(6.81,45.29) v5(6.81,44.28) v5(6.81,43.26) v5(6.81,42.24) v5(7.82,62.18) v5(7.82,61.17) v5(7.82,60.15) v5(7.82,59.13) v5(12.27,60.15) v5(12.39,59.19) v5(12.39,58.25) v5(12.65,61.04) v5(13.28,60.11) v5(13.66,61.04) v5(40.97,61.17) v5(40.97,60.15) v5(40.97,59.13) v5(41.99,61.17) v5(41.99,60.15) v5(41.99,59.13) v5(43,61.17) v5(43,60.15) v5(43,59.13) v5(81.69,47.7) v5(81.69,46.69) v5(82.63,47.7) v5(82.63,46.69) v5(83.54,47.7) v5(83.54,46.69) v5(92.15,161.14) v5(92.15,160.23) v5(92.15,159.21) v5(123.39,167.26) v5(123.39,166.32) v5(124.41,167.26) v5(124.41,166.32) v5(125.42,167.26) v5(125.42,166.32) v5(126.95,167.26) v5(126.95,166.32) v5(127.96,167.26) v5(127.96,166.32) v5(128.98,167.26) v5(128.98,166.32) v5(134.31,167.26) v5(134.31,166.35) v5(135.33,167.26) v5(135.33,166.32) v5(136.35,167.26) v5(136.35,166.35) v5(142.52,167.36) v5(142.57,166.35) v5(143.53,167.34) v5(143.56,166.37) v5(144.52,167.34) v5(144.52,166.35) v5(145.36,171.96) v5(146.38,171.96) v5(147.4,171.99) v5(148.41,171.96) v5(162.94,161.7) v5(162.91,160.68) v5(163.91,161.65) v5(163.91,160.63) v5(164.87,161.65) v5(164.87,160.61) v5(165.86,161.65) v5(165.86,160.61) v5(178.99,100.87) v5(178.99,99.95) v5(180.01,100.87) v5(180.01,99.95) v5(180.92,100.87) v5(180.92,99.95)
VIN1N_INA: length 5.6
  TOP w0.254: R181.2 3.3,73.99 R252.2 3.81,73.54 4.24,73.1 5.04,73.1 C1247.2 6.13,72.02 U1.11
VIN1P_INA: length 4.3
  TOP w0.254: R177.2 3.17,72.09 R241.2 3.83,72.75 4.27,72.75 4.76,72.26 C1247.1 5.48,71.37 U1.12
VIN2N_INA: length 6.6
  TOP w0.254: R185.2 0.96,66.2 0.96,67.82 R303.2 2.65,68.71 C1258.2 3.17,68.88 U1.14
VIN2P_INA: length 5.9
  TOP w0.254: U1.15 3.47,68.23 C1258.1 2.9,67.85 R283.2 1.8,67.85 1.37,67.41 1.37,66.58 1.37,66.48 1.73,66.12 1.93,66.12 R182.2
VIN3N_INA: length 4.5
  TOP w0.254: R204.2 4.9,63.27 4.9,63.66 R306.2 4.9,64.27 4.9,64.71 C1259.2 5.48,66.08 U1.1
VIN3P_INA: length 4.1
  TOP w0.254: R208.2 5.28,63.27 5.28,63.66 R304.2 5.41,64.14 5.41,64.71 C1259.1 5.81,65.79 6.13,66.12 U1.2
VIN_+1.0VA: length 1.1
  TOP w0.508: R1397.1 84.45,45.09 84.15,44.78
VIN_+2.5VS: length 5
  TOP w0.254: U25.8 185.04,110.52 184.76,110.79 C1236.1 184.51,111.68 183.97,112.22 183.97,113.49 R3822.2
VIN_+3.3VA: length 3
  TOP w0.508: R879.1 178.9,10.8 179.41,10.29
  vias: v1(180.42,10.11) v1(180.42,8.97) v1(181.05,10.11) v1(181.05,8.97)
VIN_+5VA: length 2.6
  TOP w0.508: 186.26,98.62 186.5,98.62 187.15,99.27 R220.1 ; R224.1 187.27,96.07
VIN_+VCCCORE:
  vias: v5(117.6,161.9) v5(117.6,160.94) v5(117.6,159.92) v5(117.93,164.77) v5(118.52,161.88) v5(118.52,160.94) v5(118.52,159.92) v5(118.85,164.8) v5(119.43,159.92) v5(119.46,161.88) v5(119.46,160.94) v5(127.2,161.88) v5(127.23,160.89) v5(127.46,163.53) v5(127.94,160.23) v5(128.09,162.51) v5(128.12,161.45) v5(134.42,162.36) v5(134.42,160.79) v5(134.52,163.83) v5(135.3,163.07) v5(135.33,161.6) v5(135.33,160.15) v5(142.49,162.74) v5(142.47,161.6) v5(142.49,160.51) v5(142.57,163.86) v5(143.51,163.3) v5(143.51,162.16) v5(143.51,161.14)
VIN_+VCCGT:
  vias: v5(145.82,167.48) v5(145.87,166.45) v5(147.27,166.32) v5(148.41,166.32) v5(149.55,166.32) v5(149.86,160.07) v5(149.86,159.06) v5(149.88,158.09) v5(149.94,156.34) v5(150.01,155.04) v5(150.8,167.44) v5(150.82,166.32) v5(150.87,160.07) v5(150.87,159.06) v5(150.9,158.09) v5(151,156.26) v5(150.98,155.04) v5(151.89,160.07) v5(151.89,159.06) v5(151.92,158.09) v5(151.89,154.99) v5(151.89,153.98) v5(152.42,161.04) v5(152.91,160.07) v5(152.91,159.06) v5(152.93,158.09) v5(152.91,154.99) v5(152.91,153.98)
VIN_LCD_CON: length 3.4
  BOTTOM w0.203: v1(71.45,157.81) 71.3,157.96 CNEDP1.30 ; CNEDP1.29 v1(70.8,157.81) ; CNEDP1.28 70.3,157.93 v1(70.18,157.81)
  vias: v4(69.42,157.74)
VIN_LCD_IN0: length 7.7
  TOP w0.508: Q42.S 75.2,164.86 75.59,165.26 R405.1 76.66,165.26 77.16,164.75 C473.1 77.51,163.48 78.87,162.13 78.87,160.7 B7.2
VIN_NV: length 6.5
  TOP w0.254: R345.2 10.74,57.74 11.25,58.25 v1(11.25,58.37) ; R387.2 3.38,57.61 3.63,57.86 4.9,57.86 5.54,58.5 5.54,58.63 5.66,58.75 R1085.2
  BOTTOM w0.254: R1083.2 11.14,58.85 11.14,58.49 v1(11.25,58.37)
  vias: v5(1.85,57.61) v5(1.85,56.59) v5(1.85,55.58) v5(4.77,116.79) v5(4.77,115.78) v5(5.28,56.59) v5(5.28,55.58) v5(5.28,54.56) v5(5.92,116.79) v5(5.92,115.78) v5(6.25,57.2) v5(7.44,55.45) v5(7.44,54.44) v5(9.09,116.67) v5(9.09,115.65) v5(10.11,116.67) v5(10.11,115.65) v5(16.08,91.14) v5(16.08,90.12) v5(17.09,91.14) v5(17.09,90.12) v5(18.11,91.14) v5(18.11,90.12)
VIN_VCCIO: length 4.6
  TOP w0.305: U18.9 99.01,159.83 U18.22 101.62,159.83 101.92,160.12 101.92,160.81 102.22,161.12 C3743.2
  vias: v1(94.26,161.06) v1(94.26,160.51) v1(94.26,159.92) v1(94.89,161.06) v1(94.89,160.51) v1(94.89,159.95)
VIN_VCCSA:
  vias: v5(162.76,157.81) v5(162.79,156.75) v5(163.09,153.83) v5(163.83,157.81) v5(163.83,155.78) v5(163.85,156.72) v5(163.85,154.69) v5(164.92,155.37)
VSS_AL37: length 1.3
  TOP w0.089: v1(123.14,22.61) 123.21,22.68 U28.AL37
  BOTTOM w0.102: TP24.1 123.62,23.09 v1(123.14,22.61)
VSSGT_SENSE: length 46.2
  TOP w0.203: U26.AH37 141.65,130.04 v1(141.96,130.36) ; v1(181.18,140.16) 181.43,140.41 R547.1
  L6_IN2 w0.203: v1(146.51,132.41) 146.7,132.6 164.29,132.6 165.43,133.75 173.56,133.75 179.09,139.27 180.3,139.27 181.18,140.15 v1(181.18,140.16)
  BOTTOM w0.203: v1(146.51,132.41) 146.25,132.41 145.9,132.77 144.45,132.77 R51.2 143.97,132.54 143.71,132.79 143.37,132.79 143.2,132.63 143.2,131.35 142.49,130.64 142.24,130.64 v1(141.96,130.36)
VSSIO_SENSE: length 76.3
  TOP w0.102: v1(126.78,112.57) 126.78,112.97 U26.J14
  TOP w0.254: v1(103.33,161.75) 103.83,162.26 R3370.2 ; v1(94.69,163.66) 94.82,163.66 95.25,163.22 R3375.1
  L3_IN1 w0.254: v1(116.28,132.67) 116.66,133.05 116.66,134.19 113.62,137.23 113.62,148.58 111,151.21 111,158.37 108,161.37 105.61,161.37 104.98,162 103.58,162 v1(103.33,161.75)
  L6_IN2 w0.254: v1(103.33,161.75) 96.6,161.75 v1(94.69,163.66) ; v1(116.28,132.67) 117.68,132.67 121.61,128.73 121.61,127.89 v1(122.63,126.88)
  BOTTOM w0.254: v1(126.78,112.57) 126.85,112.64 126.85,125.17 126.21,125.81 125.68,125.81 125.3,125.43 123.85,125.43 R52.2 123.21,126.11 122.63,126.7 v1(122.63,126.88)
VSSMPHY_SENSE: length 79
  TOP w0.076: U28.K46 127.9,33.04 128.01,32.93 128.93,32.93 129.74,33.73 130,33.73
  TOP w0.203: 130,33.73 131.9,33.73 132.28,34.12 R377.1 133.6,34.17 134.06,34.62 135.34,34.62 135.66,34.3 135.66,34.29 v1(135.84,34.12) ; v1(86.87,50.37) 86.44,49.93 R3402.1
  L3_IN1 w0.203: v1(134.19,45.77) 134.31,45.65 134.31,36.59 135.84,35.06 v1(135.84,34.12)
  BOTTOM w0.203: v1(134.19,45.77) 134.19,46.27 129.95,50.51 129.95,51.43 126.17,55.2 102.85,55.2 102.47,54.81 101.35,54.81 101.2,54.96 99.12,54.96 97.61,56.47 90.88,56.47 86.87,52.46 v1(86.87,50.37)
VSSSA_SENSE: length 72.1
  TOP w0.203: R538.1 184.99,140.16 v1(184.48,139.65) ; U26.M37 129.1,130.04 129.36,130.31 129.36,131.88 128.62,132.62 126.69,132.62 126.47,132.85 126.47,133.81 R56.2 v1(127.18,133.94)
  L6_IN2 w0.203: v1(184.48,139.65) 184.35,139.78 184.35,140.16 183.84,140.67 182.83,140.67 180.92,138.76 179.56,138.76 173.84,133.05 165.67,133.05 164.67,132.05 150.21,132.05 149.79,131.63 145.63,131.63 144.46,132.79 127.15,132.79 126.74,133.21 126.74,133.5 v1(127.18,133.94)
687_GND_+1.2VS: length 12.2
  TOP w0.254: v1(187.04,110.95) 187.04,110.94 U25.4
  TOP w0.381: R134.2 186.33,103.25 v1(186.33,102.59)
  L3_IN1 w0.381: v1(186.33,102.59) 186.84,103.1 186.84,108 187.04,108.21 v1(187.04,110.95)
  BOTTOM w0.381: v1(187.04,110.95) 187.12,110.95 187.5,111.33 PJP34.1 C119.2
+V_DDR_VREFCA_CHB_DIMM: length 10.5
  TOP w0.305: v1(138.4,64.21) CN11.164
  BOTTOM w0.508: v1(138.4,64.21) 138.38,64.23 R41.1 C78.2 R44.1 136.6,64.74 136.09,64.24 134.17,64.24 133.81,64.6 R42.2
A0_INA: length 3.8
  TOP w0.102: R201.1 9.37,67.8 9.16,67.58 U1.5 8.46,67.01 9.09,66.37 R200.1
A_COVER LED_ BL: length 4.8
  TOP w0.102: v1(68.78,160.86) 68.81,160.89 v4(69.44,160.89)
  TOP w0.254: Q27.D 69.42,162 68.78,161.37 v1(68.78,160.86)
  BOTTOM w0.254: v1(68.78,160.86) 69.04,160.86 69.54,160.35 69.54,159.85 69.3,159.6 CNEDP1.26
AC DETECT: length 6.2
  TOP w0.203: Q67.D 70.36,38.13 R3305.2 R3308.1 C3583.2 67.77,38.81 67.56,39.02 66.1,39.02 65.9,39.22 U97.6
AC_REMOVAL: length 243
  TOP w0.102: v1(97.64,60) 97.64,60.12 97.36,60.4 97.36,61.13 97.69,61.46 97.69,61.98 96.85,62.82 96.47,62.82 96.1,63.18 Q4.6 96.1,63.69 95.96,63.83 95.71,63.83 95.45,63.58 Q4.5 ; v1(188.92,140.54) 189.05,140.67 R32.1 189.61,140.34 189.56,140.29 Q3.5 189.56,138.86 189.46,138.76 189.05,138.76 188.91,138.91 Q3.6
  L3_IN1 w0.089: v1(143.46,47.7) 143.84,47.32 143.84,40.8 145.19,39.44 145.19,34.16 151.97,27.38 v1(152.22,27.38)
  L8_IN3 w0.089: v1(186.59,39.98) 186.38,40.19 186.38,42.33 185.17,43.54 183.36,43.54 182.9,44.01 182.9,52.82 183.31,53.23 183.31,62.28 187.7,66.68 187.7,84.36 189.94,86.6 189.94,93.14 188.32,94.76 188.32,99.3 192.91,103.89 192.91,131.85 190.15,134.61 190.15,138.3 188.92,139.53 v1(188.92,140.54)
  BOTTOM w0.102: U5.107 152.82,27.98 v1(152.22,27.38) ; v1(186.59,39.98) 185.9,40.67 176.06,40.67 171.63,45.11 162.95,45.11 160.22,47.83 143.59,47.83 v1(143.46,47.7) 143.18,47.98 137.3,47.98 127.67,57.61 107.51,57.61 106.7,58.42 102.36,58.42 101.2,59.59 98.68,59.59 98.28,59.99 97.64,59.99 v1(97.64,60)
ACZ_BITCLK: length 124.9
  TOP w0.102: R110.1 C260.2 110.06,9.22 v1(110.13,9.15) ; R119.1 32.08,60.28 v1(32.33,60.02)
  L3_IN1 w0.089: v1(32.33,60.02) 32.73,60.02 32.95,59.81 36.15,59.81 38.45,57.51 54.33,57.51 63.77,48.07 77.94,48.07 81.98,44.02 83.26,44.02 83.97,43.31 83.97,30.57 80.86,27.46 80.86,16.62 81.5,15.98 81.5,10.54 83,9.04 109.04,9.04 109.28,8.8 110.04,8.8 110.13,8.89 v1(110.13,9.15)
ACZ_BITCLK_PCH: length 6.5
  TOP w0.076: 111.03,15.57 110.82,15.36 110.82,13.41
  TOP w0.089: U28.BD11 111.03,16.62 111.03,15.57
  TOP w0.102: R110.2 111.23,10.98 111.23,12.73 110.82,13.13 110.82,13.41
ACZ_RST#: length 131.1
  TOP w0.102: R176.1 109.3,9.45 v1(109.55,9.2) ; U7.11 26.77,61.57 27,61.8 28.36,61.8 C137.2 29.02,62.44 29.44,62.03 31.6,62.03 v1(31.95,61.67)
  L3_IN1 w0.089: v1(31.95,61.67) 31.95,61.11 33.04,60.02 36.24,60.02 38.54,57.72 54.42,57.72 61.03,51.11 61.5,51.11 61.51,51.1 77.32,51.1 79.67,48.76 79.67,46.64 82.03,44.28 83.31,44.28 84.19,43.4 84.19,30.42 81.08,27.3 81.08,16.71 81.72,16.07 81.72,10.63 83.09,9.25 109.39,9.25 109.45,9.2 v1(109.55,9.2)
ACZ_RST#_PCH: length 6
  TOP w0.089: 110.05,15.52 110.05,16.09 U28.BE10
  TOP w0.102: R176.2 109.3,14.61 110.05,15.36 110.05,15.52
ACZ_SDATAIN0: length 131.3
  TOP w0.089: U28.BE11 110.79,16.04 110.84,15.99 110.84,15.72 110.44,15.32 110.44,13.41
  TOP w0.102: 110.44,13.41 110.44,12.02 v1(110.77,11.69) ; R117.1 30.05,60.79 32.33,60.79 v1(32.59,61.04)
  L3_IN1 w0.089: v1(32.59,61.04) 32.65,61.04
  L3_IN1 w0.102: 32.65,61.04 33.44,60.24 36.33,60.24 38.63,57.95 54.51,57.95 61.12,51.34 61.59,51.34 61.61,51.32 77.41,51.32 79.89,48.85 79.89,46.73 82.12,44.5 83.4,44.5 84.41,43.49 84.41,30.19 84.23,30.01 84.23,17.38 82.25,15.4 82.25,11.33 83.88,9.69 107.87,9.69 109.1,10.93 110.21,10.93 110.45,11.16 110.45,11.37 v1(110.77,11.69)
ACZ_SDATAOUT: length 136.4
  TOP w0.102: v1(32.59,59.13) 32.21,59.52 31.32,59.52 31.01,59.21 29.92,59.21 C172.2 29.21,59.01 28.57,59.01 28.41,59.17 U7.5 ; R271.1 111.15,9.1 v1(111.12,9.1)
  L3_IN1 w0.089: v1(32.59,59.13) 36.21,59.13 38.27,57.08 54.15,57.08 63.65,47.57 77.75,47.57 81.74,43.59 83.08,43.59 83.54,43.13 83.54,30.8 80.43,27.69 80.43,6.9 81.76,5.57 93.22,5.57 93.8,4.98 98.45,4.98 100.28,6.81 102.18,6.81 103.98,8.61 108.86,8.61 109.1,8.37 110.27,8.37 111,9.1 v1(111.12,9.1)
ACZ_SDOUT_PCH: length 6.4
  TOP w0.102: R284.1 112.65,9.88 R271.2 111.58,10.95 111.58,12.98 111.14,13.43 111.14,15.09 111.29,15.24 U28.BF12
ACZ_SPKR: length 148.9
  TOP w0.089: v2(120.83,18.14) 120.83,18.27 120.14,18.95 U28.AW29
  TOP w0.102: C131.2 33.22,61.37 v1(33.22,61.04)
  L3_IN1 w0.089: v1(33.22,61.04) 33.29,61.04 33.69,60.64 36.25,60.64 38.72,58.17 54.6,58.17 61.21,51.56 64.55,51.56 64.56,51.55 77.51,51.55 80.11,48.94 80.11,46.83 82.21,44.73 83.49,44.73 84.63,43.59 84.63,29.9 84.45,29.72 84.45,17.29 82.47,15.31 82.47,11.51 84.07,9.92 107.77,9.92 109.95,12.09 115.05,12.09 115.48,12.53 120.82,12.53 121.28,12.99 121.28,14.32 121.21,14.39 121.21,14.72 121.36,14.87 121.36,17.61 v2(120.83,18.14)
  BOTTOM w0.102: R136.2 119.65,12.86 120.17,13.37 120.17,14.79 119.71,15.25 119.71,17.5 120.34,18.14 v2(120.83,18.14)
ACZ_SPKR_B1: length 2.3
  TOP w0.102: C131.1 C138.1 R101.2
ACZ_SPKR_B2: length 2.7
  TOP w0.102: C130.2 R97.2 R101.1 28.09,63.33 C139.1
ACZ_SYNC: length 135.8
  TOP w0.102: v1(112.11,11.31) 112.34,11.53 112.34,11.81 R295.1 ; U7.10 26.87,61.17 27,61.29 28.7,61.29 C136.2 29.03,61.55 29.54,61.04 30.81,61.04 v1(31.32,61.55)
  L3_IN1 w0.089: v1(112.11,11.31) 112.11,11.05 110.61,9.54 110.61,9.05 110.14,8.58 109.19,8.58 108.95,8.82 103.2,8.82 101.69,7.32 100.51,7.32 99.01,8.82 82.91,8.82 81.29,10.45 81.29,15.64 80.64,16.28 80.64,27.55 83.76,30.66 83.76,43.22 83.17,43.81 81.83,43.81 77.84,47.79 63.74,47.79 54.24,57.29 38.36,57.29 36.12,59.53 32.26,59.53 31.32,60.47 v1(31.32,61.55)
ACZ_SYNC_PCH: length 2.7
  TOP w0.076: U28.BG13 111.48,13.67 111.73,13.41
  TOP w0.102: 111.73,13.41 112.29,12.86 R295.2
ADAP_IN: length 338
  TOP w0.076: U28.BG42 126.07,14.83 126.07,13.93 126.06,13.93 v1(126.06,13.89)
  TOP w0.102: Q3.2 189.56,136.55 C2.2 189.1,136.1 v1(188.67,136.1) ; Q4.2 95.45,64.85 95.33,64.72 94.56,64.72 94.06,64.21 94.06,63.28 v1(94.1,63.24) ; R3306.2 v1(66.95,38.13)
  TOP w0.203: U97.5 65.5,38.87 R3306.2
  L3_IN1 w0.089: v1(126.06,13.89) 126.46,14.29 127.72,14.29 128.26,13.75 144.05,13.75 144.57,14.27 148.7,14.27 149.43,13.54 152.22,13.54 153.62,14.94 153.62,16.46 157.24,20.09 v1(157.24,22.52) 157.24,22.62 157.05,22.81 155.02,22.81 153.24,24.59 153.24,27.89 151.76,29.37 151.76,33.06 151.33,33.48 151.33,37.54 149.55,39.32 149.55,43.26 149.53,43.28 149.53,45.9 v1(150.11,46.49)
  L6_IN2 w0.089: v1(186.64,39.16) 186.64,38.9 186.27,38.53 186.27,32.05 183.03,28.81 183.03,28.14 182.45,27.56 179.89,27.56 177.55,25.23 173.05,25.23 172.02,24.2 162.34,24.2 161.48,23.34 159.35,23.34 158.53,22.52 v1(157.24,22.52) ; v1(94.1,63.24) 91.94,63.24 91.39,62.69 91.39,61.29 92.02,60.66 92.02,60.02 91.77,59.77 90.75,59.77 87.32,56.34 85.73,56.34 83.51,54.12 83.51,51.9 75.89,44.28 75.89,42.88 74.82,41.8 74.82,41.16 v1(74.24,40.59)
  L8_IN3 w0.089: v1(186.64,39.16) 186.13,39.67 186.13,42.3 185.09,43.34 183.28,43.34 182.69,43.93 182.69,52.9 183.1,53.31 183.1,62.37 187.5,66.76 187.5,76.8 186.36,77.95 186.36,97.72 192.71,104.07 192.71,131.76 189.86,134.61 189.86,135.66 189.43,136.1 v1(188.67,136.1)
  BOTTOM w0.102: v1(150.11,46.49) 149.91,46.69 142.7,46.69 142.21,47.17 135.92,47.17 132.71,50.38 132.71,51.03 127.15,56.59 107.09,56.59 106.28,57.41 99.97,57.41 98.83,58.55 96.29,58.55 95.71,59.13 95.71,59.9 94.82,60.79 93.84,60.79 93.59,61.04 93.59,62.74 v1(94.1,63.24) ; U5.18 161.78,20.31 161.72,20.25 159.52,20.25 v1(157.24,22.52) ; v1(66.95,38.13) 69.42,40.59 v1(74.24,40.59)
AMP_MUTE#: length 223.1
  TOP w0.102: R121.1 30.68,57.03 v1(30.68,58.12)
  L3_IN1 w0.089: v1(156.39,3.66) 150.04,3.66 149.15,4.55 110.72,4.55 110.18,4.02 108.15,4.02 107.64,4.52 107.64,5.03 107.39,5.29 99.41,5.29 98.8,4.68 93.42,4.68 92.91,5.18 81.84,5.18 80.21,6.81 80.21,27.94 82.57,30.3 82.57,38.36 81.23,39.7 81.23,43.76 77.64,47.35 63.56,47.35 54.06,56.86 38.18,56.86 36.12,58.92 34.05,58.92 32.74,57.61 31.19,57.61 v1(30.68,58.12)
  L8_IN3 w0.089: v1(164.03,19.51) 162.76,18.24 162.76,15.32 160.08,12.63 160.08,10.42 157.35,7.69 157.35,4.63 v1(156.39,3.66)
  BOTTOM w0.102: CN12.1 9.77,49.36 9.98,49.15 21,49.15 27.99,56.14 29.97,56.14 v3(30.4,56.57) 30.68,56.85 v1(30.68,58.12) ; U5.20 v1(164.03,19.51)
APU_LCDVDD_EN_G: length 3.5
  TOP w0.254: R986.2 C1347.2 67.44,161.47 66.62,162.28 Q113.2
AUDIO_USB_OC#: length 150.6
  TOP w0.089: U28.AL41 125.61,23.02 v2(126.44,23.02)
  L3_IN1 w0.089: v1(81.72,30.19) 82.37,30.85 82.37,38.27 80.21,40.44 80.21,44.48 77.54,47.15 63.48,47.15 53.97,56.66 38.09,56.66 37.78,56.98 37.67,56.98 36.02,58.63 34.11,58.63 32.46,56.98 30.17,56.98 29.29,57.86 29.29,60.91 27.25,62.94 26.97,62.94 25.8,64.12 18.9,64.12 16.33,61.55 v1(16.33,60.02)
  L6_IN2 w0.089: v1(93.65,27.28) 93.65,26.81 95.27,25.18 95.27,24.1 95.29,24.08 95.29,23.58 95.27,23.56 95.27,22.87 97.62,20.53 98.25,20.53 99.01,19.77 107.75,19.77 110.1,22.13 112.04,22.13 112.37,22.46 116.97,22.46 117.07,22.36 118.08,22.36 118.93,23.21 125.35,23.21 125.55,23.02 v2(126.44,23.02)
  BOTTOM w0.102: v2(126.44,23.02) 126.92,22.53 127.02,22.43 R79.2 ; v1(81.72,30.19) 81.89,30.19 82.91,29.16 91.69,29.16 93.57,27.28 v1(93.65,27.28) ; R3628.2 17.22,59.64 16.84,60.02 v1(16.33,60.02)
AUX_EDP_CH_N: length 2.6
  BOTTOM w0.114: C345.2 63.77,156.75 64.03,157 64.03,157.2 63.45,157.78 63.45,158.19 63.3,158.34 CNEDP1.14
AUX_EDP_CH_P: length 2.6
  BOTTOM w0.114: C346.2 64.5,156.75 64.27,156.98 64.27,157.3 63.69,157.88 63.69,158.18 63.8,158.29 CNEDP1.15
AUX_OFF#: length 1.2
  TOP w0.102: Q51.C 94.56,28.45 R902.1
BAT1C: length 10.8
  TOP w0.203: CN30.U8 CN30.8 39.47,40.64 v4(38.73,39.91) 38.68,39.86 v1(38.68,39.2)
  BOTTOM w0.203: R3314.2 C3552.1 38.07,39.76 D42.1 38.88,39.39 v1(38.68,39.2)
BAT1D: length 10.9
  TOP w0.203: CN30.U7 CN30.7 40.97,40.67 v4(40.13,39.83) 39.5,39.2 v1(39.32,39.2)
  BOTTOM w0.203: v1(39.32,39.2) 39.25,39.26 D42.2 39.68,39.76 C3549.1 R3315.2
BAT+: length 7.7
  TOP w0.305: R186.2 v1(39.7,37.93)
  BOTTOM w0.305: v1(33.22,38.81) 33.22,38.56 33.86,37.93 v1(39.7,37.93)
  vias: v4(34.24,39.3) v5(30.05,42.62) v5(30.1,43.54) v5(31.01,43.51) v5(30.99,42.57)
BAT_I: length 150.2
  TOP w0.102: R3299.2 74.62,40.08 75.39,39.32 75.39,36.66 75.88,36.16 v1(75.88,35.22) ; R348.1 58.32,51.08 56.84,49.61 56.84,39.2 57.73,38.31 v1(57.73,38.18)
  L8_IN3 w0.089: v1(142.44,16.08) 142.19,16.08 140.35,14.24 140.35,8.65 139.08,7.38 137.69,7.38 136.71,6.4 125.13,6.4 124.52,5.79 118.02,5.79 116.78,4.56 109.87,4.56 109.21,3.9 100.62,3.9 99.98,4.53 98.16,4.53 98.09,4.46 87.54,4.46 82.52,9.49 82.52,10.96 81.86,11.62 81.86,12.89 80.66,14.09 80.66,32.66 78.11,35.22 v1(75.88,35.22) 75.78,35.22 75.18,34.62 59.89,34.62 57.73,36.78 v1(57.73,38.18)
  BOTTOM w0.102: U5.70 146.12,16.71 145.97,16.56 144.91,16.56 C347.1 144.68,16.39 144.22,16.84 143.2,16.84 v1(142.44,16.08)
BAT_SMBCLK: length 173.2
  TOP w0.102: Q60.6 129.72,8.1 129.62,8.2 129.62,8.74 v1(129.71,8.84) 131.07,8.84 R145.1
  TOP w0.203: v1(68.27,42.24) 68.17,42.14 U97.12
  L6_IN2 w0.089: v1(129.71,8.84) 130.11,8.44 139.96,8.44 141.38,9.86 145.77,9.86 149.4,13.49 149.4,15.04 150.19,15.83 151.62,15.83 151.97,16.17 151.97,17.33 v1(152.96,18.32)
  L8_IN3 w0.089: v1(129.71,8.84) 129.71,8.8 129.11,8.21 128.31,8.21 128.17,8.35 126.9,8.35 126.28,7.74 124.55,7.74 124.06,7.25 117.31,7.25 116.63,7.92 113.47,7.92 113.27,7.72 104.82,7.72 103.07,5.97 97.93,5.97 97.12,6.79 95.99,6.79 95.62,6.42 87.62,6.42 84.6,9.44 84.6,12.27 82.74,14.14 82.74,15.87 84.13,17.27 84.13,31.63 78.81,36.95 76.49,36.95 75.26,38.18 75.26,41.35 v1(75.77,41.86)
  BOTTOM w0.102: U5.110 154.02,21.3 152.96,20.25 v1(152.96,18.32) ; v1(75.77,41.86) 75.51,41.86 75.26,42.12 68.4,42.12 v1(68.27,42.24) 68.1,42.24 67.77,41.91 67.77,41.18 66.04,39.45 59.51,39.45 55.7,43.26 39.06,43.26 37.79,41.99 R3314.1
BAT_SMBDAT: length 171
  TOP w0.102: Q60.3 128.58,6.8 128.85,7.06 v1(128.85,8.63) 128.85,9.03 128.53,9.35 R144.1
  TOP w0.203: v1(68.27,41.61) 68.15,41.74 U97.11
  L6_IN2 w0.089: v1(128.85,8.63) 129.25,8.23 140.04,8.23 141.46,9.66 145.86,9.66 149.6,13.4 149.6,14.95 150.21,15.56 151.64,15.56 152.17,16.08 152.17,17.17 152.86,17.86 v1(153.62,17.86)
  L8_IN3 w0.089: v1(128.85,8.63) 128.75,8.73 124.3,8.73 123.91,8.34 119.91,8.34 119.02,7.45 117.4,7.45 116.73,8.12 113.39,8.12 113.19,7.92 103.87,7.92 102.13,6.18 98.02,6.18 97.2,6.99 95.9,6.99 95.53,6.63 87.7,6.63 84.8,9.53 84.8,12.37 82.94,14.24 82.94,15.78 84.33,17.18 84.33,31.71 78.89,37.15 76.92,37.15 75.96,38.12 75.96,40.91 v1(75.77,41.1)
  BOTTOM w0.102: U5.111 154.31,28.56 154.31,20.97 153.62,20.27 v1(153.62,17.86) ; R3315.1 39.95,42.12 40.46,42.62 55.83,42.62 59.51,38.94 66.24,38.94 68.27,40.97 v1(68.27,41.61) 68.53,41.86 75.01,41.86 v1(75.77,41.1)
BAT_V: length 163.8
  TOP w0.203: v1(32.46,38.81) 32.46,38.53 33.77,37.22 R194.2 R187.1 C232.1 36.25,36.98 36.98,36.98 37.14,37.15 Q119.6
  L8_IN3 w0.203: v1(32.46,38.81) 32.43,38.84 32.43,39.93 35.2,42.7 48.46,42.7 49.94,41.23 55.83,41.23 58.37,38.69 58.37,36.52 59.97,34.92 71.41,34.92 72.57,36.08 77.94,36.08 81.13,32.89 81.13,14.28 82.33,13.08 82.33,11.81 82.98,11.16 82.98,9.77 87.79,4.96 96.8,4.96 96.94,5.1 104.04,5.1 104.54,4.6 105.38,4.6 106.12,5.34 112.97,5.34 114.01,6.38 124.45,6.38 124.94,6.87 136.52,6.87 137.5,7.85 138.89,7.85 139.88,8.84 139.88,16.19 140.79,17.1 143.2,17.1 144.06,17.95 v1(146.14,17.95)
  BOTTOM w0.203: v1(146.14,17.95) 146.18,17.91 U5.73
BAT_V_ON#: length 7.7
  TOP w0.102: 37.79,35.83 37.79,35.36 37.9,35.26 38.3,35.26 38.44,35.4 Q119.3 38.44,36.1 38.67,36.33 R186.1 R3316.1 43.78,36.33 Q155.G
BATLOW#: length 4.1
  TOP w0.076: U28.BF44 126.95,15.45 127.2,15.19 127.2,14.79 127.68,14.31 127.68,13.41
  TOP w0.102: 127.68,13.41 127.68,13.06 127.58,12.97 R111.1
BATPRESS: length 73.9
  TOP w0.102: v1(77.24,32.46) 76.5,33.19 76.5,35.99 75.59,36.91 75.59,40.13 74.95,40.76 74.95,42.55 72.64,44.86 69.9,44.86 69.47,44.43 R3310.1 ; Q12.D 31.06,37.54 v1(30.81,37.8)
  TOP w0.203: R3310.1 R3334.2 69.06,43.39 68.17,44.28 66.5,44.28 66.3,44.07 U97.15
  L8_IN3 w0.102: v1(30.81,37.8) 31.57,37.04 43.21,37.04 44.51,38.33 53.49,38.33 58.83,32.99 76.71,32.99 v1(77.24,32.46)
BATT-: length 7.6
  BOTTOM w0.508: 52.02,47.32 52.86,48.16 R317.1
  vias: v4(51.87,39.58) v5(51.26,45.65) v5(51.26,44.66) v5(52.27,45.6) v5(52.27,44.58)
BATT_DUMP(ROM_PWR): length 11.5
  TOP w0.203: CN30.U6 CN30.6 v4(42.47,40.06) 41.86,39.45 v1(41.86,39.2) 41.73,39.07 Q155.D
  BOTTOM w0.203: v1(41.86,39.2) 41.92,39.26 D43.1 41.65,40.03 C3553.1
BATT_TEMP: length 140.4
  L8_IN3 w0.089: v1(44.65,41.1) 46.08,41.1 47.41,39.77 54.41,39.77 59.76,34.42 75.27,34.42 75.67,34.82 76.31,34.82 76.51,35.02 77.96,35.02 80.46,32.52 80.46,14 81.66,12.8 81.66,10.06 87.46,4.26 98.55,4.26 98.62,4.33 99.9,4.33 100.53,3.69 109.29,3.69 109.95,4.35 117.72,4.35 118.95,5.59 124.61,5.59 125.22,6.2 136.8,6.2 137.78,7.18 139.17,7.18 140.55,8.56 140.55,11.08 144.73,15.26 144.73,15.95 v1(145.74,16.97)
  BOTTOM w0.102: v1(145.74,16.97) 145.88,17.11 U5.71 ; R3324.1 43.81,41.94 v1(44.65,41.1)
BATT_TEMP_R: length 11.9
  TOP w0.203: v1(42.49,39.22) 42.82,39.22 v4(43.97,40.36) 43.97,40.64 43.97,40.65 CN30.5 CN30.U5
  BOTTOM w0.203: C3550.1 42.57,40.03 D43.2 42.3,39.39 42.47,39.22 v1(42.49,39.22) ; C3550.1 R3313.2 ; C3550.1 R3324.2
BATT_VA_OFF#: length 160.6
  TOP w0.102: v1(55.7,63.33) 55.7,63.96 54.56,65.1 54.56,66.37 53.21,67.72 R896.2 53.21,68.7 52.87,69.04 Q88.2
  L8_IN3 w0.089: v1(55.7,63.33) 55.7,53.31 56.5,52.51 70.38,52.51 74.65,48.24 74.65,37.81 76.12,36.34 78.56,36.34 83.52,31.37 83.52,17.52 82.13,16.12 82.13,13.88 82.78,13.23 82.78,11.72 83.24,11.26 83.24,9.94 87.37,5.81 95.69,5.81 96.15,5.36 104.14,5.36 104.63,4.88 105.29,4.88 106.01,5.6 112.86,5.6 113.9,6.64 124.34,6.64 124.83,7.13 136.41,7.13 137.39,8.11 138.78,8.11 139.62,8.95 139.62,16.44 142.19,19 144.88,19 v1(145.15,19.27)
  BOTTOM w0.102: v1(145.15,19.27) 145.15,19.8 145.65,20.31 U5.79
BL_ON: length 26.5
  TOP w0.102: v1(69.04,160.18) 69.16,160.05 v4(69.16,159.46)
  L8_IN3 w0.102: v1(83.72,156.77) 83.06,157.43 78.05,157.43 75.46,154.84 69.57,154.84 68.66,155.76 68.66,156.82 68.88,157.05 68.88,160.03 v1(69.04,160.18)
  BOTTOM w0.102: CNEDP1.25 68.8,159.74 69.04,159.97 v1(69.04,160.18) ; v1(83.72,156.77) 83.72,156.72 83.26,156.26 83.26,154.99 83.02,154.75 U29.4
BOARD ID: length 310.3
  TOP w0.102: v1(76.4,166.2) 76.66,166.45 Q57.G
  L3_IN1 w0.089: v1(76.4,166.2) 76.85,165.74 94.56,165.74 95.06,166.25 101.32,166.25 103.68,168.61 103.68,173.05 104.51,173.88 105.72,173.88 106.91,172.7 111.8,172.7 112.24,173.14 114.74,173.14 115.69,174.09 121.75,174.09 122.58,173.26 142.52,173.26 144.6,175.34 156.52,175.34 162.38,169.48 170.85,169.48 174.41,165.92 182.18,165.92 182.92,165.18 183.59,165.18 188.02,160.75 188.02,159.43 189.53,157.91 191.47,157.91 193.47,155.91 193.47,138.42 193.32,138.28 193.32,137.34 194.54,136.12 194.54,102.44 193.9,101.8 193.9,93.35 193.15,92.6 193.15,76.65 192.46,75.96 192.46,64.61 185.77,57.92 185.77,46.54 187.38,44.93 187.38,43.79 v1(187.82,43.35)
  L6_IN2 w0.089: v1(161.11,17.48) 161.11,18.11 163.02,20.02 164.16,20.02 165.14,19.03 169.08,19.03 169.33,18.78 175.94,18.78 177.45,20.29 177.45,23.4 179.34,25.28 183.27,25.28 188.99,31 188.99,42.11 188.14,42.96 188.14,43.03 v1(187.82,43.35)
  BOTTOM w0.102: v1(161.11,17.48) 160.98,17.35 160.98,17.1 160.62,16.73 160.62,14.41 160.82,14.22 U5.34 160.82,12.36 160.48,12.02 160.48,11.59 R174.1 R246.2
BOOT_GCORE1: length 3.1
  BOTTOM w0.203: 22,72.03 22,71.44 21.8,71.24 U721.1
  BOTTOM w0.508: 22,72.03 22,72.8 22.55,73.36 R925.2
BST1_NVD: length 2
  TOP w0.254: R232.1 15.82,117.55 16.33,117.05 U722.1
BST2_NVD: length 2.5
  TOP w0.305: U722.18 21.79,117.05 22.17,117.43
  TOP w0.508: R239.1 22.68,117.94 22.17,117.43
BST3_NVD: length 2.2
  BOTTOM w0.254: R242.1 25.15,148.6 U32.2
BST_1.2VS: length 4.3
  TOP w0.254: U25.10 184.72,108.27 184.48,108.03 184.48,106.61 183.97,106.1 183.97,104.92 R842.2
BST_+1.0VA: length 1.5
  TOP w0.254: U17.20 90,42.5 90.07,42.57 R3361.2
BST_+3.3VA: length 1.5
  TOP w0.305: R66.2 180.54,16.59 180.54,16.22 180.55,16.21 U12.20
BST_+5VA: length 2.2
  TOP w0.254: R223.2 193.01,94.06 192.35,94.06 192.1,93.81 U9.20
BST_VCCIO: length 1.2
  TOP w0.254: R3379.2 102.11,159.13 101.81,158.83 U18.20
BT_ON: length 85.5
  TOP w0.102: v1(141.55,22.94) 141.4,22.79 141.4,12.02 v1(145.24,8.18) ; v1(93.2,10.98) CNWLAN1.54 93.2,8.19 R3247.2 92.48,7.47 v4(91.64,7.47)
  L6_IN2 w0.089: v1(93.2,10.98) 93.2,10.84 93.46,10.58 95.76,10.58 98.09,12.91 113.43,12.91 116.9,9.45 120.38,9.45 121.54,8.28 121.54,7.31 122.25,6.61 140.58,6.61 140.77,6.42 143.2,6.42 144.96,8.18 v1(145.24,8.18)
  BOTTOM w0.102: v1(141.55,22.94) 141.81,22.94 141.96,22.79 144.45,22.79 144.68,23.02 R103.2 R105.1 144.98,24.08 145.36,23.7 146.38,23.7 146.57,23.51 U5.87
BTL_BEEP: length 198.8
  TOP w0.102: v1(33.86,61.04) 33.86,61.62 C138.2 ; v1(83.51,12.02) 82.24,12.02 80.97,10.75 v1(79.58,10.75)
  L3_IN1 w0.089: v1(33.86,61.04) 36.14,61.04 38.81,58.37 54.69,58.37 61.3,51.76 77.58,51.76 80.31,49.03 80.31,46.91 82.19,45.04 83.47,45.04 84.83,43.67 84.83,29.79 84.66,29.61 84.66,17.21 82.68,15.23 82.68,12.86 v1(83.51,12.02)
  L8_IN3 w0.089: v1(79.58,10.75) 79.58,7.19 80.59,6.18 80.59,4.39 83.23,1.75 92.13,1.75 92.81,1.07 117.6,1.07 119.88,3.36 146.86,3.36 149.05,5.54 149.05,6.94 149.81,7.7 153.87,7.7 157.3,11.13 157.3,13.46 160.01,16.16 v1(161.02,16.16)
  BOTTOM w0.102: U5.28 162.15,16.31 161.86,16.59 161.45,16.59 v1(161.02,16.16)
C COVER LIGHT: length 184
  L3_IN1 w0.089: v1(143.84,49.61) 144.6,48.85 144.6,41.48 147.78,38.31 147.78,33.33 v1(148.67,32.44)
  L8_IN3 w0.102: v1(92.79,156.75) 93.72,157.69 100.66,157.69 106.02,152.33 106.02,130.8 105.33,130.11 105.33,109.96 105.15,109.78 103.85,108.48 103.85,100.82 100.68,97.66 100.68,90.4 97.59,87.31 97.59,83.26 98.37,82.48 98.37,80.6 101.17,77.8 101.17,70.76 103.83,68.09 103.83,65.18 102.82,64.16 102.82,61.04 103.07,60.79 103.33,60.79 v1(103.96,60.15)
  BOTTOM w0.102: v1(143.84,49.61) 143.81,49.63 136.96,49.63 135.44,51.16 128.17,58.42 107.85,58.42 106.05,60.22 104.03,60.22 v1(103.96,60.15) ; v1(148.67,32.44) 148.77,32.34 U5.97 ; v1(92.79,156.75) 92.79,156.34 R3692.2
CAP+: length 1.9
  TOP w0.203: U7.36 20.1,57.57 19.63,57.1 19.62,57.1 C179.1
CAP-: length 1.7
  TOP w0.203: C179.2 19.21,57.31 19.87,57.97 U7.35
CATERR#: length 9.3
  TOP w0.076: 167.03,127.74 165.99,126.7 164.31,126.7 162.65,125.03 160.24,125.03 159.79,125.48 U26.BM30
  TOP w0.102: R26.1 167.03,127.74
CFG0: length 7.4
  TOP w0.076: U26.BN25 160.4,121.54 160.73,121.87 164.41,121.87 164.54,122 R9.2
CFG2: length 7.7
  TOP w0.076: U26.BN26 160.34,122.26 160.56,122.05 163.78,122.05 164.62,122.89 R11.2
CFG4: length 6.8
  TOP w0.076: R22.2 164.27,115.52 162.49,117.3 161.87,117.3 161.64,117.53 U26.BR20
CFG5: length 8.5
  TOP w0.076: R12.2 164.67,118.19 164.03,117.55 163.25,117.55 162.74,118.06 160.1,118.06 159.69,117.66 U26.BM20
CFG6: length 5.7
  TOP w0.076: R14.2 163.61,116.41 162.42,117.6 U26.BT20
CFG7: length 6.9
  TOP w0.076: R19.2 163.27,117.3 162.69,117.88 161.19,117.88 160.99,117.69 U26.BP20
CFG8: length 4.8
  TOP w0.102: TP41.1 165.05,120.35 164.26,119.56 162.05,119.56 U26.BR23
CFG9: length 4.6
  TOP w0.102: U26.BR22 162.06,118.76 165.62,118.76 TP42.1
CFG10: length 5.7
  TOP w0.102: U26.BT23 164.03,119.96 164.92,120.86 166.95,120.86 TP44.1
CFG11: length 5.5
  TOP w0.102: U26.BT22 164.64,119.18 165.05,119.59 166.95,119.59 TP43.1
CFG12: length 6.9
  TOP w0.076: TP46.1 163.02,114.63 163.02,115.78 162.48,116.31 161.97,116.31 161.87,116.41 160.1,116.41 U26.BM19
CFG13: length 7.3
  TOP w0.076: U26.BR19 161.85,116.81 162.15,116.51 162.51,116.51 163.18,115.84 163.18,114.7 164.27,113.62 164.57,113.62 164.92,113.27 164.92,112.98 TP45.1
CFG14: length 8.3
  TOP w0.076: TP47.1 166.06,114 164.35,114 163.51,114.84 163.51,116.04 162.43,117.12 161.44,117.12 161.13,116.81 U26.BP19
CFG15: length 5.3
  TOP w0.076: TP48.1 164.88,113.78 164.33,113.78 163.35,114.77 163.35,115.91 162.44,116.81 U26.BT19
CFG16: length 3.5
  TOP w0.102: TP52.1 131.65,24.34 129.63,24.34 128.93,23.64 U28.AK48
CHG_G_LED: length 427.7
  TOP w0.102: R3723.1 176.02,154.56 v1(177.11,155.65) ; CN9.3 163.4,7.7 v4(163.4,7.7) 163.4,7.95 v1(163.78,8.33)
  L6_IN2 w0.089: v1(161.67,17.91) 162.22,17.35 163.62,17.35 166.15,14.83 166.15,11.52 167.72,9.95 167.72,9.48 167.21,8.97 164.41,8.97 v1(163.78,8.33) 163.4,7.95 163.4,7.04 165.99,4.45 178.21,4.45 179.41,5.65 179.41,19.09 190.67,30.36 190.67,41.01 189.15,42.53 188.93,42.53 188.29,43.17 v1(188.29,43.95)
  L8_IN3 w0.089: v1(9.9,69.95) 10.22,70.27 11.24,70.27 12.72,68.79 16.46,68.79 16.77,68.48 18.11,68.48 18.41,68.17 25.55,68.17 27.52,66.2 28.51,66.2 29.78,64.94 30.09,64.94 30.09,64.94 31.28,64.94 32.04,64.19 34.15,64.19 34.91,64.94 47.06,64.94 47.87,64.14 52.54,64.14 52.74,64.33 56.8,64.33 57.33,63.81 57.33,61.6 60.55,58.38 68.68,58.38 70.53,56.53 70.53,54.25 75.68,49.09 83.25,49.09 84.94,47.4 84.94,16.75 85.34,16.35 85.34,14.64 85.21,14.51 85.21,9.69 87.87,7.03 95.36,7.03 95.73,7.4 97.37,7.4 98.16,6.61 101.98,6.61 103.7,8.33 112.83,8.33 113.44,8.94 118.7,8.94 119.57,9.81 124.07,9.81 124.44,9.44 129.96,9.44 129.99,9.41 134.12,9.41 134.31,9.6 136.4,9.6 136.6,9.41 137.81,9.41 138,9.22 v1(138.12,9.22) ; v1(188.29,43.95) 188.29,45.06 187.91,45.44 187.91,47.7 186.24,49.37 186.24,60.12 190.58,64.46 190.58,72.62 193.75,75.8 193.75,93.01 194.52,93.78 194.52,98.54 195.12,99.14 195.12,134.72 193.62,136.22 193.62,144.1 192.99,144.73 192.99,150.96 187.91,156.04 183.59,156.04 181.94,157.69 179.15,157.69 v1(177.11,155.65)
  BOTTOM w0.102: v1(138.12,9.22) 141.4,12.5 146.61,12.5 148.41,14.3 152.86,14.3 154.51,15.95 157.3,15.95 159.25,17.91 v1(161.67,17.91) U5.24 ; CN12.42 9.81,69.86 v1(9.9,69.95)
CHG_LX: length 23.5
  TOP w0.203: U97.27 62.28,40.94 62.11,40.77 61.29,40.77 C3541.2
  TOP w0.508: C3541.2 v1(61.64,40.06)
  L6_IN2 w0.508: v1(47.95,53.17) 47.95,52.53 54.43,46.05 54.43,44.02 58.39,40.06 v1(61.64,40.06)
CHG_REF: length 149.8
  TOP w0.102: v1(56.84,52.91) 56.79,52.86 52.45,52.86 51.94,53.37 C353.1 R326.2
  L8_IN3 w0.089: v1(56.84,52.91) 70.27,52.91 74.7,48.48 74.85,48.33 74.85,37.89 76.21,36.54 78.64,36.54 83.73,31.46 83.73,17.43 82.33,16.04 82.33,13.97 82.99,13.31 82.99,11.81 83.44,11.35 83.44,10.02 87.45,6.02 95.78,6.02 96.23,5.57 104.37,5.57 104.72,5.21 105.13,5.21 105.72,5.8 112.68,5.8 112.95,6.07 112.95,6.82 113.64,7.52 116.46,7.52 117.14,6.84 124.26,6.84 124.75,7.33 126.45,7.33 127.07,7.95 128,7.95 128.61,7.33 136.33,7.33 137.31,8.31 138.7,8.31 139.42,9.03 139.42,17.63 141.68,19.89 143.92,19.89 v1(144.09,19.71)
  BOTTOM w0.102: U5.81 145.49,21.11 v1(144.09,19.71)
CHGR_LED: length 25.2
  TOP w0.102: C14.1 Q190.D ; C14.1 170.76,159.13 v1(170.76,159.72) ; C14.1 R10.1
  BOTTOM w0.102: v1(170.76,159.72) 166.06,164.42 161.49,164.42 157.3,168.61 157.3,170.51 157.73,170.94 LED2.C
CLEAR CMOS: length 29.3
  TOP w0.102: Q16.2 Q16.5 169.1,23.73 C3384.1 v1(168.22,23.19)
  L6_IN2 w0.089: v1(168.22,23.19) 167.42,23.99 162.93,23.99 161.47,22.54 158.84,22.54 158.33,22.03 157.17,22.03 156.48,22.72 153.9,22.72 153.49,22.3 v1(153.36,22.3)
  BOTTOM w0.102: U5.99 149.62,27.9 149.17,27.46 149.17,26.11 149.42,25.86 149.42,25.54 152.66,22.3 v1(153.36,22.3)
CLK_CPU_24MHZ_DN: length 105.4
  TOP w0.076: 106.96,41.1 106.96,41.08 107.01,41.04 107.01,38.94 107.39,38.56 107.94,38.56 108.46,38.04 108.46,36.82 108.46,36.73 U28.C6
  TOP w0.089: U26.D31 123.62,126.54 v1(123.27,126.88)
  TOP w0.114: v2(108.41,42.07) 108.08,41.74 107.3,41.74 106.96,41.4 106.96,41.1
  L3_IN1 w0.102: v2(108.41,42.07) 108.41,41.94 108.71,41.63 108.99,41.63 109.14,41.79 109.14,41.85 111.84,44.54 111.84,57.82 109.37,60.28 109.37,81.74 108.58,82.53 108.58,89.32 110.04,90.77 110.04,104.89 116.97,111.82 116.97,120.94 117.85,121.83 117.85,125.03 118.76,125.94 119.14,125.94 119.24,126.04 119.54,126.04 119.64,125.94 119.95,125.94 120.04,126.04 120.35,126.04 120.45,125.94 120.75,125.94 120.85,126.04 121.16,126.04 121.26,125.94 122.88,125.94 123.49,126.55 123.49,126.72 123.33,126.88 v1(123.27,126.88)
CLK_CPU_24MHZ_DP: length 105.4
  TOP w0.076: 107.21,41.1 107.21,41.09 107.16,41.05 107.16,39 107.45,38.71 108,38.71 108.61,38.1 108.61,36.96 108.74,36.83 108.74,36.34 U28.D7 ; v1(123.97,126.87) 123.97,126.79 U26.E31
  TOP w0.114: 107.21,41.1 107.21,41.3 107.4,41.49 108.14,41.49 v2(108.41,41.23)
  L3_IN1 w0.102: v2(108.41,41.23) 108.61,41.43 109.07,41.43 109.34,41.7 109.34,41.76 112.04,44.46 112.04,57.9 109.57,60.37 109.57,81.83 108.79,82.62 108.79,89.23 110.24,90.69 110.24,104.81 117.17,111.74 117.17,120.86 118.06,121.75 118.06,124.94 118.85,125.73 122.97,125.73 123.77,126.54 123.77,126.67 v1(123.97,126.87)
CLK_CPU_BCLK_DN: length 109.2
  TOP w0.076: 108.95,41.1 108.43,40.58 108.43,38.88 108.87,38.43 108.87,37.03 109.06,36.85 U28.C8 ; 120.44,126.94 120.89,126.94 120.9,126.95 120.93,126.95 121.21,127.23 121.63,127.23 121.72,127.14 121.72,126.99 U26.A32
  TOP w0.114: 120.43,126.94 v2(120.19,126.7) ; 108.95,41.1 108.99,41.14 108.99,41.33 109.25,41.58 109.88,41.58 v2(109.93,41.63)
  L3_IN1 w0.102: v2(109.93,41.63) 110.24,41.63 110.49,41.38 110.71,41.38 110.87,41.54 110.87,42.29 112.52,43.95 112.52,58.1 110.06,60.57 110.06,82.03 109.27,82.82 109.27,89.03 110.72,90.49 110.72,104.61 117.65,111.54 117.65,120.19 119.48,122.02 119.48,122.79 120.22,123.52 122.22,123.52 124.46,125.77 124.46,127.29 124.26,127.49 122.34,127.49 122.31,127.49 121.95,127.13 121.24,127.13 121.23,127.13 121.23,127.12 120.94,126.83 120.32,126.83 v2(120.19,126.7)
CLK_CPU_BCLK_DP: length 109.3
  TOP w0.076: v2(120.73,127.33) 120.78,127.38 121.69,127.38 121.96,127.12 121.96,127.06 121.96,126.85 U26.B31 ; 109.14,40.95 109.12,40.93 109,40.93 108.79,40.72 108.58,40.52 108.58,40.23 108.66,40.16 108.66,39.93 108.58,39.85 108.58,39.62 108.66,39.55 108.66,39.32 108.58,39.24 108.58,38.94 109.03,38.5 109.03,38.27 109.1,38.19 109.1,37.96 109.03,37.89 109.03,37.24 U28.B8
  TOP w0.114: 109.14,40.95 109.23,41.04 109.23,41.23 109.35,41.34 109.49,41.34 109.73,41.1 110.06,41.1 v2(110.25,40.91)
  L3_IN1 w0.102: v2(110.25,40.91) 110.52,41.18 110.79,41.18 111.07,41.46 111.07,42.21 112.72,43.86 112.72,44.97 112.82,45.07 112.82,45.38 112.72,45.48 112.72,45.78 112.82,45.88 112.82,46.18 112.72,46.28 112.72,46.59 112.82,46.69 112.82,46.99 112.72,47.09 112.72,58.19 110.26,60.65 110.26,82.11 109.47,82.9 109.47,88.95 110.93,90.4 110.93,104.53 117.85,111.46 117.85,120.11 119.68,121.94 119.68,122.7 120.3,123.32 122.3,123.32 124.66,125.68 124.66,127.38 124.35,127.69 123.95,127.69 123.85,127.79 123.55,127.79 123.45,127.69 123.14,127.69 123.04,127.79 122.74,127.79 122.64,127.69 122.34,127.69 122.23,127.69 121.87,127.33 v2(120.73,127.33)
CLK_CPU_PCIBCLK_DN: length 107.1
  TOP w0.076: v2(105.99,40.21) 106.37,40.21 106.48,40.11 106.48,38.46 106.88,38.05 107.68,38.05 107.92,37.81 107.92,37.41 U28.B6
  TOP w0.089: v1(122.99,128.67) 123.12,128.67 123.23,128.78 123.23,129.03 U26.C36
  L3_IN1 w0.102: v2(105.99,40.21) 106.09,40.31 106.7,40.31 107.01,40.62 107.01,41.74 111.35,46.08 111.35,57.62 108.89,60.08 108.89,81.54 108.1,82.33 108.1,89.52 109.55,90.97 109.55,105.1 116.48,112.02 116.48,121.31 117.3,122.13 117.3,125.94 117.88,126.52 117.88,126.87 118.77,127.77 120.01,127.77 120.12,127.87 121.51,127.87 122.9,129.25 123.17,129.25 123.29,129.13 123.29,128.97 v1(122.99,128.67)
CLK_CPU_PCIBCLK_DP: length 107.1
  TOP w0.076: U28.A6 108.07,37.76 108.07,37.88 107.75,38.2 106.95,38.2 106.63,38.52 106.63,40.21 v2(105.99,40.85)
  TOP w0.089: U26.D35 123.46,128.79 123.46,129.02 123.62,129.18 v1(123.82,129.18)
  L3_IN1 w0.102: v2(105.99,40.85) 106.09,40.85 106.42,40.52 106.62,40.52 106.81,40.7 106.81,41.82 111.15,46.16 111.15,57.53 108.69,60 108.69,81.46 107.9,82.25 107.9,89.6 109.35,91.06 109.35,105.18 116.28,112.11 116.28,121.4 117.09,122.21 117.09,126.02 117.68,126.61 117.68,126.96 118.69,127.97 119.93,127.97 120.03,128.07 121.43,128.07 122.82,129.46 123.25,129.46 123.52,129.18 v1(123.82,129.18)
CLK_EC_LPC: length 48.1
  L6_IN2 w0.089: v1(123.69,13.54) 123.69,13 124.57,12.12 127.81,12.12 129.03,13.34 132.59,13.34 133.72,12.2 143.69,12.2 147.19,15.7 147.19,16.64 151.75,21.2 154.04,21.2 154.25,21.42 159.21,21.42 159.46,21.67 v1(159.71,21.67)
  BOTTOM w0.102: U5.13 160.35,22.31 v1(159.71,21.67) ; R323.2 123.94,15.15 123.94,14.41 123.9,14.37 123.9,13.75 v1(123.69,13.54)
CLK_LAN_REQ: length 84.1
  TOP w0.089: U28.BB30 120.28,17.33 v1(120.83,17.33)
  TOP w0.102: R312.2 90.45,50.19 90.12,49.86 88.59,49.86 v1(88.21,49.48)
  TOP w0.203: U1901.12 91.89,51.84 91.84,51.9 90.78,51.9 90.45,51.57 R1907.2 R312.2
  L3_IN1 w0.089: v1(120.83,17.33) 120.32,17.33 118.9,15.91 114.3,15.91 113.09,14.7 113.09,14.14 112.44,13.48 109.37,13.48 109.23,13.35 109.23,13.35 109.09,13.21 109.07,13.21 v1(107.64,11.79)
  L6_IN2 w0.089: v1(107.64,11.79) 107.36,11.51 107.01,11.51 105.5,10 96.32,10 96.06,9.75 90.73,9.75 90.18,10.3 90.18,11.71 90.09,11.79 89.25,11.79 87.62,13.43 87.62,14.82 87.16,15.28 87.16,21.36 85.11,23.41 85.11,46.38 v1(88.21,49.48)
CLK_PCIE_GFX_DN: length 96
  TOP w0.076: v2(108.96,23.25) 109.2,23.25 109.63,23.68 U28.AH9
  TOP w0.114: v1(103.38,97.26) 103.22,97.11 102.91,97.11 101.48,98.54 97.23,98.54 96.96,98.81 96.27,98.81 96.15,98.93 G1.BM27
  L8_IN3 w0.102: v1(103.38,97.26) 102.34,97.26 101.5,96.42 101.5,89.6 99.06,87.16 99.06,81.18 102.23,78.01 102.23,74.32 103.38,73.18 103.38,69.41 104.44,68.34 104.44,61.45 105.46,60.43 105.46,47.38 104.7,46.61 104.7,45.53 102.02,42.85 102.02,41.83 100.91,40.71 100.91,33.19 101.68,32.43 101.68,29.92 103.25,28.35 103.25,25.9 104.64,24.51 108.32,24.51 109.14,23.69 109.14,23.42 108.97,23.25 v2(108.96,23.25)
CLK_PCIE_GFX_DP: length 96
  TOP w0.076: v2(109.9,23.32) 109.8,23.42 109.8,23.79 U28.AH10
  TOP w0.114: v1(103.2,96.6) 103.2,96.73 103.06,96.87 102.81,96.87 101.38,98.3 97.13,98.3 96.86,98.57 96.38,98.57 96.15,98.33 G1.BM26
  L8_IN3 w0.102: v1(103.2,96.6) 103.2,96.75 102.89,97.06 102.42,97.06 101.7,96.34 101.7,89.51 99.26,87.07 99.26,81.27 102.44,78.09 102.44,74.41 103.58,73.26 103.58,69.49 104.65,68.43 104.65,61.53 105.66,60.52 105.66,47.29 104.9,46.53 104.9,45.44 102.23,42.77 102.23,41.74 101.12,40.63 101.12,33.28 101.88,32.51 101.88,30.01 103.45,28.43 103.45,25.99 104.72,24.72 108.41,24.72 109.35,23.78 109.35,23.58 109.61,23.32 v2(109.9,23.32)
CLK_PCIE_LAN_DN: length 40.5
  TOP w0.114: v2(91.39,49.25) 91.39,49.36 91.65,49.62 91.65,49.8 92.09,50.24 U1901.16 ; v2(108.66,26.37) 108.66,26.27 U28.AE6
  L6_IN2 w0.102: v2(91.39,49.25) 91.39,49.31 91.69,49.61 92.17,49.61 92.93,48.85 97.87,48.85 99.89,46.82 104.51,46.82 106.81,44.53 106.81,38.23 105.71,37.14 105.71,33.25 106.63,32.33 106.63,29.11 107.12,28.62 107.12,28.48 107.34,28.26 107.48,28.26 107.95,27.79 107.95,27.65 108.16,27.44 108.3,27.44 108.52,27.22 108.94,27.22 109.04,27.12 109.04,26.83 108.66,26.45 v2(108.66,26.37)
CLK_PCIE_LAN_DP: length 40.5
  TOP w0.114: v2(109.3,26.37) 109.3,26.24 108.94,25.88 U28.AE7 ; v1(91.26,49.86) 91.35,49.86 91.64,50.16 91.64,50.37 91.91,50.64 U1901.15
  L6_IN2 w0.102: v1(91.26,49.86) 92.28,49.86 93.04,49.1 97.97,49.1 100,47.07 104.62,47.07 107.06,44.63 107.06,38.12 105.97,37.03 105.97,33.35 106.88,32.44 106.88,29.22 108.62,27.48 109.04,27.48 109.3,27.22 v2(109.3,26.37)
CLK_PCIE_WLAN_DN: length 23.2
  TOP w0.076: U28.AB2 106.48,27.56 106.55,27.64 106.55,27.77 106.45,27.87 106.18,27.87 105.88,27.56 105.88,27.12 105.95,27.05 v2(105.97,27.05)
  TOP w0.102: CNWLAN1.49 91.95,17.94 91.81,18.07 91.81,18.08 91.81,20.16 v1(92.07,20.42)
  BOTTOM w0.102: v2(105.97,27.05) 105.45,27.05 105.3,26.9 104.62,26.9 102.12,24.4 102.12,24.4 102.06,24.34 94.54,24.34 91.64,21.44 91.64,20.82 92.03,20.42 v1(92.07,20.42)
CLK_PCIE_WLAN_DP: length 23.2
  TOP w0.076: U28.AB3 106.7,27.72 106.7,27.83 106.51,28.02 106.12,28.02 105.74,27.64 v2(105.49,27.64)
  TOP w0.102: v1(91.35,20.42) 91.59,20.19 91.59,18.07 91.45,17.94 CNWLAN1.47
  BOTTOM w0.102: v2(105.49,27.64) 105.49,27.41 105.21,27.13 104.53,27.13 101.96,24.56 94.45,24.56 91.41,21.53 91.41,20.49 v1(91.35,20.42)
CLK_TPM: length 66.3
  L3_IN1 w0.089: v1(122.38,15.32) 122.61,15.08 122.61,12.67 124.16,11.12 153.88,11.12 154.38,10.62 157.17,10.62 159.56,8.23 v1(159.89,8.23)
  BOTTOM w0.102: CNDEG1.6 176.33,3.23 175.72,2.62 173.18,2.62 171.27,4.52 171.27,7.83 168.73,10.37 164.24,10.37 162.1,8.23 v3(160.98,8.23) v1(159.89,8.23) ; R334.2 121.87,15.98 122.38,15.47 v1(122.38,15.32)
CLKIN_XTAL: length 48.6
  TOP w0.089: v2(108.25,31.37) U28.R6
  TOP w0.102: v3(95.55,11.26) 95.7,11.11 CNWLAN1.64 95.7,8.33 94.99,7.62 R443.2
  L6_IN2 w0.089: v3(95.55,11.26) 95.81,11.26 97.87,13.32 113.4,13.32 v1(113.71,13.63)
  L8_IN3 w0.089: v2(108.25,31.37) 108.51,31.12 108.51,30.86 109.57,29.8 109.87,29.8 110.11,29.56 110.11,24.03 111.09,23.05 112.13,23.05 113.12,22.06 114.03,22.06 115.65,20.45 115.65,20.24 117.04,18.84 117.04,18.32 115.26,16.54 115.26,14.2 114.68,13.62 113.73,13.62 v1(113.71,13.63)
CLKREQ_MD2_SSD1: length 34.7
  TOP w0.076: v1(125.81,26.24) 125.4,25.84 U28.AE41
  TOP w0.102: CNSSD1.52 152.07,31.42 153.02,32.38 v1(153.02,32.68)
  L8_IN3 w0.089: v1(131.27,26.37) 132.66,26.37 135.33,29.04 137.67,29.04 141.69,33.05 149.34,33.05 149.68,32.72 152.98,32.72 v1(153.02,32.68)
  BOTTOM w0.102: v1(125.81,26.24) 127.58,26.24 128.47,27.13 v3(128.95,27.13) 130.5,27.13 v1(131.27,26.37) 131.44,26.37 R350.2
CLKREQ_MD2_SSD2: length 67.3
  TOP w0.089: v1(120.09,21.49) 120.09,21.49 120.14,21.54 120.48,21.54 U28.AR32
  TOP w0.102: CNSSD2.52 175.07,32.98 v3(174.57,33.48)
  L8_IN3 w0.089: v1(120.09,21.49) 120.22,21.49 120.61,21.88 120.61,22.95 120.75,23.09 120.75,25.12 122.36,26.73 128.91,26.73 129.13,26.96 131.75,26.96 134.04,29.24 136.5,29.24 138.38,31.12 139.47,31.12 141.63,33.28 151.33,33.28 151.64,32.97 152.75,32.97 154.02,34.24 162.76,34.24 163.91,33.1 169.87,33.1 170.26,33.48 v3(174.57,33.48)
  BOTTOM w0.102: R341.2 120.72,20.86 v1(120.09,21.49)
