# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_BRI_DT: length 32.4
  TOP w0.076: 103.96,19.76 104.85,19.76 105.13,19.49 106.69,19.49 106.77,19.4 107.16,19.4 U28.AV4
  TOP w0.102: v4(87.71,6.86) 87.71,7.29 88.7,8.29 CNWLAN1.36 88.7,10.21 88.34,10.57 88.34,11.26 88.87,11.79 90.32,11.79 v1(91.41,12.88) ; R368.2 102.56,19.26 102.94,18.88 v1(102.95,18.88) 103.17,19.1 103.17,19.48 103.45,19.76 103.96,19.76
  L8_IN3 w0.089: v1(102.95,18.88) 103.55,18.28 103.55,16.49 100.63,13.57 98.15,13.57 97,12.43 91.86,12.43 v1(91.41,12.88)
CNV_BRI_RSP: length 27.6
  TOP w0.076: v1(104.98,18.77) 105.03,18.72 106.02,18.72 106.16,18.58 U28.AY2
  TOP w0.102: v1(88.73,13.07) 86.44,10.77 85.83,10.77 85.2,10.15 CNWLAN1.22
  L8_IN3 w0.089: v1(104.98,18.77) 104.98,16.99 100.91,12.92 98.42,12.92 97.27,11.78 90.12,11.78 88.84,13.07 v1(88.73,13.07)
CNV_RF_RESET#: length 39.8
  TOP w0.076: 112.95,13.41 112.8,13.41 112.6,13.62 112.6,15.07 112.99,15.45 U28.BE16
  TOP w0.102: v1(112.77,11.26) 112.93,11.41 112.93,12.5 113.28,12.86 R442.2 113.36,13.01 112.95,13.41 ; v3(82.12,10.8) 82.12,10.63 82.2,10.55 CNWLAN1.10
  L3_IN1 w0.089: v1(112.77,11.26) 112.77,11.61 112.57,11.81 111.78,11.81 110.67,10.7 109.19,10.7 107.96,9.47 83.44,9.47 v3(82.12,10.8)
CNV_RGI_DT: length 29.3
  TOP w0.076: v1(104.16,18.75) 104.55,18.37 106.12,18.37 106.25,18.24 107.01,18.24 107.25,18 U28.BA4
  TOP w0.102: CNWLAN1.32 87.7,10.52 v3(87.45,10.77) 87.45,11.01 89.48,13.04 v1(89.48,13.07)
  L8_IN3 w0.089: v1(89.48,13.07) 89.48,13.06 90.54,12 97.18,12 98.33,13.14 100.82,13.14 104.16,16.48 v1(104.16,18.75)
  BOTTOM w0.102: v3(87.45,10.77) 87.88,10.34 R362.2 R356.2
CNV_RGI_RSP: length 27.2
  TOP w0.076: v1(104.6,20.27) 105.1,19.76 106.65,19.76 106.8,19.61 U28.AV3
  TOP w0.102: v1(90.47,13.07) 89.42,12.02 88.78,12.02 88.11,11.35 88.11,10.42 88.2,10.33 CNWLAN1.34
  L8_IN3 w0.089: v1(90.47,13.07) 91.33,12.21 97.09,12.21 98.24,13.36 100.72,13.36 103.76,16.4 103.76,19.44 v1(104.6,20.27)
CNV_WR_CLKN: length 28.6
  TOP w0.076: U28.BD4 107.41,16.72 v2(107.47,16.72)
  TOP w0.114: CNWLAN1.21 84.95,13.58 85.34,13.19 86.05,13.19 v2(86.13,13.11)
  BOTTOM w0.114: v2(107.47,16.72) 107.21,16.46 107.21,16.02 106.28,15.09 102.74,15.09 102.12,14.47 100.33,14.47 100.31,14.49 100.31,14.49 100.1,14.7 95.38,14.7 94.64,13.95 87.98,13.95 87.13,13.11 v2(86.13,13.11)
CNV_WR_CLKP: length 28.7
  TOP w0.076: v2(106.55,16.59) 106.69,16.45 U28.BE3
  TOP w0.114: v2(86.16,13.95) 86.16,13.87 85.71,13.43 85.44,13.43 85.19,13.68 85.19,15.85 85.45,16.11 CNWLAN1.23
  BOTTOM w0.114: v2(106.55,16.59) 106.84,16.59 106.96,16.48 106.96,16.11 106.18,15.33 102.84,15.33 102.64,15.33 102.02,14.71 100.43,14.71 100.41,14.73 100.41,14.73 100.2,14.94 95.28,14.94 94.54,14.2 87.88,14.2 87.03,13.35 86.62,13.35 86.16,13.81 v2(86.16,13.95)
CNV_WR_D0N: length 27.6
  TOP w0.076: 103.96,16.14 104.06,16.14 104.11,16.18 104.63,16.18 105.63,17.18 106.11,17.18 U28.BB3
  TOP w0.114: 103.96,16.14 103.07,16.14 102.94,16.01 102.6,16.01 102.48,16.14 102.13,16.14 102.01,16.01 101.67,16.01 101.54,16.14 101.2,16.14 101.04,15.98 v2(101.04,15.8) ; CNWLAN1.15 83.45,16.15 83.68,15.91 83.68,15.21 v2(83.44,14.96)
  BOTTOM w0.114: v2(101.04,15.8) 100.86,15.98 99.92,15.98 99.38,15.43 95.08,15.43 94.33,14.69 87.24,14.69 87.09,14.84 86.05,14.84 85.24,14.04 84.03,14.04 83.77,14.29 83.77,14.65 83.47,14.96 v2(83.44,14.96)
CNV_WR_D0P: length 27.6
  TOP w0.076: 103.96,16.38 103.97,16.38 104.02,16.34 104.57,16.34 105.56,17.33 106.53,17.33 U28.BB4
  TOP w0.114: CNWLAN1.17 83.95,16.06 83.92,16.03 83.92,15.42 v2(84.38,14.96) ; 103.96,16.38 101.34,16.38 101.04,16.68 v2(101.04,16.69)
  BOTTOM w0.114: v2(101.04,16.69) 101.04,16.61 100.65,16.22 99.82,16.22 99.28,15.67 94.98,15.67 94.23,14.93 87.34,14.93 87.19,15.08 85.95,15.08 85.14,14.28 84.13,14.28 84.02,14.39 84.02,14.75 84.23,14.96 v2(84.38,14.96)
CNV_WR_D1N: length 29.9
  TOP w0.076: 104.57,16.97 104.72,16.97 105.34,17.59 106.51,17.59 106.56,17.64 U28.BA3
  TOP w0.114: v2(81.69,19) 81.79,19 82.03,18.77 82.03,18.02 81.95,17.94 CNWLAN1.9 ; v2(102.31,16.97) 104.57,16.97
  BOTTOM w0.114: v2(102.31,16.97) 102.12,16.97 101.85,17.24 100.07,17.24 99.01,16.17 94.77,16.17 94.71,16.11 90.21,16.11 89.41,16.91 82.92,16.91 82.09,17.73 82.09,18.73 81.82,19 v2(81.69,19)
CNV_WR_D1P: length 29.9
  TOP w0.076: U28.BA2 106.23,17.9 106.15,17.99 106.02,17.99 105.97,17.93 105.97,17.83 105.87,17.74 105.28,17.74 104.75,17.21 104.57,17.21
  TOP w0.114: v2(102.31,17.73) 102.31,17.71 102.81,17.21 103.15,17.21 103.27,17.34 103.62,17.34 103.74,17.21 104.57,17.21 ; CNWLAN1.11 82.45,17.94 82.27,18.12 82.27,18.62 v2(82.65,19)
  BOTTOM w0.114: v2(82.65,19) 82.33,18.68 82.33,17.83 83.02,17.15 83.36,17.15 83.48,17.27 83.83,17.27 83.95,17.15 84.29,17.15 84.42,17.27 84.76,17.27 84.89,17.15 85.23,17.15 85.35,17.27 85.7,17.27 85.82,17.15 86.16,17.15 86.29,17.27 86.63,17.27 86.76,17.15 87.1,17.15 87.22,17.27 87.57,17.27 87.69,17.15 89.51,17.15 90.31,16.35 94.61,16.35 94.67,16.41 98.91,16.41 99.97,17.48 101.85,17.48 102.11,17.73 v2(102.31,17.73)
CNV_WT_CLKN: length 16.7
  TOP w0.076: U28.BC5 107.47,17.11 v2(107.24,17.35)
  TOP w0.114: v2(97.23,19.28) 97.58,18.93 97.58,18.07 97.45,17.94 CNWLAN1.71
  BOTTOM w0.114: v2(97.23,19.28) 97.5,19.02 97.5,18.15 97.97,17.68 98.96,17.68 99.34,18.06 99.34,18.82 99.73,19.22 100.35,19.22 100.62,19.48 105.5,19.48 107.24,17.75 v2(107.24,17.35)
CNV_WT_CLKP: length 16.7
  TOP w0.076: U28.BB6 108.46,17.66 108.29,17.49 108.09,17.49 107.89,17.69 v2(107.85,17.69)
  TOP w0.114: v2(98.17,19.28) 97.82,18.93 97.82,18.07 97.95,17.94 CNWLAN1.73
  BOTTOM w0.114: v2(98.17,19.28) 97.74,18.85 97.74,18.25 98.07,17.92 98.86,17.92 99.1,18.16 99.1,18.92 99.63,19.46 100.25,19.46 100.52,19.73 105.6,19.73 107.64,17.69 v2(107.85,17.69)
CNV_WT_D0N: length 21.6
  TOP w0.076: 108.17,13.58 108.18,13.6 108.25,13.6 108.81,14.16 108.81,15.25 108.73,15.33 108.73,15.71 108.7,15.74 108.7,15.99 108.62,16.07 108.52,16.07 U28.BE6
  TOP w0.114: v2(105.73,12.1) 106.18,12.55 106.18,12.93 106.53,13.28 107.87,13.28 108.17,13.58 ; CNWLAN1.65 95.95,16.11 96.08,15.98 96.08,14.41 v2(95.77,14.11)
  BOTTOM w0.114: v2(105.73,12.1) 106.11,12.47 106.11,12.6 105.97,12.74 105.16,12.74 104.22,13.67 97.9,13.67 97.41,13.19 96.41,13.19 96.05,13.54 96.05,13.83 v2(95.77,14.11)
CNV_WT_D0P: length 21.6
  TOP w0.076: U28.BD7 108.64,16.28 108.85,16.06 108.85,15.89 108.88,15.86 108.88,15.39 108.96,15.31 108.96,14.1 108.34,13.48 108.34,13.41
  TOP w0.114: CNWLAN1.67 96.45,16.11 96.32,15.98 96.32,14.37 v2(96.6,14.1) ; v2(106.5,12.1) 106.42,12.17 106.42,12.83 106.63,13.04 107.97,13.04 108.34,13.41
  BOTTOM w0.114: v2(96.6,14.1) 96.55,14.1 96.29,13.85 96.29,13.64 96.51,13.43 97.31,13.43 97.8,13.92 104.32,13.92 105.26,12.98 106.07,12.98 106.35,12.7 106.35,12.24 v2(106.5,12.1)
CNV_WT_D1N: length 22.9
  TOP w0.076: U28.BG6 108.24,15.15 108.35,15.15 108.43,15.06 108.43,14.58 107.9,14.05 105.52,14.05 104.98,13.52 104.98,13.41
  TOP w0.114: 104.98,13.41 104.59,13.02 104.59,12.58 v2(104.07,12.06) ; CNWLAN1.59 94.45,16.11 94.57,16 94.57,13.31 v2(94.27,13.01)
  BOTTOM w0.114: v2(94.27,13.01) 94.36,13.01 94.56,12.81 94.56,12.14 94.84,11.85 97.34,11.85 98.42,12.94 103.92,12.94 104.34,12.51 104.34,12.33 v2(104.07,12.06)
CNV_WT_D1P: length 22.9
  TOP w0.076: U28.BF6 108.58,15.13 108.58,14.52 107.96,13.9 105.59,13.9 105.22,13.53 105.22,13.41
  TOP w0.114: CNWLAN1.61 94.95,16.11 94.81,15.97 94.81,13.3 v2(95.1,13.01) ; v2(104.83,12.06) 104.83,12.92 105.22,13.31 105.22,13.41
  BOTTOM w0.114: v2(104.83,12.06) 104.58,12.31 104.58,12.61 104.02,13.18 98.32,13.18 97.24,12.09 94.94,12.09 94.8,12.24 94.8,12.71 v2(95.1,13.01)
CNV_WT_RCOMP: length 5.3
  TOP w0.076: 103.96,17.88 104.19,17.88 104.34,17.73 104.72,17.73 105.04,18.05 U28.BA1
  TOP w0.102: 103.96,17.88 103,17.88 102.72,18.16 102.72,18.54 102.48,18.77 101.75,18.77 R367.1
CODEC_BITCLK: length 4.7
  TOP w0.102: U7.6 28.88,59.57 C164.2 29.44,60.12 30.17,60.12 30.33,60.28 R119.2
CODEC_DIN: length 2.7
  TOP w0.102: U7.8 28.72,60.37 R117.2
CODEC_EAPD: length 5
  TOP w0.102: U7.47 25.12,56.45 25.68,55.88 28.14,55.88 28.78,56.52 R123.2
CODEC_GND: length 17.6
  TOP w0.203: v1(19.25,61.93) 19.61,61.57 U7.26 ; v1(20.65,56.21) 20.85,56.21 21.12,56.48 U7.37
  TOP w0.381: AR6.2 21.31,65.31 AB4.2 21.13,65 21.33,64.8 v1(21.33,64.52)
  TOP w0.508: v1(19.25,61.93) 19.05,62.13 C161.2 C163.2 ; AB5.2 13.99,56.42 v1(14.05,56.47) 14.12,56.39 C194.2 ; C178.2 17.41,56.4 v1(17.35,56.34) 17.08,56.07 AR25.2 ; C1234.2 16.46,62.58 v1(16.46,63.2) 16.46,63.68 16.97,64.19 C199.1 ; C195.2 14.25,59.08 v1(14.05,58.88) ; C143.1 19.81,54.37 AC3.2 19.81,55.96 v1(19.76,56.01) ; C183.2 17.25,63.05 v1(17.09,63.2)
  BOTTOM w0.305: AB1.2 21.21,56.77 v1(20.65,56.21)
  BOTTOM w0.508: v1(20.62,62.46) 20.8,62.64 AB3.2
CODEC_PCBEEP: length 1.9
  TOP w0.102: U7.12 26.79,61.97 27.3,62.49 C139.2
CORE_PLLVDD_GPU: length 63.7
  TOP w0.102: v6(90.22,95.1) 90.22,95.1 90.54,94.78 G1.BD21
  TOP w0.203: G1.BD15 90.25,90.88 v1(90.25,90.94)
  TOP w0.25: G1.BB24 88.9,97.13 v6(88.8,97.13) ; G1.BD12 v6(90.25,88.78) ; G1.BC12 v6(89.55,88.78)
  TOP w0.3: G1.AF11 77.7,88.03 v6(77.7,88.13) ; G1.U42 71.4,109.23 v6(71.4,109.13)
  TOP w0.508: B34.2 C1445.2 83.95,77.7 83.08,78.57 v1(82.5,78.57)
  L8_IN3 w0.35: 82.5,88.6 82.63,88.73 88.22,88.73 88.34,88.85 ; 82.5,88.6 v1(82.5,78.57) ; 82.5,88.6 82.37,88.73 78.3,88.73 v6(77.7,88.13) 77.05,88.78 73.4,88.78 73.02,89.16 69.95,89.16 68.86,90.25 68.86,94.49 68.57,94.78 68.57,95.27 68.96,95.66 68.96,100.82 68.68,101.1 68.68,102.67 68.86,102.85 68.86,107.69 69.7,108.53 70.8,108.53 v6(71.4,109.13)
  BOTTOM w0.35: v6(77.7,88.13) 78.13,88.56 C1444.2 ; C1432.2 71.07,108.66 71.4,108.99 v6(71.4,109.13)
  BOTTOM w0.381: C1433.2 88.32,96.53 88.8,97 v6(88.8,97.13) 88.51,97.42 C1457.2 ; v1(90.25,90.94) 90.25,90.2 C1446.2 90.17,88.86 v6(90.25,88.78)
CPU_2_PCH_TRIGGER: length 3.8
  TOP w0.076: U28.AK2 106.39,23.7 104.24,23.7 103.96,23.98
  TOP w0.102: R431.2 102.93,23.83 103.19,24.08 103.63,24.08 103.86,24.08 103.96,23.98
CPU_PROCHOT#: length 8.1
  TOP w0.102: v1(188.42,146.99) 188.39,146.96 U3.31 ; R29.2 191.67,142.83 v1(191.44,142.83)
  BOTTOM w0.102: v1(191.44,142.83) 188.42,145.85 v1(188.42,146.99)
CPU_TRST#_PCH: length 3.7
  TOP w0.076: U28.AM4 107.03,22.55 106.22,22.55 105.78,22.99 105.15,22.99 v1(104.72,22.56)
  BOTTOM w0.102: TP55.1 104.98,22.81 v1(104.72,22.56)
CPU_VCCIO_PWR_GATE#: length 3.6
  TOP w0.076: 103.96,19.26 106.07,19.26 106.29,19.04 106.41,19.04 U28.AY3
  TOP w0.102: 103.96,19.26 TP38.1
CPUCORE_ON_EC: length 169.7
  TOP w0.102: R505.1 188.75,153.44 v1(189.05,153.75)
  L6_IN2 w0.089: v1(149.58,26.55) 149.55,26.58 149.55,27.13 151.08,28.65 161.65,28.65 163.02,27.29 163.87,27.29 164.55,27.97 175.95,27.97 178.06,30.08 182.29,30.08 184.1,31.89 184.1,46.56 184.73,47.2 v1(184.99,47.2)
  L8_IN3 w0.089: v1(189.05,153.75) 189.43,153.75 190.58,152.61 190.58,139.81 191.17,139.22 191.17,135.25 193.93,132.49 193.93,101.1 192.86,100.03 192.86,96.85 191.59,95.58 191.59,84.79 189.33,82.53 189.33,65.26 185.04,60.97 185.04,47.25 v1(184.99,47.2)
  BOTTOM w0.102: U5.100 150.02,27.92 149.58,27.49 v1(149.58,26.55)
CPVEE: length 2.7
  TOP w0.203: C178.1 18.49,57.77 19.16,57.77 19.76,58.37 U7.34
CT1_1V8_AON: length 1.7
  TOP w0.254: C3893.2 74.37,63.45 74.61,63.22 U107.12
CT2_1V8_MAIN: length 1.7
  TOP w0.254: C3896.2 75.51,64.14 75.51,63.33 75.41,63.22 U107.10
DAS_SSD2: length 28.4
  TOP w0.102: CNSSD2.10 164.57,32.18 v1(164.54,32.21) ; CNSSD1.10 v1(141.57,31.94)
  L8_IN3 w0.089: v1(164.54,32.21) 163.45,31.12 153.88,31.12 152.49,32.52 149.35,32.52 148.78,31.94 v1(141.57,31.94)
  BOTTOM w0.102: v1(164.54,32.21) 164.57,32.18 TP199.1 ; TP198.1 141.53,31.9 v1(141.57,31.94)
DC_IN: length 123.4
  TOP w0.203: R3305.1 69.62,37.14 C3582.1 69.9,35.89 70.18,36.17 v1(70.18,36.35) ; D28.1 59.45,36.08 v1(58.88,36.66)
  TOP w0.381: 46.05,65.23 47.7,66.88 R900.1
  TOP w0.508: v1(35.38,58.12) 35.38,60.79 39.83,65.23 46.05,65.23
  L3_IN1 w0.381: v1(35.38,58.12) 29.39,52.12 26.85,52.12 26.29,51.57 12.7,51.57 v1(9.85,48.72)
  L8_IN3 w0.203: v1(10.87,48.59) 11,48.59 11.63,47.96 11.63,41.99 13.79,39.83 24.84,39.83 25.73,40.72 30.91,40.72 33.45,43.26 48.72,43.26 50.24,41.74 56.08,41.74 58.88,38.94 v1(58.88,36.66) 60.3,35.23 64.92,35.23 65.76,36.07 69.9,36.07 v1(70.18,36.35)
DC_IN+:
  vias: v1(2.11,53.55) v1(2.11,52.66) v1(2.11,50.24) v1(2.11,49.23) v1(2.11,48.34) v1(2.23,47.58) v1(2.49,50.75) v5(1.47,54.18) v5(1.47,53.17) v5(1.47,52.15) v5(1.47,50.75) v5(1.47,49.74) v5(1.47,48.72) v5(1.47,47.7) v5(2.36,54.56) v5(38.56,166.2) v5(38.56,165.05) v5(39.57,166.2) v5(39.57,165.05) v5(40.72,166.2) v5(40.72,165.05) v5(41.73,166.2) v5(41.73,165.05) v5(42.75,166.2) v5(42.75,165.05)
DC_IN_B: length 46.6
  TOP w0.203: v1(64.21,36.5) 64.21,35.82 63.83,35.44 C3535.2 63.58,36.3 C3532.2 63.58,36.35 R3295.2
  TOP w0.254: v1(37.29,54.36) 36.96,54.69 R344.1
  L8_IN3 w0.203: v1(37.29,54.36) 37.45,54.36 37.79,54.02 37.79,50.12 40.97,46.94 62.81,46.94 63.7,46.05 63.7,37.01 v1(64.21,36.5)
  vias: v5(22.68,49.86) v5(22.68,48.85) v5(23.7,49.86) v5(23.7,48.85) v5(33.48,53.8) v5(33.48,52.78) v5(34.49,53.8) v5(34.49,52.78)
DCIN_G: length 181.9
  TOP w0.508: Q41.4 2.94,47.39 v1(2.87,47.32) ; Q43.4 v1(2.02,51.43)
  L3_IN1 w0.508: v1(2.02,51.43) 2.7,51.43 ; 2.7,51.43 3.25,50.88 3.25,47.7 v1(2.87,47.32) ; 2.7,51.43 3.25,51.98 3.25,57.74 2.72,58.27 2.72,62.97 1.32,64.37 1.32,102.29 2.36,103.33 2.36,113.24 3.89,114.76 3.89,120.86 6.55,123.52 6.55,124.16 2.74,127.97 2.74,140.03 4.16,141.45 4.16,142.17 3.67,142.66 3.67,143.38 5.28,144.99 5.28,149.18 1.79,152.67 1.79,161.69 2.74,162.64 8.71,162.64 10.62,164.54 23.7,164.54 27,167.85 43.76,167.85 44.27,167.34 v1(44.27,161.75)
  BOTTOM w0.381: R420.1 44.35,157.48 43.89,157.94 43.89,161.37 v1(44.27,161.75) 44.78,162.26 R403.2
DDR0_A_ALERT_N: length 29.8
  TOP w0.076: 149.64,102.89 149.6,102.93 149.6,106.06 U26.AU5
  TOP w0.102: v1(149.37,101.37) 149.37,101.4 149.72,101.75 149.72,102.81 149.64,102.89
  TOP w0.165: v1(152.73,83.61) 152.38,83.26 152.38,82.63 152.39,82.61 CN1.116
  L8_IN3 w0.135: v1(152.73,83.61) 153.35,83.61 154.62,84.89 154.62,86.63 155.02,87.02 155.02,92.48 151.38,96.12 151.38,97.77 149.37,99.79 v1(149.37,101.37)
DDR0_A_PARITY: length 27.5
  TOP w0.076: v1(142.36,100.77) 141.75,100.77 141.2,101.32 141.2,103.63 141,103.82 141,105.07 U26.AG3
  TOP w0.165: v1(144.09,88.92) 145.48,88.92 145.64,89.08 CN1.143
  L8_IN3 w0.076: v1(142.36,100.77) 142.8,100.33 142.8,98.85 143.77,97.88 143.77,97.48
  L8_IN3 w0.135: 143.77,97.48 143.77,95.38 143.55,95.16 143.55,94.96 143.77,94.75 143.77,94.52 143.6,94.35 142.76,94.35 142.63,94.22 142.63,93.95 142.76,93.82 143.62,93.82 143.75,93.68 143.75,93.41 143.62,93.28 142.37,93.28 142.24,93.14 142.24,92.87 142.37,92.74 143.15,92.74 143.29,92.6 143.29,92.15 143.04,91.91 143.04,91.53 143.29,91.28 143.29,90.92 143.15,90.78 142.37,90.78 142.23,90.65 142.23,90.38 142.37,90.24 143.15,90.24 143.29,90.11 143.29,88.65 143.43,88.51 143.68,88.51 v1(144.09,88.92)
DDR0_VREF_DQ: length 5
  TOP w0.076: TP39.1 164.19,112.19 164.19,112.58 163.47,113.3 162.32,113.3 162.01,112.99 162.01,112.74 161.75,112.47 161.37,112.47 160.99,112.1 U26.BP13
DDR1_B_ALERT_N: length 45.2
  TOP w0.076: v1(146.73,108.95) U26.AR8
  TOP w0.165: CN11.116 152.4,69.04 152.57,69.21 152.57,69.95 v1(152.4,70.12)
  L3_IN1 w0.076: v1(146.73,108.95) 146.73,108.95 146.36,108.58 146.36,108.02 147.18,107.21 147.18,103.62 148.02,102.78 148.02,100.2 149.89,98.34 149.89,97.48
  L3_IN1 w0.135: 149.89,97.48 149.89,95.34 152.48,92.75 152.48,87.5 153.24,86.74 153.24,82.34 152.86,81.96 152.86,80.26 152.92,80.2 152.92,75.11 152.86,75.05 152.86,73.07 153.22,72.71 153.22,70.95 v1(152.4,70.12)
DDR1_B_PARITY: length 41.4
  TOP w0.076: v1(142.16,108.3) U26.AJ7
  TOP w0.165: CN11.143 145.65,76.05 143.54,73.94 v1(143.39,73.94)
  L3_IN1 w0.076: v1(142.16,108.3) 142.16,106.74 141.64,106.23 141.64,99.69 142.18,99.14 142.18,97.48
  L3_IN1 w0.135: v1(143.39,73.94) 143.19,73.94 142.7,74.44 142.7,79.4 142.69,79.41 142.69,79.82 142.7,79.83 142.7,83.75 142.66,83.79 142.66,85.63 142.58,85.71 142.58,85.92 142.58,85.93 142.58,87.54 141.71,88.4 141.71,89.75 140.33,91.13 140.33,92.54 140.58,92.79 141.28,92.79 142.18,93.69 142.18,97.48
DDR4_DIMM_DRAMRST#: length 19.2
  TOP w0.102: CN11.108 154.4,67.02 v1(154.25,66.88) ; CN1.108 154.39,80.27 v1(155.76,78.9)
  BOTTOM w0.102: v1(154.25,66.88) 154.25,66.32 C74.2 R43.1 155.4,66.32 155.4,67.26 156.39,68.25 156.39,78.27 v1(155.76,78.9)
DDR4_DRAMRST#: length 121.8
  TOP w0.076: U28.BB46 128.7,17.24 128.84,17.39 130.09,17.39 130.5,16.97 v1(130.5,16.86)
  L6_IN2 w0.089: v1(130.5,16.86) 130.66,16.71 131.81,16.71 132.41,16.11 134,16.11 135.99,18.11 140.78,18.11 142.65,19.97 143.74,19.97 145.19,21.42 145.94,21.42 148.77,24.25 151.67,24.25 153.17,25.75 162.99,25.75 163.33,25.42 171.21,25.42 172.69,26.9 176.53,26.9 178.42,28.78 180.67,28.78 181.76,29.87 182.37,29.87 184.48,31.98 184.48,45.29 v1(185.11,45.93)
  BOTTOM w0.102: v1(185.11,45.93) 183.72,45.93 182.14,44.35 175.26,44.35 173.32,46.3 173.32,49.57 171.63,51.26 165.3,51.26 156.16,60.4 R53.2 R43.2
DDR_RCOMP0: length 8.1
  TOP w0.254: U26.G1 125.25,103.67 124.37,102.8
  TOP w0.381: 124.37,102.8 123.51,101.93 118.95,101.93 118.57,102.31 R1.2
DDR_RCOMP1: length 6.8
  TOP w0.254: 124.66,102.1 126.11,103.55 U26.H1
  TOP w0.381: 124.66,102.1 124.66,100.92 126.27,99.31 R2.2
DDR_RCOMP2: length 5.9
  TOP w0.254: 125.7,102.44 126.68,103.44 126.68,104.45 U26.J2
  TOP w0.381: 125.7,102.44 125.55,102.28 125.55,101.3 126.65,100.2 R4.2
DDR_VTT_PG_CTRL: length 29.7
  TOP w0.102: R305.2 188.16,118.32 187.02,117.17 184.99,117.17 v1(181.43,113.62) ; U26.BT13 163.64,112.09 v1(163.77,111.96)
  L3_IN1 w0.076: 167.11,112.73 164.53,112.73 v1(163.77,111.96)
  L3_IN1 w0.089: v1(181.43,113.62) 172.16,113.62 171.27,112.73 167.11,112.73
  BOTTOM w0.076: v3(164.44,111.71) 164.16,111.99 163.8,111.99 v1(163.77,111.96)
DGPU_PEX_RXN_0: length 24.1
  TOP w0.102: G1.BK27 94.95,98.98 95.3,99.33 95.69,99.33 95.88,99.53 99.09,99.53 99.33,99.29
  TOP w0.114: 99.33,99.29 103.74,99.29 112.23,107.78 114.51,107.78 114.68,107.94 C1516.2
DGPU_PEX_RXN_1: length 22.3
  TOP w0.114: C1514.2 112.77,108.37 112.6,108.54 112.34,108.54 103.61,99.81 95.91,99.81 95.67,100.04 95.15,100.04 95.04,100.15 95.04,100.29 95.21,100.46 95.37,100.46 G1.BL29
DGPU_PEX_RXN_2: length 22.8
  TOP w0.114: C1512.2 114.68,110.24 114.4,109.96 112.03,109.96 111.16,109.08 111.16,108.68 103.31,100.84 96.39,100.84 G1.BM30
DGPU_PEX_RXN_3: length 22.6
  TOP w0.114: G1.BK30 94.93,101.08 95.29,101.44 95.66,101.44 95.88,101.66 95.98,101.66 95.99,101.66 96.49,101.66 96.6,101.56 98.16,101.56 98.21,101.61 98.21,101.61 103.1,101.61 110.45,108.96 110.45,109.42 112.15,111.12 112.57,111.12 C1510.2
DGPU_PEX_RXN_4: length 24.6
  TOP w0.114: C1491.2 114.72,112.4 114.84,112.28 114.84,112.12 114.72,112.01 112.05,112.01 109.75,109.71 109.75,109.26 107.13,106.64
  TOP w0.117: G1.BL32 95.45,102.54 95.56,102.65 95.69,102.65 95.79,102.55 95.79,102.34 95.99,102.15 97.53,102.15 97.74,102.36 102.86,102.36 107.13,106.64
DGPU_PEX_RXN_5: length 21.6
  TOP w0.114: G1.BM33 96.38,102.95 97.32,102.95 97.48,103.11 102.61,103.11 109.05,109.55 109.05,110.21 112.01,113.17 112.66,113.17 112.77,113.28 C1490.2
DGPU_PEX_RXN_6: length 25
  TOP w0.114: C1489.2 114.46,114.29 112.14,114.29 108.36,110.5 108.36,109.84 102.38,103.86 97.19,103.86 97.09,103.76 95.88,103.76 95.88,103.77 95.81,103.77 95.59,103.54 95.37,103.54 95.01,103.18 G1.BK33
DGPU_PEX_RXN_7: length 23.7
  TOP w0.114: G1.BL35 95.39,104.63 95.16,104.63 95.06,104.53 95.06,104.32 95.16,104.21 95.73,104.21 95.95,104 96.91,104 97.27,104.37 102.24,104.37 107.85,109.98 107.85,110.75 112.18,115.08 112.44,115.08 112.77,114.75 C1488.2
DGPU_PEX_RXN_8: length 23.9
  TOP w0.114: G1.BM36 96.41,105.01 96.62,105.01 96.87,105.26 96.87,105.26 98.94,105.26 99.05,105.37 101.91,105.37 106.78,110.24 106.78,111.01 112.09,116.32 114.36,116.32 C1483.2
DGPU_PEX_RXN_9: length 23.8
  TOP w0.114: G1.BK36 95,105.28 95.36,105.64 95.56,105.64 95.57,105.65 95.58,105.65 95.81,105.88 95.82,105.88 98.65,105.88 98.9,106.12 101.67,106.12 106.09,110.53 106.09,111.57 112.02,117.5 112.59,117.5 C1482.2
DGPU_PEX_RXN_10: length 26
  TOP w0.114: G1.BL38 95.45,106.75 95.54,106.84 95.67,106.84 95.78,106.73 95.78,106.51 95.94,106.35 96.52,106.35 96.71,106.54 96.72,106.54 98.47,106.54 98.8,106.87 101.43,106.87 105.39,110.82 105.39,112 111.73,118.35 114.74,118.35 114.85,118.46 114.85,118.64 114.75,118.75 C1481.2
DGPU_PEX_RXN_11: length 22.8
  TOP w0.114: C1480.2 112.76,119.58 112.64,119.47 111.85,119.47 104.69,112.31 104.69,111.11 101.2,107.63 98.75,107.63 98.25,107.14 96.39,107.14 G1.BM39
DGPU_PEX_RXN_12: length 26.4
  TOP w0.114: G1.BK39 94.97,107.38 95.29,107.71 95.3,107.71 95.31,107.72 95.64,107.72 95.88,107.96 96.43,107.96 96.59,107.81 98.11,107.81 98.69,108.38 100.97,108.38 103.99,111.4 103.99,112.61 111.98,120.6 114.37,120.6 C1479.2
DGPU_PEX_RXN_13: length 24.5
  TOP w0.114: G1.BL41 95.54,108.69 95.75,108.69 96,108.45 97.94,108.45 98.62,109.13 100.73,109.13 103.29,111.69 103.29,112.96 111.8,121.47 112.91,121.47 113.03,121.59 113.03,121.83 112.91,121.95 C1478.2
DGPU_PEX_RXN_14: length 25
  TOP w0.114: G1.BM42 96.35,109.28 97.86,109.28 98.47,109.89 100.5,109.89 102.59,111.98 102.59,113.25 112,122.66 114.37,122.66 C1477.2
DGPU_PEX_RXN_15: length 24.8
  TOP w0.114: C1476.2 112.6,123.84 112.19,123.84 101.87,113.52 101.87,113.52 101.87,113.45 101.87,113.44 101.87,113.42
  TOP w0.117: G1.BK42 94.94,109.48 95.28,109.83 95.64,109.83 95.94,110.12 97.89,110.12 98.41,110.64 100.26,110.64 101.87,112.25 101.87,113.42
DGPU_PEX_RXP_0: length 24.1
  TOP w0.102: G1.BL27 95.28,98.98 95.21,98.9 95.21,98.76 95.29,98.67 95.62,98.67 95.83,98.88 95.83,99.15 95.97,99.3 98.99,99.3 99.24,99.05 99.33,99.05
  TOP w0.114: 99.33,99.05 103.84,99.05 112.33,107.53 114.44,107.53 C1515.2
DGPU_PEX_RXP_1: length 22.3
  TOP w0.114: C1513.2 112.41,108.78 112.24,108.78 103.51,100.05 96.01,100.05 95.84,100.22 95.84,100.45 95.6,100.7 95.06,100.7 G1.BK29
DGPU_PEX_RXP_2: length 22.9
  TOP w0.114: C1511.2 114.68,109.5 114.46,109.72 112.13,109.72 111.4,108.98 111.4,108.58 103.41,100.59 96.26,100.59 96.15,100.48 G1.BM29
DGPU_PEX_RXP_3: length 22.6
  TOP w0.114: G1.BL30 95.56,100.97 95.72,100.97 95.83,101.08 95.83,101.26 95.98,101.42 96.39,101.42 96.5,101.31 98.26,101.31 98.31,101.37 103.2,101.37 110.69,108.86 110.69,109.32 112.25,110.88 112.85,110.88 112.97,110.76 112.97,110.56 112.86,110.44 C1509.2
DGPU_PEX_RXP_4: length 24.6
  TOP w0.114: 107.3,106.46 107.32,106.48 107.32,106.49 107.37,106.54 107.37,106.54 109.99,109.16 109.99,109.61 112.15,111.77 114.42,111.77 C1507.2
  TOP w0.117: G1.BK32 94.96,102.48 95.32,102.12 95.67,102.12 95.89,101.9 97.63,101.9 97.85,102.12 102.96,102.12 107.3,106.46
DGPU_PEX_RXP_5: length 21.6
  TOP w0.114: G1.BM32 96.37,102.71 97.42,102.71 97.58,102.87 102.71,102.87 109.3,109.45 109.3,110.11 112.11,112.93 112.66,112.93 112.77,112.81 C1506.2
DGPU_PEX_RXP_6: length 25
  TOP w0.114: G1.BL33 95.45,103.04 95.54,102.94 95.68,102.94 95.81,103.07 95.81,103.41 95.92,103.52 97.19,103.52 97.29,103.62 102.48,103.62 108.6,109.74 108.6,110.4 112.24,114.05 114.57,114.05 114.68,113.93 C1505.2
DGPU_PEX_RXP_7: length 23.8
  TOP w0.102: G1.BK35 95.05,104.89 95.65,104.89 95.82,104.71 95.82,104.48 95.84,104.46 95.84,104.46 96.02,104.28 96.03,104.28 96.06,104.25
  TOP w0.114: 96.06,104.25 96.06,104.24 96.81,104.24 97.17,104.61 102.14,104.61 107.61,110.08 107.61,110.85 112.08,115.33 112.57,115.33 112.77,115.53 C1504.2
DGPU_PEX_RXP_8: length 23.9
  TOP w0.114: G1.BM35 96.33,104.77 96.72,104.77 96.97,105.01 99.04,105.01 99.15,105.13 102.01,105.13 107.03,110.14 107.03,110.91 112.19,116.07 114.41,116.07 114.68,115.81 C1499.2
DGPU_PEX_RXP_9: length 23.8
  TOP w0.114: C1498.2 112.82,116.79 112.96,116.93 112.96,117.12 112.82,117.26 112.12,117.26 106.33,111.47 106.33,110.43 101.77,105.88 99,105.88 98.75,105.63 95.92,105.63 95.77,105.49 95.77,105.3 95.66,105.18 95.54,105.18 G1.BL36
DGPU_PEX_RXP_10: length 25.9
  TOP w0.114: G1.BK38 94.94,106.68 95.32,106.31 95.64,106.31 95.84,106.11 96.63,106.11 96.81,106.29 98.57,106.29 98.9,106.63 101.53,106.63 105.63,110.72 105.63,111.9 111.83,118.11 114.43,118.11 C1497.2
DGPU_PEX_RXP_11: length 22.8
  TOP w0.114: G1.BM38 96.36,106.89 98.35,106.89 98.85,107.39 101.3,107.39 104.93,111.01 104.93,112.21 111.95,119.23 112.64,119.23 112.76,119.11 C1496.2
DGPU_PEX_RXP_12: length 26.4
  TOP w0.114: G1.BL39 95.43,107.36 95.43,107.19 95.54,107.07 95.72,107.07 95.83,107.19 95.83,107.57 95.98,107.72 96.33,107.72 96.49,107.56 98.21,107.56 98.79,108.14 101.07,108.14 104.23,111.3 104.23,112.51 112.08,120.36 114.6,120.36 114.71,120.24 114.71,120.05 C1495.2
DGPU_PEX_RXP_13: length 24.5
  TOP w0.114: C1494.2 112.6,121.23 111.9,121.23 103.53,112.86 103.53,111.59 100.83,108.89 98.72,108.89 98.04,108.2 95.9,108.2 95.65,108.45 95.31,108.45 95.29,108.46 95.28,108.46 94.97,108.78 G1.BK41
DGPU_PEX_RXP_14: length 25.1
  TOP w0.114: G1.BM41 96.4,109.04 97.96,109.04 98.57,109.65 100.6,109.65 102.83,111.88 102.83,113.15 112.1,122.42 114.37,122.42 C1493.2
DGPU_PEX_RXP_15: length 24.8
  TOP w0.114: C1492.2 112.85,123.22 112.85,123.46 112.71,123.6 112.29,123.6 102.11,113.42 102.11,113.42
  TOP w0.117: 102.11,113.42 102.11,112.15 100.36,110.4 98.52,110.4 97.99,109.88 96.04,109.88 95.79,109.62 95.79,109.37 95.67,109.26 95.53,109.26 95.45,109.34 G1.BL42
DGPU_PEX_TXN_0: length 13.9
  TOP w0.117: G1.BH26 93.6,98.03 v6(93.6,97.88)
  BOTTOM w0.114: v6(93.6,97.88) 93.74,97.73 94.26,97.73 94.62,98.09 95.37,98.09 95.56,97.89 101.48,97.89 102.25,98.67 105.65,98.67 105.77,98.78 105.77,99.02 105.65,99.14 C1227.2
DGPU_PEX_TXN_1: length 18.3
  TOP w0.117: G1.BE26 v6(90.95,97.98)
  BOTTOM w0.114: v6(90.95,97.98) 91.17,98.2 91.17,98.49 91.48,98.8 91.98,98.8 92.16,98.62 101.21,98.62 102.67,100.08 107.36,100.08 C1225.2
DGPU_PEX_TXN_2: length 14.8
  TOP w0.117: G1.BG27 v6(92.95,99.28)
  BOTTOM w0.114: C1223.2 105.54,101.16 105.42,101.04 102.65,101.04 101.02,99.41 98.64,99.41 98.56,99.33 95.57,99.33 95.37,99.14 93.63,99.14 93.13,99.64 92.95,99.64 92.84,99.54 92.84,99.39 v6(92.95,99.28)
DGPU_PEX_TXN_3: length 16.4
  TOP w0.117: v6(93.6,100.01) 93.64,100.05 93.64,100.22 93.48,100.38 G1.BH29
  BOTTOM w0.114: C867.2 107.66,102.57 107.77,102.45 107.77,102.27 107.64,102.14 102.76,102.14 100.77,100.15 98.52,100.15 98.31,99.94 95.6,99.94 95.34,100.2 94.17,100.2 93.87,99.9 93.71,99.9 v6(93.6,100.01)
DGPU_PEX_TXN_4: length 16.8
  TOP w0.117: G1.BE29 v6(90.95,100.08)
  BOTTOM w0.114: v6(90.95,100.08) 91.18,100.32 91.18,100.59 91.48,100.89 92.19,100.89 92.36,100.71 98.03,100.71 98.2,100.89 100.52,100.89 103.14,103.51 105.33,103.51 C855.2
DGPU_PEX_TXN_5: length 17.3
  TOP w0.117: v6(92.95,101.38) 92.83,101.26 G1.BG30
  BOTTOM w0.114: v6(92.95,101.38) 92.84,101.48 92.84,101.65 92.96,101.76 93.12,101.76 93.64,101.24 95.46,101.24 95.58,101.35 97.7,101.35 98,101.65 100.29,101.65 103.07,104.43 107.32,104.43 107.57,104.67 C853.2
DGPU_PEX_TXN_6: length 15
  TOP w0.117: G1.BH32 93.35,102.2 93.46,102.08 v6(93.65,102.08)
  BOTTOM w0.114: v6(93.65,102.08) 93.72,102.01 93.88,102.01 94.22,102.35 94.22,102.35 95.38,102.35 95.67,102.06 97.51,102.06 97.86,102.41 100.06,102.41 103.2,105.54 105.62,105.54 105.74,105.66 105.74,105.88 105.62,106 C851.2
DGPU_PEX_TXN_7: length 19.1
  TOP w0.117: G1.BE32 v6(90.95,102.18)
  BOTTOM w0.114: C847.2 107.24,107.07 103.73,107.07 99.84,103.17 97.57,103.17 97.22,102.82 91.39,102.82 91.13,102.57 91.13,102.37 v6(90.95,102.18)
DGPU_PEX_TXN_8: length 16
  TOP w0.117: v6(92.95,103.48) G1.BG33
  BOTTOM w0.114: v6(92.95,103.48) 92.81,103.62 92.81,103.75 92.92,103.87 93.09,103.87 93.62,103.34 95.76,103.34 95.93,103.5 96.91,103.5 97.34,103.94 99.61,103.94 103.73,108.06 105.37,108.06 105.54,108.22 C834.2
DGPU_PEX_TXN_9: length 17.6
  TOP w0.117: G1.BH35 93.33,104.57 93.33,104.3 93.43,104.21 v6(93.62,104.21)
  BOTTOM w0.114: C833.2 107.66,109.55 107.77,109.44 107.77,109.23 107.66,109.11 103.8,109.11 99.73,105.04 97.37,105.04 96.5,104.16 95.76,104.16 95.52,104.4 94.22,104.4 93.89,104.08 93.73,104.08 93.62,104.19 v6(93.62,104.21)
DGPU_PEX_TXN_10: length 17.7
  TOP w0.117: G1.BE35 v6(90.95,104.28)
  BOTTOM w0.114: v6(90.95,104.28) 91.2,104.54 91.2,104.66 91.46,104.91 96.35,104.91 97.22,105.79 99.49,105.79 104.19,110.49 105.33,110.49 C831.2
DGPU_PEX_TXN_11: length 18.9
  TOP w0.117: G1.BG36 v6(92.95,105.58)
  BOTTOM w0.102: v6(92.95,105.58) 92.8,105.72 92.8,105.85 92.93,105.98 93.08,105.98 93.62,105.44
  BOTTOM w0.114: 93.62,105.44 95.87,105.44 96.97,106.54 99.25,106.54 102.03,109.32 102.03,110.06 103.43,111.46 107.27,111.46 107.57,111.76 C829.2
DGPU_PEX_TXN_12: length 16.3
  TOP w0.117: v6(93.6,106.31) 93.46,106.31 93.35,106.42 G1.BH38
  BOTTOM w0.114: v6(93.6,106.31) 93.6,106.41 93.71,106.53 96.15,106.53 96.93,107.3 96.93,107.3 99.02,107.3 101.19,109.47 101.19,110.21 103.51,112.53 105.62,112.53 105.74,112.65 105.74,112.87 105.63,112.98 C828.2
DGPU_PEX_TXN_13: length 21.2
  TOP w0.117: G1.BE38 v6(90.95,106.38)
  BOTTOM w0.114: v6(90.95,106.38) 91.24,106.68 91.24,106.93 91.51,107.2 92.03,107.2 92.19,107.03 95.69,107.03 96.57,107.91 98.65,107.91 100.32,109.58 100.32,110.71 103.35,113.75 106.79,113.75 106.97,113.93 107.37,113.93 C826.2
DGPU_PEX_TXN_14: length 17.7
  TOP w0.117: v6(92.95,107.68) 92.8,107.68 92.65,107.53 G1.BG39
  BOTTOM w0.114: v6(92.95,107.68) 92.83,107.8 92.83,107.96 92.95,108.07 93.24,108.07 93.78,107.54 95.29,107.54 96.27,108.52 98.27,108.52 99.52,109.77 99.52,110.9 103.54,114.92 105.27,114.92 105.54,115.18 C824.2
DGPU_PEX_TXN_15: length 19
  TOP w0.117: G1.BG41 v6(92.95,108.48)
  BOTTOM w0.114: C822.2 107.37,116.21 103.84,116.21 98.73,111.1 98.73,110.26 97.69,109.23 93.46,109.23 93.17,108.94 93.17,108.71 v6(92.95,108.48)
DGPU_PEX_TXP_0: length 13.8
  TOP w0.117: G1.BG26 v6(92.95,97.98)
  BOTTOM w0.114: v6(92.95,97.98) 93.44,97.49 94.36,97.49 94.72,97.85 95.27,97.85 95.46,97.65 101.58,97.65 102.35,98.43 105.36,98.43 C1224.2
DGPU_PEX_TXP_1: length 18.3
  TOP w0.117: v6(91.65,97.98) 91.65,98.06 91.87,98.28 G1.BF26
  BOTTOM w0.114: C1226.2 107.57,99.72 107.45,99.84 102.77,99.84 101.31,98.37 92.06,98.37 91.88,98.56 91.58,98.56 91.41,98.39 91.41,98.1 91.53,97.98 v6(91.65,97.98)
DGPU_PEX_TXP_2: length 14.8
  TOP w0.117: G1.BF27 v6(92.25,99.28)
  BOTTOM w0.114: v6(92.25,99.28) 92.64,98.89 92.99,98.89 95.47,98.89 95.67,99.09 98.66,99.09 98.74,99.17 101.12,99.17 102.75,100.8 105.27,100.8 C859.2
DGPU_PEX_TXP_3: length 16.5
  TOP w0.117: G1.BG29 v6(92.95,100.08)
  BOTTOM w0.114: C868.2 107.33,101.9 102.86,101.9 100.87,99.91 98.62,99.91 98.41,99.7 95.5,99.7 95.24,99.96 94.27,99.96 93.92,99.61 93.46,99.61 92.99,100.08 v6(92.95,100.08)
DGPU_PEX_TXP_4: length 16.8
  TOP w0.117: G1.BF29 91.89,100.38 91.65,100.13 v6(91.65,100.08)
  BOTTOM w0.114: v6(91.65,100.08) 91.54,100.08 91.42,100.2 91.42,100.49 91.58,100.65 92.09,100.65 92.26,100.47 98.13,100.47 98.3,100.65 100.62,100.65 103.24,103.27 105.42,103.27 105.54,103.15 C852.2
DGPU_PEX_TXP_5: length 17.3
  TOP w0.117: G1.BF30 v6(92.25,101.38)
  BOTTOM w0.114: v6(92.25,101.38) 92.64,100.99 95.56,100.99 95.68,101.11 97.8,101.11 98.1,101.41 100.39,101.41 103.17,104.19 107.35,104.19 C854.2
DGPU_PEX_TXP_6: length 15
  TOP w0.117: G1.BG32 v6(92.95,102.18)
  BOTTOM w0.114: C846.2 105.34,105.3 103.3,105.3 100.16,102.17 97.96,102.17 97.61,101.82 95.57,101.82 95.28,102.11 94.32,102.11 93.97,101.76 93.97,101.75 93.92,101.7 93.5,101.7 93.02,102.18 v6(92.95,102.18)
DGPU_PEX_TXP_7: length 19.2
  TOP w0.117: v6(91.65,102.18) 91.65,102.21 91.92,102.48 G1.BF32
  BOTTOM w0.114: v6(91.65,102.18) 91.49,102.18 91.38,102.3 91.38,102.47 91.49,102.58 97.32,102.58 97.67,102.93 99.94,102.93 103.83,106.83 107.28,106.83 107.44,106.66 C848.2
DGPU_PEX_TXP_8: length 16
  TOP w0.117: v6(92.25,103.48) G1.BF33
  BOTTOM w0.114: v6(92.25,103.48) 92.64,103.09 95.86,103.09 96.03,103.26 97.01,103.26 97.44,103.69 99.71,103.69 103.83,107.81 105.24,107.81 C832.2
DGPU_PEX_TXP_9: length 17.6
  TOP w0.117: G1.BG35 v6(92.95,104.28)
  BOTTOM w0.114: v6(92.95,104.28) 92.99,104.28 93.47,103.8 93.96,103.8 94.32,104.16 95.42,104.16 95.66,103.92 96.6,103.92 97.47,104.8 99.83,104.8 103.9,108.87 107.36,108.87 C830.2
DGPU_PEX_TXP_10: length 17.7
  TOP w0.117: G1.BF35 91.83,104.58 91.65,104.39 v6(91.65,104.28)
  BOTTOM w0.114: v6(91.65,104.28) 91.56,104.28 91.44,104.4 91.44,104.56 91.56,104.67 96.45,104.67 97.32,105.55 99.59,105.55 104.29,110.25 105.42,110.25 105.54,110.14 C827.2
DGPU_PEX_TXP_11: length 19
  TOP w0.117: G1.BF36 v6(92.25,105.58)
  BOTTOM w0.114: C789.2 107.3,111.22 103.53,111.22 102.27,109.96 102.27,109.22 99.35,106.29 97.07,106.29 95.97,105.19 92.99,105.19 92.64,105.19 v6(92.25,105.58)
DGPU_PEX_TXP_12: length 16.4
  TOP w0.117: G1.BG38 v6(92.95,106.38)
  BOTTOM w0.114: v6(92.95,106.38) 92.98,106.38 93.46,105.9 93.74,105.9 94.13,106.28 96.26,106.28 97.03,107.06 99.12,107.06 101.43,109.37 101.43,110.11 103.61,112.29 105.34,112.29 C825.2
DGPU_PEX_TXP_13: length 21.2
  TOP w0.117: G1.BF38 v6(91.65,106.38)
  BOTTOM w0.114: v6(91.65,106.38) 91.49,106.54 91.49,106.82 91.61,106.95 91.93,106.95 92.09,106.79 95.79,106.79 96.67,107.67 98.75,107.67 100.56,109.48 100.56,110.61 103.45,113.51 106.89,113.51 107.07,113.69 107.57,113.69 107.68,113.57 107.68,113.35 C823.2
DGPU_PEX_TXP_14: length 17.7
  TOP w0.117: G1.BF39 v6(92.25,107.68)
  BOTTOM w0.114: C821.2 105.23,114.68 103.64,114.68 99.76,110.8 99.76,109.67 98.37,108.28 96.37,108.28 95.39,107.29 92.64,107.29 v6(92.25,107.68)
DGPU_PEX_TXP_15: length 19
  TOP w0.117: v6(93.6,108.41) 93.6,108.53 G1.BH41
  BOTTOM w0.114: v6(93.6,108.41) 93.42,108.59 93.42,108.84 93.56,108.98 97.79,108.98 98.97,110.16 98.97,111 103.94,115.97 107.49,115.97 107.61,115.86 107.61,115.56 C788.2
DGPU_PWR_ON: length 78.1
  TOP w0.089: U28.AW24 116.17,19.02 115.77,18.62 v2(115.77,18.49)
  TOP w0.102: Q96.1 74.1,50.44 R978.2 72.97,51.57 v1(72.97,53.27) 72.97,54.37 D4.1
  L8_IN3 w0.089: v1(98.37,44.48) 98.37,44.47 98.28,44.38 98.09,44.38 97.92,44.21 97.92,36.89 96.4,35.37 96.4,27.04 101.71,21.73 105.8,21.73 106.79,20.74 106.79,20.53 107.14,20.18 110.2,20.18 111.11,19.26 113.77,19.26 114.66,18.37 115.65,18.37 v2(115.77,18.49)
  BOTTOM w0.102: v1(98.37,44.48) 98.3,44.4 93.67,44.4 93.14,43.87 90.85,43.87 84.81,49.91 84.66,49.91 82.9,51.67 76.31,51.67 74.71,53.27 v1(72.97,53.27)
DGPU_RST_PCH#: length 87.3
  TOP w0.089: U28.BF21 115.5,15.55 115.17,15.22 115.17,14.93 114.38,14.14 v1(114.38,14.1)
  TOP w0.102: Q99.2 107.39,69.17 107.06,68.84 106.17,68.84 105.18,67.85 105.18,65.4 102.39,62.61 99.08,62.61 98.75,62.94 98.25,62.94 v1(98.12,62.82)
  L8_IN3 w0.089: v1(114.38,14.1) 114.38,14.2 115.06,14.89 115.06,16.71 116.81,18.46 116.81,18.79 115.98,19.61 115.09,19.61 114.27,20.42 114.27,20.55 112.88,21.95 110.16,21.95 109.27,21.06 108.08,21.06 106.13,23.02 101,23.02 96.8,27.21 96.8,35.2 98.33,36.72 98.33,40.13 100.14,41.94 100.14,47.87 99.75,48.26 99.75,50.62 98.37,52 98.37,57.48 99.56,58.67 99.56,62.17 98.92,62.82 v1(98.12,62.82)
  BOTTOM w0.102: R363.2 115.57,15.24 114.43,14.1 v1(114.38,14.1)
DIMM_DQ_CPU_VREF_B: length 106
  TOP w0.254: v1(163,112.59) 162.87,112.46 162.12,112.46 161.75,112.09 U26.BR13
  L3_IN1 w0.508: v1(139.85,65.94) 140.13,66.22 180.75,66.22 181.25,66.73 181.25,67.9 181.51,68.15 v1(181.51,68.38)
  L6_IN2 w0.508: v1(163,112.59) 163,112.81 163.4,113.21 165.58,113.21 v1(169.87,108.92)
  L8_IN3 w0.508: v1(169.87,108.92) 171.65,107.14 171.65,104.48 177.76,98.38 179.91,98.38 183.5,94.79 183.5,69.41 182.47,68.38 v1(181.51,68.38)
  BOTTOM w0.076: v3(164.39,113.12) 163.53,113.12 v1(163,112.59)
  BOTTOM w0.508: v1(139.85,65.94) C76.2 R41.2
DMI_RXN0: length 97.3
  TOP w0.076: 121.17,40.31 121.19,40.31 121.19,40.32 121.25,40.32 121.33,40.24 121.33,38.88 120.85,38.39 120.85,37.48 121.14,37.19 121.14,37.02 121.31,36.86 121.43,36.86 121.49,36.86 121.65,36.7 U28.C33
  TOP w0.114: 121.17,40.31 121.07,40.31 v2(120.73,39.97) ; v1(123.94,108.78) 124.27,108.45 U26.E8
  L6_IN2 w0.102: v1(123.94,108.78) 123.7,109.02 123.7,109.27 123.44,109.53 122.76,109.53 121.39,110.9 114.32,110.9 111.33,107.9 111.33,90.71 109.11,88.49 109.11,77.83 107.01,75.72 107.01,65.23 112.95,59.29 112.95,46.39 114.68,44.66 114.68,43.57 118.33,39.92 119.54,39.92 120.68,39.92 v2(120.73,39.97)
DMI_RXN1: length 92.6
  TOP w0.076: 120.29,39.15 120.3,39.14 120.36,39.14 120.45,39.06 120.45,37.32 120.55,37.21 120.55,36.86 120.72,36.69 120.81,36.69 U28.C32
  TOP w0.114: 120.29,39.15 119.3,40.14 119.3,41.04 v2(119.12,41.23) ; U26.F6 124.92,107.6 124.6,107.91 v1(124.6,107.99)
  L6_IN2 w0.102: v2(119.12,41.23) 119.3,41.41 119.3,41.67 118.99,41.99 117.19,41.99 115.34,43.84 115.34,44.93 113.61,46.66 113.61,59.56 108.91,64.26 108.91,76.53 109.77,77.39 109.77,88.06 112.16,90.45 112.16,107.32 114.04,109.19 120.92,109.19 121.72,108.4 124.17,108.4 124.58,107.99 v1(124.6,107.99)
DMI_RXN2: length 88.9
  TOP w0.076: 119.1,39.32 119.86,38.56 119.86,36.93 120.04,36.74 120.12,36.74 U28.C31
  TOP w0.114: 119.1,39.32 117.78,40.64 117.78,41.87 118.32,42.42 118.32,43.37 118.21,43.49 v2(117.83,43.49) ; U26.E5 124.11,106.81 123.94,106.97 v1(123.94,107.21)
  L6_IN2 w0.102: v2(117.83,43.49) 118.62,43.49 118.97,43.84 118.97,44.75 116.43,47.29 116.43,59.55 110.82,65.16 110.82,75.92 111.35,76.45 111.35,85.07 111.35,85.07 111.35,85.6 111.35,85.6 111.35,87.39 111.43,87.48 111.43,87.48 111.67,87.71 113.87,89.91 113.87,105.62 115.52,107.27 117.83,107.27 118.54,106.56 121.34,106.56 121.67,106.23 123.19,106.23 123.75,106.78 123.75,107.01 v1(123.94,107.21)
DMI_RXN3: length 83.1
  TOP w0.076: 118.41,39.32 118.49,39.23 118.5,39.23 119.66,38.08 119.66,36.89 U28.C29
  TOP w0.114: U26.J9 126.22,109.28 v1(125.93,109.57) ; v2(120.6,46.82) 120.39,47.02 118.83,47.02 116.32,44.51 116.32,41.48 118.38,39.42 118.38,39.35 118.41,39.32
  L6_IN2 w0.102: v1(125.93,109.57) 125.51,109.16 125.34,109.16 125.1,108.92 125.1,106.72 117.68,99.29 117.68,90.02 118.46,89.23 118.46,78.34 118.31,78.18 118.31,75.67 118.82,75.16 118.82,48.28 119.98,47.12 120.29,47.12 v2(120.6,46.82)
DMI_RXP0: length 97.3
  TOP w0.076: U28.B33 121.62,37.14 121.49,37.01 121.37,37.01 121.3,37.09 121.3,37.25 121,37.54 121,38.33 121.49,38.81 121.49,40.17 121.49,40.3 121.31,40.47 121.29,40.47 121.27,40.49
  TOP w0.114: v2(120.73,40.86) 121.03,40.55 121.21,40.55 121.27,40.49 ; U26.D8 123.62,108.54 123.38,108.78 v1(123.29,108.78)
  L6_IN2 w0.102: v2(120.73,40.86) 120.73,40.69 120.22,40.18 119.54,40.18 118.43,40.18 114.93,43.67 114.93,44.77 113.21,46.49 113.21,59.39 107.26,65.34 107.26,73.01 107.36,73.11 107.36,73.41 107.26,73.51 107.26,73.82 107.36,73.92 107.36,74.22 107.26,74.32 107.26,74.81 107.36,74.91 107.36,75.22 107.26,75.31 107.26,75.62 109.36,77.72 109.36,88.39 111.58,90.61 111.58,104.57 111.68,104.67 111.68,104.97 111.58,105.07 111.58,105.37 111.68,105.47 111.68,105.78 111.58,105.88 111.58,106.18 111.68,106.28 111.68,106.59 111.58,106.68 111.58,106.99 111.68,107.09 111.68,107.39 111.58,107.49 111.58,107.8 114.43,110.65 118.05,110.65 118.15,110.55 118.46,110.55 118.56,110.65 118.86,110.65 118.96,110.55 119.27,110.55 119.37,110.65 119.67,110.65 119.77,110.55 120.07,110.55 120.17,110.65 120.48,110.65 120.58,110.55 120.88,110.55 120.98,110.65 121.29,110.65 122.66,109.27 123.34,109.27 123.44,109.17 123.44,108.93 v1(123.29,108.78)
DMI_RXP1: length 92.6
  TOP w0.076: U28.B32 120.94,36.91 120.86,36.84 120.78,36.84 120.7,36.92 120.7,37.28 120.6,37.38 120.6,39.12 120.41,39.31 120.41,39.32
  TOP w0.114: U26.E6 124.27,107.67 v1(123.93,108.01) ; v2(120.06,41.23) 119.91,41.23 119.54,40.86 119.54,40.24 120.41,39.37 120.41,39.32
  L6_IN2 w0.102: v2(120.06,41.23) 119.94,41.23 119.56,41.61 119.56,41.78 119.09,42.24 117.3,42.24 115.59,43.95 115.59,45.04 113.87,46.77 113.87,47.07 113.97,47.17 113.97,47.48 113.87,47.57 113.87,47.88 113.97,47.98 113.97,48.28 113.87,48.38 113.87,48.69 113.97,48.79 113.97,49.09 113.87,49.19 113.87,49.5 113.97,49.59 113.97,49.9 113.87,50 113.87,59.67 113.65,59.88 113.65,60.02 113.44,60.24 113.3,60.24 113.08,60.45 113.08,60.59 112.86,60.81 112.72,60.81 112.51,61.02 112.51,61.16 112.29,61.38 112.15,61.38 111.94,61.59 111.94,61.73 111.72,61.95 111.58,61.95 109.17,64.36 109.17,73.2 109.27,73.29 109.27,73.6 109.17,73.7 109.17,74 109.27,74.1 109.27,74.41 109.17,74.51 109.17,74.81 109.27,74.91 109.27,75.21 109.17,75.31 109.17,75.62 109.27,75.72 109.27,76.02 109.17,76.12 109.17,76.43 110.03,77.28 110.03,87.96 112.42,90.35 112.42,107.21 114.14,108.94 120.81,108.94 121.61,108.14 123.79,108.14 v1(123.93,108.01)
DMI_RXP2: length 88.9
  TOP w0.076: 119.44,39.32 119.44,39.2 120.01,38.62 120.01,38.5 120.01,36.99 120.11,36.9 120.23,36.9 120.28,36.95 U28.B31
  TOP w0.114: v1(123.27,107.22) 123.27,107.16 U26.D5 ; v2(117.88,44.17) 118.57,43.49 118.57,42.32 118.02,41.77 118.02,40.74 119.44,39.32
  L6_IN2 w0.102: v1(123.27,107.22) 123.49,106.99 123.49,106.89 123.08,106.48 121.77,106.48 121.44,106.81 121.13,106.81 121.03,106.91 120.73,106.91 120.63,106.81 120.24,106.81 120.14,106.91 119.84,106.91 119.74,106.81 118.64,106.81 117.93,107.52 115.41,107.52 113.61,105.72 113.61,90.02 111.56,87.97 111.09,87.5 111.09,85.5 111.09,85.5 111.09,85.17 111.09,85.17 111.09,76.56 110.57,76.03 110.57,65.06 116.18,59.44 116.18,47.19 117.06,46.3 117.06,46.16 117.28,45.95 117.42,45.95 117.71,45.66 117.71,45.52 117.93,45.3 118.07,45.3 118.72,44.65 118.72,43.95 118.51,43.74 118.31,43.74 v2(117.88,44.17)
DMI_RXP3: length 83
  TOP w0.076: 118.23,39.15 118.31,39.08 118.44,39.08 119.51,38.01 119.51,37.27 U28.B29
  TOP w0.114: 118.23,39.15 118.14,39.25 118.14,39.32 116.08,41.38 116.08,44.61 118.73,47.26 120.26,47.26 v2(120.6,47.6) ; v1(125.89,108.78) 126.06,108.61 U26.J8
  L6_IN2 w0.102: v1(125.89,108.78) 125.76,108.91 125.44,108.91 125.36,108.82 125.36,106.61 124.04,105.3 124.04,105.16 123.83,104.94 123.69,104.94 123.47,104.73 123.47,104.59 123.25,104.37 123.11,104.37 122.9,104.15 122.9,104.01 122.68,103.8 122.54,103.8 122.33,103.58 122.33,103.44 122.11,103.23 121.97,103.23 121.76,103.01 121.76,102.87 121.54,102.66 121.4,102.66 117.93,99.19 117.93,90.12 118.72,89.33 118.72,89.03 118.82,88.93 118.82,88.63 118.72,88.53 118.72,88.22 118.82,88.12 118.82,87.82 118.72,87.72 118.72,87.41 118.82,87.32 118.82,87.01 118.72,86.91 118.72,86.61 118.82,86.51 118.82,86.2 118.72,86.1 118.72,78.23 118.57,78.08 118.57,75.77 119.07,75.26 119.07,50.81 119.17,50.71 119.17,50.41 119.07,50.31 119.07,50.01 119.17,49.91 119.17,49.6 119.07,49.5 119.07,49.2 119.17,49.1 119.17,48.79 119.07,48.69 119.07,48.39 120.09,47.37 120.37,47.37 v2(120.6,47.6)
DMI_TXN0: length 100
  TOP w0.076: 121.21,108.67 121.23,108.69 121.92,108.69 122.02,108.59 122.02,108.35 121.94,108.27 121.74,108.27 121.66,108.35 U26.A8
  TOP w0.089: v2(121.97,33.53) 122.02,33.53 122.22,33.33 122.22,33.1 U28.K34
  TOP w0.114: v1(120.23,108.08) 120.17,108.08 119.99,108.26 119.99,108.42 120.12,108.56 121.1,108.56 121.21,108.67
  L6_IN2 w0.102: v2(121.97,33.53) 122.04,33.53 122.23,33.35 122.23,33.13 121.84,32.74 119.36,32.74 118.08,34.02 118.08,36.35 118.3,36.57 118.44,36.57 118.65,36.78 118.65,36.92 118.87,37.14 119.01,37.14 119.23,37.35 119.23,37.49 119.44,37.71 119.58,37.71 119.8,37.92 119.8,38.06 120.29,38.56 121.11,38.56 121.61,39.07 121.61,41.74 120.45,42.9 117.57,42.9 116.25,44.22 116.25,45.31 114.88,46.69 114.88,48.29 114.98,48.39 114.98,48.69 114.88,48.79 114.88,49.1 114.98,49.19 114.98,49.5 114.88,49.6 114.88,49.9 114.98,50 114.98,50.31 114.88,50.41 114.88,50.71 114.98,50.81 114.98,51.11 114.88,51.21 114.88,60.07 110.16,64.79 110.16,76.48 110.69,77.01 110.69,87.67 110.84,87.82 110.84,87.82 113.08,90.06 113.08,90.27 113.08,98.07 113.08,105.76 115.24,107.93 118.1,107.93 118.61,107.42 118.61,107.42 118.76,107.27 119.52,107.27 120.23,107.98 v1(120.23,108.08)
DMI_TXN1: length 85.6
  TOP w0.076: U26.B6 122.6,107.6 122.68,107.67 122.68,107.81 122.57,107.92 121.49,107.92 120.88,107.32 120.87,107.32 120.85,107.3 120.84,107.3
  TOP w0.089: v2(121.92,34.65) 121.77,34.5 U28.G33
  TOP w0.114: 120.84,107.3 119.74,107.3 119.45,107.01 117.98,107.01 117.68,106.72 117.68,104.83 117.42,104.57 116.95,104.57 116.83,104.46 v1(116.62,104.46)
  L6_IN2 w0.102: v2(121.92,34.65) 121.87,34.7 121.87,34.96 122.17,35.26 122.17,35.47 122.17,35.97 123.6,37.39 123.6,42.93 118.41,48.12 118.41,61.32 114.76,64.98 114.76,69.93 115.77,70.95 115.77,78.18 116.28,78.69 116.28,80.17 116.15,80.3 116.15,100.38 116.25,100.48 116.25,100.78 116.15,100.88 116.15,101.19 116.25,101.29 116.25,101.59 116.15,101.69 116.15,102 116.25,102.1 116.25,102.4 116.15,102.5 116.15,102.8 116.25,102.9 116.25,103.21 116.15,103.31 116.15,103.61 116.25,103.71 116.25,104.02 116.15,104.11 116.15,104.42 116.29,104.55 116.52,104.55 v1(116.62,104.46)
DMI_TXN2: length 92.2
  TOP w0.076: 119.25,105.56 119.73,106.05 119.73,106.19 120.41,106.86 121.04,106.86 121.35,107.17 121.7,107.17 121.81,107.06 121.81,106.95 121.7,106.84 U26.A5
  TOP w0.089: U28.K32 121.01,33.25 v2(121.33,33.25)
  TOP w0.114: v2(118.96,105.15) 118.96,105.28 119.25,105.56
  L6_IN2 w0.102: v2(118.96,105.15) 118.75,105.37 118.13,105.37 116.99,106.51 115.88,106.51 114.63,105.26 114.63,89.74 112.09,87.2 112.09,85.34 112.09,85.33 112.09,85.07 112.09,85.06 112.09,76.02 111.71,75.64 111.71,65.21 117.09,59.82 117.09,47.57 122.27,42.39 122.27,38.07 121.52,37.32 120.61,37.32 119.43,36.13 119.43,35.72 118.92,35.21 118.92,34.67 118.92,34.11 119.25,33.79 119.56,33.78 120.07,34.29 120.52,34.29 121.33,33.48 v2(121.33,33.25)
DMI_TXN3: length 90.7
  TOP w0.076: 121.1,106.35 121.9,106.35 122.5,105.76 122.93,105.76 123.04,105.86 123.04,106.1 122.96,106.18 122.72,106.18 U26.B4
  TOP w0.089: v2(119.59,35.01) 119.58,35 119.58,34.89 U28.G30
  TOP w0.114: v1(120.85,105.12) 120.85,104.88 120.74,104.77 120.47,104.77 120.39,104.85 120.39,105.64 121.1,106.35
  L6_IN2 w0.102: v2(119.59,35.01) 119.84,35.27 119.84,35.97 120.78,36.91 121.76,36.91 122.68,37.83 122.68,42.56 117.5,47.74 117.5,60.22 113.49,64.24 113.49,70.03 114.76,71.3 114.76,73 113.11,74.65 113.11,79.51 113.46,79.86 115.14,81.54 115.14,105.09 115.92,105.87 117.04,105.87 118.28,104.63 119.86,104.63 120.04,104.8 120.54,104.8 v1(120.85,105.12)
DMI_TXP0: length 100
  TOP w0.076: U26.B8 122.17,108.53 122.17,108.66 121.99,108.84 121.11,108.84
  TOP w0.089: v2(122.76,33.35) 122.76,33.5 U28.J35
  TOP w0.114: 121.11,108.84 121.07,108.8 120.02,108.8 119.76,108.54 119.76,108.19 v1(119.65,108.08)
  L6_IN2 w0.102: v2(122.76,33.35) 122.48,33.08 122.48,33.02 121.94,32.48 121.73,32.48 119.26,32.48 117.83,33.91 117.83,36.46 120.19,38.81 121,38.81 121.36,39.17 121.36,41.63 120.34,42.65 117.47,42.65 116,44.12 116,45.21 114.63,46.58 114.63,59.96 109.9,64.69 109.9,76.59 110.43,77.11 110.43,87.77 110.59,87.93 112.82,90.16 112.82,90.27 112.82,98.07 112.82,105.87 115.14,108.18 118.2,108.18 118.71,107.67 118.72,107.67 118.87,107.52 119.42,107.52 119.65,107.75 v1(119.65,108.08)
DMI_TXP1: length 85.6
  TOP w0.076: U26.C6 122.87,107.69 122.87,107.87 122.64,108.1 121.4,108.1 120.79,107.49
  TOP w0.089: U28.F34 121.45,35.16 v2(121.29,35.01)
  TOP w0.114: v1(116.66,105.04) 116.74,105.04 116.97,104.81 117.32,104.81 117.44,104.93 117.44,106.82 117.88,107.25 119.43,107.25 119.67,107.49 120.79,107.49
  L6_IN2 w0.102: v1(116.66,105.04) 116.52,105.04 116.33,104.85 116.23,104.85 115.9,104.52 115.9,80.19 116.03,80.07 116.03,78.8 115.52,78.29 115.52,71.05 114.5,70.03 114.5,64.87 118.16,61.21 118.16,48.01 123.34,42.83 123.34,37.49 121.92,36.07 121.92,35.37 121.56,35.01 v2(121.29,35.01)
DMI_TXP2: length 92.2
  TOP w0.076: U26.B5 122.28,106.81 121.77,107.32 121.28,107.32 120.98,107.01 120.34,107.01 119.58,106.25 119.58,106.11 119.51,106.04 119.25,106.04
  TOP w0.089: v2(120.52,33.53) 120.79,33.53 U28.J32
  TOP w0.114: v2(118.96,106.04) 119.25,106.04
  L6_IN2 w0.102: v2(118.96,106.04) 118.54,105.62 118.23,105.62 117.09,106.76 115.77,106.76 114.38,105.36 114.38,89.85 111.84,87.31 111.84,85.36 111.83,85.35 111.83,85.06 111.84,85.06 111.84,76.13 111.45,75.75 111.45,65.1 116.84,59.72 116.84,47.46 122.02,42.28 122.02,38.18 121.41,37.57 120.51,37.57 119.18,36.24 119.18,35.82 118.67,35.31 118.67,34.01 119.15,33.53 119.53,33.53 119.66,33.53 120.17,34.04 120.42,34.04 120.52,33.93 v2(120.52,33.53)
DMI_TXP3: length 90.7
  TOP w0.076: 120.75,106.35 120.76,106.36 120.79,106.36 120.96,106.53 121.99,106.53 122.11,106.41 123,106.41 123.32,106.09 U26.D4
  TOP w0.089: v2(120.42,34.8) 120.33,34.8 120.14,35 U28.F30
  TOP w0.114: 120.75,106.35 120.15,105.74 120.15,104.75 120.37,104.53 120.7,104.53 v1(120.85,104.38)
  L6_IN2 w0.102: v2(120.42,34.8) 120.24,34.8 120.1,34.95 120.1,35.87 120.89,36.66 121.87,36.66 122.93,37.72 122.93,42.66 117.75,47.84 117.75,60.33 113.74,64.34 113.74,69.93 115.01,71.2 115.01,73.1 113.36,74.76 113.36,79.4 115.39,81.43 115.39,104.98 116.03,105.62 116.94,105.62 118.18,104.37 119.97,104.37 120.14,104.55 120.68,104.55 v1(120.85,104.38)
DMIC_CLK: length 4.7
  BOTTOM w0.102: B16.1 v3(73.1,155.53) 73.61,156.04 73.61,156.42 73.29,156.74 D44.1 73.29,158.9 CNEDP1.34
DMIC_CLK_L: length 196.6
  TOP w0.102: U7.3 27.23,58.37 v1(27.25,58.39)
  L8_IN3 w0.089: v1(70.81,156.16) 69.78,157.2 69.78,159 69.84,159.06 69.84,161.52 68.9,162.46 68.73,162.46 62.06,162.46 58.45,158.85 54.02,158.85 52.4,160.48 52.4,162.77 46.35,168.81 34.09,168.81 28.68,163.41 28.68,161.65 29.93,160.4 29.93,150.69 29.63,150.4 29.63,126.14 26.33,122.84 26.33,114.7 26.78,114.25 26.78,111.78 25.44,110.44 23.82,110.44 23.82,110.44 23.21,110.44 21.3,108.53 21.3,107.48 19.81,105.99 14.01,105.99 12.46,104.45 12.46,104.28 12.46,79.97 9.1,76.61 9.1,72.86 8.81,72.57 8.81,68.44 9.61,67.64 13.04,67.64 13.62,67.05 19.31,67.05 19.61,67.36 25.21,67.36 27.65,64.91 27.65,63.24 26.64,62.22 26.64,62.05 26.64,60.13 27.43,59.34 27.43,58.57 v1(27.25,58.39)
  BOTTOM w0.102: v1(70.81,156.16) 70.26,155.6 C2579.1 B16.2
DMIC_DATA: length 3
  BOTTOM w0.102: B15.1 72.84,156.8 D44.2 72.91,157.31 v3(72.62,157.61) 72.8,157.79 CNEDP1.33
DMIC_DATA_L: length 203.4
  TOP w0.102: U7.2 27.51,57.97 v1(27.89,58.35)
  L8_IN3 w0.089: v1(70.05,156.16) 70.05,156.64 69.58,157.11 69.58,159.08 69.64,159.14 69.64,161.43 68.82,162.26 62.14,162.26 58.54,158.65 54.47,158.65 53.83,158.01 46.39,158.01 45.11,159.29 45.11,162.55 47.27,164.71 47.27,167.6 46.26,168.61 34.17,168.61 28.89,163.32 28.89,161.73 30.13,160.49 30.13,150.6 29.84,150.31 29.84,126.05 26.54,122.75 26.54,114.78 26.98,114.34 26.98,111.7 25.52,110.23 23.29,110.23 21.51,108.45 21.51,107.4 19.9,105.79 14.09,105.79 12.67,104.37 12.67,79.89 9.3,76.52 9.3,72.78 9.01,72.49 9.01,68.61 9.78,67.84 13.12,67.84 13.7,67.26 19.23,67.26 19.53,67.56 25.29,67.56 27.86,65 27.86,63.15 26.84,62.14 26.84,60.22 27.63,59.42 27.63,58.6 v1(27.89,58.35)
  BOTTOM w0.102: v1(70.05,156.16) 70.26,156.37 C2578.1 B15.2
