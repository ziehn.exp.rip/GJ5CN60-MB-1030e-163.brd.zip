# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ34: length 29.6
  TOP w0.076: U26.AA4 135.58,105.94 v1(135.24,105.69)
  TOP w0.102: v1(132.68,87.57) 132.68,88.4 132.64,88.44 CN1.187
  L8_IN3 w0.076: v1(135.24,105.69) 136.1,104.83 136.1,99.84 133.31,97.05 133.31,96.95
  L8_IN3 w0.089: v1(132.68,87.57) 132.68,87.28 132.48,87.07 132.39,87.07 132.19,87.27 132.19,87.67 132.36,87.84 132.36,87.96 132.19,88.13 132.19,88.47 131.49,89.17 131.49,90.78 131.58,90.87 131.91,90.87 132,90.96 132,91.14 131.91,91.22 131.58,91.22 131.49,91.31 131.49,91.49 131.58,91.58 131.91,91.58 132,91.67 132,91.85 131.91,91.94 131.58,91.94 131.49,92.02 131.49,92.2 131.58,92.29 131.94,92.29 132.01,92.36 132.01,92.57 131.94,92.65 131.55,92.65 131.49,92.71 131.49,92.94 131.55,93 131.94,93 132.01,93.07 132.01,93.29 131.94,93.36 131.56,93.36 131.49,93.43 131.49,93.64 131.56,93.71 131.94,93.71 132.01,93.79 132.01,94 131.94,94.07 131.56,94.07 131.49,94.14 131.49,94.35 131.56,94.42 131.95,94.42 132.01,94.48 132.01,94.73 131.95,94.78 131.58,94.78 131.49,94.87 131.49,95.01 131.63,95.15 131.83,95.15 131.94,95.26 131.94,95.46 133.31,96.83 133.31,96.95
M_A_DQ35: length 30.1
  TOP w0.076: U26.AA5 135.58,106.59 v1(135.24,106.34)
  TOP w0.102: v1(133.64,87.13) CN1.183
  L8_IN3 w0.076: v1(135.24,106.34) 136.25,106.34 136.39,106.2 136.39,99.9 133.75,97.25 133.75,96.95
  L8_IN3 w0.089: v1(133.64,87.13) 133.64,86.98 133.56,86.89 133.33,86.89 133.24,86.8 133.24,86.57 133.13,86.46 133.01,86.46 132.7,86.76 132.7,86.89 133.41,87.59 133.41,87.72 133.32,87.8 133.18,87.8 133.09,87.89 133.09,88.03 133,88.12 132.88,88.12 132.8,88.05 132.68,88.05 132.55,88.18 132.55,88.3 132.62,88.37 132.62,88.5 132.14,88.98 132.14,89.1 132.3,89.26 132.3,89.34 132.21,89.43 131.84,89.43 131.78,89.49 131.78,89.73 131.84,89.79 132.25,89.79 132.3,89.84 132.3,90.09 132.25,90.14 131.84,90.14 131.78,90.2 131.78,90.44 131.84,90.5 132.21,90.5 132.29,90.59 132.29,91.26 132.21,91.34 132.21,91.47 132.29,91.55 132.29,91.97 132.22,92.04 132.22,92.16 132.3,92.24 132.3,92.7 132.23,92.77 132.23,92.88 132.3,92.95 132.3,93.41 132.23,93.48 132.23,93.59 132.3,93.66 132.3,94.12 132.23,94.19 132.23,94.29 132.3,94.36 132.3,94.85 132.17,94.98 132.17,95.08 132.23,95.14 132.23,95.34 133.75,96.86 133.75,96.95
M_A_DQ36: length 30.6
  TOP w0.076: v1(137.31,102.88) 136.92,103.28 136.92,103.7 137.03,103.81 137.03,106.06 U26.AB5
  TOP w0.102: v1(135.87,85.7) 135.9,85.7 137.4,87.2 137.4,88.14 137.15,88.4 CN1.169
  L8_IN3 w0.076: v1(137.31,102.88) 137.92,102.27 137.92,97.84 137.57,97.48
  L8_IN3 w0.089: v1(135.87,85.7) 136.04,85.54 136.07,85.54 136.15,85.46 136.28,85.46 136.37,85.55 136.37,85.82 136.23,85.96 136.23,86.05 136.37,86.18 136.37,86.53 136.07,86.83 135.81,86.83 135.72,86.92 135.72,87.09 135.94,87.32 135.94,87.42 135.86,87.5 135.76,87.5 135.69,87.58 135.69,87.79 135.76,87.86 135.86,87.86 135.94,87.95 135.94,88.07 134.33,89.69 134.33,94.25 134.48,94.39 134.48,94.61 134.62,94.75 134.84,94.75 134.98,94.89 134.98,95.12 135.12,95.26 135.34,95.26 135.49,95.4 135.49,95.62 135.63,95.76 135.85,95.76 135.99,95.9 135.99,96.12 136.13,96.26 136.35,96.26 136.49,96.4 136.49,96.62 136.63,96.76 136.85,96.76 137.57,97.48
M_A_DQ37: length 30.2
  TOP w0.076: v1(137.31,102.25) 136.75,102.81 136.75,103.77 136.86,103.88 136.86,105.57 U26.AB4
  TOP w0.102: v1(135.88,85.06) 135.83,85.06 135.39,85.51 135.39,86.91 136.15,87.66 CN1.173
  L8_IN3 w0.076: 136.91,97.48 137.65,98.22 137.65,101.91 v1(137.31,102.25)
  L8_IN3 w0.089: v1(135.88,85.06) 136.14,85.06 136.23,84.97 136.23,84.73 136.1,84.6 135.64,84.6 135.39,84.85 135.39,87.73 135.4,87.97 135.4,88.21 134.04,89.56 134.04,94.61 136.91,97.48
M_A_DQ38: length 28.4
  TOP w0.076: v1(135.24,104.4) U26.AA2
  TOP w0.102: CN1.186 132.9,82.34 133.01,82.46 133.01,83.15 133.41,83.54 v1(133.64,83.54)
  L8_IN3 w0.076: 133.02,96.95 133.11,97.05 133.11,97.09 135.94,99.92 135.94,103.71 v1(135.24,104.4)
  L8_IN3 w0.089: 133.02,96.95 131.2,95.13 131.2,89.05 131.9,88.35 131.9,87.15 132.86,86.19 132.86,85.98 132.95,85.89 133.07,85.89 133.16,85.8 133.16,85.62 133.07,85.53 132.93,85.53 132.86,85.46 132.86,85.25 132.93,85.18 133.13,85.18 133.21,85.09 133.21,84.91 133.13,84.82 133.04,84.82 132.88,84.66 132.88,84.52 133.11,84.29 133.11,84.08 v1(133.64,83.54)
M_A_DQ39: length 27.5
  TOP w0.076: v1(135.24,103.77) 135.58,104 U26.AA1
  TOP w0.102: v1(133.63,82.92) 134.06,82.5 134.06,82.17 133.9,82 CN1.182
  L8_IN3 w0.076: 132.61,96.95 132.78,97.13 132.92,97.13 135.77,99.99 135.77,103.24 v1(135.24,103.77)
  L8_IN3 w0.089: 132.61,96.95 130.9,95.25 130.9,88.93 131.61,88.22 131.61,87.03 132.57,86.07 132.57,84.4 132.82,84.16 132.82,83.91 132.82,83.19 132.84,83.17 132.84,82.85 132.95,82.74 133.19,82.74 133.36,82.92 v1(133.63,82.92)
M_A_DQ40: length 33.7
  TOP w0.076: U26.V5 133.91,106.93 133.99,107.02 134.27,107.02 134.52,106.77 134.52,102.05 134.65,101.91 134.76,101.91 135.24,102.39 v1(135.24,102.5)
  TOP w0.102: v1(131.12,87.49) 130.7,87.49 130.58,87.37 130.58,85.88 130.45,85.75 130.05,85.75 129.94,85.87 129.94,87.6 130.64,88.3 CN1.195
  L8_IN3 w0.076: v1(135.24,102.5) 135.24,102.67 135.34,102.77 135.5,102.77 135.61,102.66 135.61,101.13 135.23,100.75 135.23,100.56 135.61,100.18 135.61,100.06 132.85,97.3 132.25,97.3 131.91,96.95
  L8_IN3 w0.089: v1(131.12,87.49) 130.96,87.49 130.81,87.35 130.81,87.31 130.63,87.14 130.5,87.14 130.41,87.23 130.41,87.74 130.5,87.83 130.65,87.83 130.74,87.92 130.74,88.09 130.65,88.18 130.5,88.18 130.41,88.27 130.41,88.35 130.55,88.49 130.55,88.58 130.41,88.72 130.41,95.46 131.91,96.95
M_A_DQ41: length 30.9
  TOP w0.076: U26.V2 134.19,104.44 134.19,101.08 134.43,100.84 v1(134.66,100.84)
  TOP w0.102: CN1.190 131.9,82.57 v1(132.35,83.03)
  L8_IN3 w0.076: 131.08,96.95 131.75,97.63 132.71,97.63 134.07,98.99 134.07,99.59 134.34,99.86 134.95,99.86 135.1,100.01 135.1,100.13 134.86,100.36 134.86,100.64 v1(134.66,100.84)
  L8_IN3 w0.089: v1(132.35,83.03) 132.01,82.69 131.86,82.69 131.77,82.78 131.77,83.05 132.09,83.37 132.09,83.49 131.88,83.71 131.88,83.83 132.1,84.05 132.1,84.23 131.94,84.39 131.94,84.57 132.08,84.71 132.08,84.93 131.94,85.06 131.94,85.28 132.08,85.42 132.08,85.64 131.94,85.78 131.94,85.99 131.77,86.16 131.77,86.17 131.49,86.44 130.89,86.44 130.71,86.26 130.47,86.26 129.82,86.91 129.82,95.7 131.08,96.95
M_A_DQ42: length 30
  TOP w0.076: U26.U1 v1(132.72,103.78)
  TOP w0.102: CN1.208 127.39,83.35 128.5,84.46 v1(128.89,84.46)
  L8_IN3 w0.076: v1(132.72,103.78) 133.1,103.41 133.1,101.17 130.15,98.22 129.46,98.22 129,97.77 128.35,97.77 128.07,97.48
  L8_IN3 w0.089: 128.07,97.48 127.05,96.47 127.05,85.47 127.18,85.34 127.54,85.34 127.63,85.24 127.63,84.89 127.76,84.76 128.12,84.76 128.32,84.56 128.32,84.49 128.08,84.25 128.08,84.06 128.19,83.95 128.38,83.95 v1(128.89,84.46)
M_A_DQ43: length 30.4
  TOP w0.076: U26.U2 v1(132.72,104.42)
  TOP w0.102: v1(128.89,83.11) 128.73,83.11 128.39,82.78 CN1.204
  L8_IN3 w0.076: v1(132.72,104.42) 133.26,103.88 133.26,101.1 130.22,98.06 129.55,98.06 129.08,97.59 128.59,97.59 128.48,97.48
  L8_IN3 w0.089: 128.48,97.48 127.34,96.35 127.34,85.95 128.37,84.92 128.68,84.92 129.04,85.28 129.4,85.28 129.79,84.9 129.79,83.38 129.53,83.11 v1(128.89,83.11)
M_A_DQ44: length 30.2
  TOP w0.076: v1(134.2,100.51) 133.91,100.8 U26.V1
  TOP w0.102: v1(131.1,83.04) 131.1,82.96 130.9,82.75 CN1.194
  L8_IN3 w0.076: 130.67,96.95 131.5,97.79 132.64,97.79 133.9,99.05 133.9,99.66 134.2,99.96 v1(134.2,100.51)
  L8_IN3 w0.089: 130.67,96.95 129.53,95.82 129.53,86.79 130.35,85.97 130.83,85.97 131.01,86.15 131.37,86.15 131.65,85.87 131.65,84.02 131.5,83.88 131.5,83.48 131.48,83.46 131.48,82.5 131.39,82.41 130.67,82.41 130.51,82.57 130.51,82.95 130.6,83.04 v1(131.1,83.04)
M_A_DQ45: length 32.8
  TOP w0.076: U26.V4 133.91,106.3 134,106.4 134.27,106.4 134.35,106.32 134.35,101.52 134.43,101.44 134.65,101.44 135.07,101.86 v1(135.24,101.86)
  TOP w0.102: CN1.191 131.64,88.4 131.84,88.21 131.84,87.98 131.69,87.82 131.69,87.61 131.84,87.45 131.84,86.97 132.68,86.13 132.68,85.99 132.48,85.79 132.26,85.79 131.66,86.39 131.51,86.39 131.28,86.16 131,86.16 130.9,86.26 130.9,86.72 v1(131.11,86.93)
  L8_IN3 w0.076: 131.49,96.95 132,97.46 132.78,97.46 135.33,100.01 135.33,100.15 135.03,100.45 135.03,100.78 135.44,101.19 135.44,101.79 135.37,101.86 v1(135.24,101.86)
  L8_IN3 w0.089: v1(131.11,86.93) 130.96,86.93 130.65,86.61 130.53,86.61 130.12,87.03 130.12,95.58 131.49,96.95
M_A_DQ46: length 32.6
  TOP w0.076: v1(132.72,106.34) U26.U5
  TOP w0.102: v1(128.35,87.41) 127.88,87.41 127.77,87.3 127.77,86.45 127.71,86.39 127.37,86.39 127.23,86.53 127.23,87.9 127.64,88.31 CN1.207
  L8_IN3 w0.076: 129.04,96.97 129.75,97.69 130.4,97.69 134.08,101.37 134.08,104.98 v1(132.72,106.34)
  L8_IN3 w0.089: 129.04,96.97 128.35,96.29 128.35,92.9 128.27,92.81 128,92.81 127.93,92.73 127.93,92.53 128,92.45 128.29,92.45 128.35,92.39 128.35,92.12 128.29,92.06 128,92.06 127.93,91.99 127.93,91.77 128,91.7 128.28,91.7 128.35,91.63 128.35,91.42 128.28,91.35 128,91.35 127.93,91.27 127.93,91.06 128,90.99 128.29,90.99 128.35,90.93 128.35,90.7 128.29,90.63 128,90.63 127.93,90.56 127.93,90.35 128,90.28 128.28,90.28 128.35,90.21 128.35,89.99 128.28,89.92 128,89.92 127.93,89.85 127.93,89.64 128,89.57 128.28,89.57 128.35,89.5 128.35,89.28 128.28,89.21 128,89.21 127.93,89.14 127.93,88.93 128,88.86 128.29,88.86 128.35,88.79 128.35,88.52 128.29,88.45 128.02,88.45 127.93,88.36 127.93,87.57 128.09,87.41 v1(128.35,87.41)
M_A_DQ47: length 31.5
  TOP w0.076: v1(132.72,105.69) U26.U4
  TOP w0.102: CN1.203 128.64,88.41 128.83,88.22 128.83,87.21 128.45,86.82 v1(128.37,86.82)
  L8_IN3 w0.076: v1(132.72,105.69) 133.14,105.69 133.92,104.91 133.92,101.44 130.37,97.89 129.63,97.89 129.13,97.39 128.83,97.39
  L8_IN3 w0.089: 128.83,97.39 128.8,97.39 128.63,97.22 128.63,96.98 128.45,96.8 128.21,96.8 127.97,96.56 127.97,96.44 128.06,96.35 128.06,96.26 127.97,96.17 127.69,96.17 127.64,96.12 127.64,95.83 127.71,95.75 128,95.75 128.06,95.69 128.06,95.46 128,95.39 127.7,95.39 127.64,95.33 127.64,95.1 127.7,95.04 127.99,95.04 128.06,94.97 128.06,94.75 127.99,94.68 127.69,94.68 127.64,94.63 127.64,94.38 127.69,94.33 127.99,94.33 128.06,94.26 128.06,94.04 127.99,93.97 127.69,93.97 127.64,93.91 127.64,93.67 127.69,93.62 128,93.62 128.06,93.55 128.06,93.32 128,93.26 127.72,93.26 127.64,93.17 127.64,92.41 127.71,92.33 127.71,92.18 127.64,92.11 127.64,91.65 127.71,91.58 127.71,91.47 127.64,91.39 127.64,90.94 127.71,90.87 127.71,90.76 127.64,90.68 127.64,90.23 127.71,90.16 127.71,90.04 127.64,89.97 127.64,89.52 127.71,89.45 127.71,89.33 127.64,89.26 127.64,88.81 127.74,88.71 127.74,88.58 127.64,88.48 127.64,87.45 127.85,87.23 127.85,87.11 127.64,86.89 127.64,86.34 127.71,86.27 127.84,86.27 128.05,86.48 128.05,86.73 128.14,86.82 v1(128.37,86.82)
M_A_DQ48: length 31.8
  TOP w0.076: v1(131.92,101.68) 131.67,101.92 131.67,104.44 U26.R2
  TOP w0.102: v1(125.94,83.02) 126.39,82.57 CN1.212
  L8_IN3 w0.076: 126.19,97.48 127.02,98.31 128.79,98.31 129.24,98.76 129.98,98.76 131.92,100.69 v1(131.92,101.68)
  L8_IN3 w0.089: 126.19,97.48 125.97,97.27 125.97,94.26 124.88,93.17 124.88,87.47 125.12,87.24 125.12,85.35 125.58,84.89 126.87,84.89 126.96,84.8 126.96,84.62 126.87,84.53 126.52,84.53 126.43,84.45 126.43,84.27 126.52,84.18 126.92,84.18 127.01,84.09 127.01,83.91 126.92,83.82 126.52,83.82 126.43,83.73 126.43,83.11 126.34,83.02 v1(125.94,83.02)
M_A_DQ49: length 32.3
  TOP w0.076: v1(130.21,106.34) U26.P5
  TOP w0.102: v1(122.67,86.8) 122.57,86.8 122.15,87.22 CN1.229
  L8_IN3 w0.076: 124.52,95.71 124.52,95.88 124.84,96.19 124.84,97.63 126.88,99.68 128.4,99.68 130.97,102.25 130.97,105.57 v1(130.21,106.34)
  L8_IN3 w0.089: 124.52,95.71 124.52,94.86 123.43,93.77 123.43,93.22 123.43,87.7 123.18,87.45 123.18,85.99 123.27,85.91 123.9,85.91 124.12,85.68 124.12,85.44 123.96,85.28 122.99,85.28 122.67,85.59 v1(122.67,86.8)
M_A_DQ50: length 33.5
  TOP w0.076: v1(132.35,102.08) 131.84,102.59 131.84,105.57 U26.R4
  TOP w0.102: v1(125.97,86.92) 125.86,86.92 125.51,87.27 125.51,88.25 125.64,88.39 CN1.215
  L8_IN3 w0.076: v1(132.35,102.08) 132.35,100.89 130.04,98.58 129.33,98.58 128.88,98.13 127.31,98.13 126.66,97.48
  L8_IN3 w0.089: v1(125.97,86.92) 126.44,86.92 126.56,86.81 126.56,85.52 126.4,85.36 125.52,85.36 125.41,85.47 125.41,87.36 125.17,87.59 125.17,87.67 125.26,87.76 125.49,87.76 125.58,87.85 125.58,88.03 125.49,88.12 125.26,88.12 125.17,88.21 125.17,90.28 125.34,90.44 125.34,90.65 125.17,90.82 125.17,90.92 125.26,91.01 125.47,91.01 125.56,91.09 125.56,91.27 125.47,91.36 125.26,91.36 125.17,91.45 125.17,91.63 125.26,91.72 125.4,91.72 125.48,91.8 125.48,91.99 125.4,92.07 125.26,92.07 125.17,92.16 125.17,92.34 125.26,92.43 125.39,92.43 125.47,92.51 125.47,92.7 125.39,92.78 125.26,92.78 125.17,92.87 125.17,93.05 125.36,93.24 125.67,93.24 125.76,93.34 125.76,93.64 126.26,94.14 126.26,97.08 126.66,97.48
M_A_DQ51: length 32.4
  TOP w0.076: v1(130.21,105.69) U26.P4
  TOP w0.102: v1(122.64,87.43) 123.15,87.93 CN1.225
  L8_IN3 w0.076: 124.23,95.71 124.23,95.84 124.66,96.26 124.66,98.15 126.35,99.84 128.33,99.84 130.81,102.32 130.81,105.09 v1(130.21,105.69)
  L8_IN3 w0.089: v1(122.64,87.43) 123.14,87.93 123.14,88.67 123.05,88.76 122.4,88.76 122.31,88.85 122.31,89.02 122.4,89.11 123.05,89.11 123.14,89.2 123.14,89.38 123.05,89.47 122.4,89.47 122.31,89.56 122.31,89.73 122.4,89.82 123.05,89.82 123.14,89.91 123.14,90.89 123.05,90.98 122.41,90.98 122.32,91.07 122.32,91.24 122.41,91.33 123.05,91.33 123.14,91.42 123.14,91.6 123.05,91.69 122.41,91.69 122.32,91.78 122.32,91.95 122.41,92.04 123.05,92.04 123.14,92.13 123.14,92.44 123.05,92.53 122.68,92.53 122.59,92.61 122.59,92.79 122.68,92.88 123.05,92.88 123.14,92.97 123.14,93.9 124.23,94.99 124.23,95.71
M_A_DQ52: length 34
  TOP w0.076: v1(132.73,102.54) 132,103.27 132,106.06 U26.R5
  TOP w0.102: CN1.211 126.64,88.16 v1(126,87.51)
  L8_IN3 w0.076: 127.37,97.48 127.83,97.94 128.95,97.94 129.41,98.4 130.1,98.4 132.73,101.03 v1(132.73,102.54)
  L8_IN3 w0.089: 127.37,97.48 126.85,96.96 126.56,96.67 126.56,93.69 126.47,93.6 126.14,93.6 126.05,93.51 126.05,93.34 126.14,93.25 126.47,93.25 126.56,93.16 126.56,92.98 126.47,92.89 125.86,92.89 125.77,92.8 125.77,92.63 125.86,92.54 126.47,92.54 126.56,92.45 126.56,90.45 126.38,90.27 125.58,90.27 125.49,90.18 125.49,90 125.58,89.91 126.48,89.91 126.56,89.84 126.56,89.63 126.48,89.56 125.54,89.56 125.47,89.48 125.47,89.28 125.54,89.2 126.46,89.2 126.55,89.11 126.55,88.94 126.46,88.85 125.55,88.85 125.47,88.76 125.47,88.58 125.55,88.49 126.49,88.49 126.56,88.42 126.56,88.22 126.44,88.1 126.44,87.87 126.56,87.75 126.56,87.58 126.49,87.51 v1(126,87.51)
M_A_DQ53: length 30.5
  TOP w0.076: v1(130.21,104.39) U26.P2
  TOP w0.102: v1(122.9,82.99) 123.2,82.99 123.39,82.79 CN1.224
  L8_IN3 w0.076: 123.94,95.71 123.94,95.82 124.13,96 124.14,96 124.49,96.36 124.49,98.21 126.29,100.01 126.42,100.01 126.42,100.01 128.26,100.01 130.64,102.39 130.64,103.95 v1(130.21,104.39)
  L8_IN3 w0.089: v1(122.9,82.99) 123.06,82.99 123.48,83.4 123.48,84.38 122.21,85.65 122.21,86.59 122.17,86.63 122.17,88.49 122.01,88.65 122.01,90.04 122.1,90.13 122.25,90.13 122.34,90.22 122.34,90.39 122.24,90.49 122.1,90.49 122.01,90.58 122.01,92.06 122.3,92.35 122.3,93.47 123.94,95.11 123.94,95.71
M_A_DQ54: length 32.1
  TOP w0.076: v1(131.46,101.32) 131.39,101.39 U26.R1
  TOP w0.102: v1(125.94,83.73) 125.39,83.18 CN1.216
  L8_IN3 w0.076: v1(131.46,101.32) 131.46,100.47 129.92,98.92 129.17,98.92 128.72,98.48 126.67,98.48 125.68,97.49 125.68,97.48
  L8_IN3 w0.089: 125.68,97.48 125.68,94.38 124.59,93.3 124.59,87.35 124.82,87.11 124.82,85.23 125.16,84.9 125.16,84.77 124.35,83.97 124.35,83.84 124.48,83.71 124.6,83.71 125.31,84.42 125.44,84.42 125.55,84.3 125.55,84.16 124.94,83.55 124.94,83.43 125.07,83.3 125.2,83.3 125.62,83.73 v1(125.94,83.73)
M_A_DQ55: length 31.3
  TOP w0.076: v1(130.21,103.75) U26.P1
  TOP w0.102: v1(122.9,83.62) 122.64,83.62 122.39,83.37 CN1.228
  L8_IN3 w0.076: 123.65,95.71 123.65,95.76 124.29,96.4 124.29,98.24 126.23,100.18 128.18,100.18 130.33,102.33 130.33,103.63 v1(130.21,103.75)
  L8_IN3 w0.089: 123.65,95.71 123.65,95.23 123.25,94.83 123.12,94.83 122.92,95.04 122.79,95.04 122.66,94.91 122.66,94.79 122.87,94.58 122.87,94.45 122.75,94.33 122.62,94.33 122.42,94.52 122.3,94.52 122.17,94.4 122.17,94.27 122.37,94.07 122.37,93.95 122.01,93.59 122.01,92.47 121.72,92.18 121.72,90.3 121.63,90.21 121.44,90.21 121.35,90.12 121.35,89.94 121.44,89.85 121.63,89.85 121.72,89.76 121.72,89.58 121.63,89.5 121.44,89.5 121.35,89.41 121.35,89.23 121.44,89.14 121.63,89.14 121.72,89.05 121.72,88.53 121.87,88.37 121.87,86.45 121.92,86.41 121.92,85.48 122.9,84.5 v1(122.9,83.62)
M_A_DQ56: length 37.9
  TOP w0.076: U26.M4 129.2,105.7 129.2,104.88 129.32,104.76 129.32,103.07 129.15,102.9 v1(129.15,102.31)
  TOP w0.102: v1(121.05,82.45) 121.39,82.1 CN1.232
  L8_IN3 w0.076: 120.51,100.39 120.63,100.39 120.76,100.51 128.04,100.51 129.15,101.62 v1(129.15,102.31)
  L8_IN3 w0.089: 120.51,100.39 120.17,100.39 118.66,98.87 118.66,96.43 120.54,94.54 120.54,94.07 120.45,93.98 120.24,93.98 120.15,93.9 120.15,93.72 120.24,93.63 120.45,93.63 120.54,93.54 120.54,93.36 120.45,93.27 120.24,93.27 120.15,93.18 120.15,93.01 120.24,92.92 120.45,92.92 120.54,92.83 120.54,92.65 120.45,92.56 120.24,92.56 120.15,92.47 120.15,92.29 120.24,92.21 120.45,92.21 120.54,92.12 120.54,91.81 120.27,91.54 120.27,91.35 120.54,91.08 120.54,90.78 120.32,90.56 120.32,90.37 120.54,90.15 120.54,88.42 120.93,88.02 120.93,86.28 121.13,86.08 121.13,84.63 120.53,84.04 120.53,82.88 120.96,82.45 v1(121.05,82.45)
M_A_DQ57: length 34.4
  TOP w0.076: v1(128.23,101.47) 128,101.47 127.88,101.6 127.88,102.31 128.88,103.31 U26.M1
  TOP w0.102: CN1.237 120.15,88.26 119.95,88.06 119.95,87.61 v1(120.4,87.16)
  L8_IN3 w0.076: 120.57,100.97 127.02,100.97 127.52,101.47 v1(128.23,101.47)
  L8_IN3 w0.089: v1(120.4,87.16) 119.81,87.75 119.81,89.67 119.52,89.96 119.52,90.9 118.96,91.46 118.96,93.85 118.12,94.69 118.12,95.24 118.03,95.33 117.69,95.33 117.6,95.42 117.6,95.6 117.69,95.69 118.2,95.69 118.29,95.78 118.29,95.95 118.2,96.04 117.69,96.04 117.6,96.13 117.6,96.31 117.69,96.4 117.9,96.4 117.98,96.49 117.98,96.67 117.9,96.75 117.69,96.75 117.6,96.84 117.6,97.02 117.69,97.11 117.91,97.11 118,97.2 118,97.38 117.91,97.47 117.69,97.47 117.6,97.55 117.6,97.73 117.69,97.82 117.93,97.82 118.02,97.91 118.02,98.09 117.93,98.18 117.69,98.18 117.6,98.27 117.6,98.44 117.69,98.53 117.93,98.53 118.02,98.62 118.02,98.8 117.93,98.89 117.69,98.89 117.6,98.98 117.6,99.15 117.69,99.24 117.85,99.24 117.93,99.33 117.93,99.66 119.25,100.97 120.57,100.97
M_A_DQ58: length 39.5
  TOP w0.076: v1(127.69,105.69) U26.L4
  TOP w0.102: CN1.246 117.9,82.43 v1(117.4,82.92)
  L8_IN3 w0.089: v1(127.69,105.69) 127.43,105.69 124.45,102.71 118.41,102.71 115.85,100.15 115.85,94.12 115.94,94.03 116.18,94.03 116.24,93.97 116.24,93.73 116.18,93.67 115.94,93.67 115.85,93.58 115.85,93.41 115.94,93.32 116.14,93.32 116.23,93.23 116.23,93.05 116.14,92.96 115.94,92.96 115.85,92.87 115.85,92.69 115.94,92.61 116.12,92.61 116.21,92.52 116.21,92.34 116.12,92.25 115.94,92.25 115.85,92.16 115.85,91.98 115.94,91.89 116.15,91.89 116.24,91.81 116.24,91.67 116.23,91.67 116.23,91.62 116.15,91.54 115.94,91.54 115.85,91.45 115.85,91.27 115.94,91.18 116.3,91.18 116.43,91.05 116.43,90.38 116.55,90.26 116.86,90.26 117.06,90.06 117.06,89.75 117.27,89.54 117.48,89.54 117.62,89.41 117.62,89.28 117.53,89.19 117.27,89.19 117.18,89.1 117.18,88.92 117.27,88.83 117.67,88.83 117.76,88.75 117.76,88.56 117.67,88.48 117.27,88.48 117.18,88.39 117.18,85.84 117.87,85.15 117.87,84.58 118.1,84.35 118.1,83.48 117.54,82.92 v1(117.4,82.92)
M_A_DQ59: length 36
  TOP w0.076: v1(127.69,104.39) U26.L2
  TOP w0.102: CN1.245 118.15,87.89 v1(117.69,87.43)
  L8_IN3 w0.089: v1(117.69,87.43) 117.82,87.3 118.28,87.3 118.36,87.39 118.36,87.79 118.28,87.88 118.14,87.88 118.05,87.97 118.05,88.14 118.14,88.23 118.28,88.23 118.36,88.32 118.36,88.5 118.28,88.59 118.14,88.59 118.05,88.68 118.05,88.82 118.23,89 118.23,89.21 117.38,90.05 117.38,91.19 117.29,91.28 116.61,91.28 116.52,91.37 116.52,91.55 116.61,91.64 117.33,91.64 117.38,91.69 117.38,91.94 117.33,91.99 116.58,91.99 116.49,92.08 116.49,92.26 116.58,92.35 117.32,92.35 117.38,92.41 117.38,92.64 117.32,92.7 116.61,92.7 116.52,92.79 116.52,92.97 116.61,93.06 117.29,93.06 117.38,93.15 117.38,93.33 117.23,93.48 116.63,93.48 116.53,93.58 116.53,94.18 116.14,94.57 116.14,100.03 118.53,102.42 124.66,102.42 126.62,104.39 v1(127.69,104.39)
M_A_DQ60: length 40.7
  TOP w0.076: v1(129.55,102.74) 129.55,102.92 129.49,102.99 129.49,104.82 129.42,104.89 129.42,106.12 U26.M5
  TOP w0.102: CN1.236 120.39,82.65 120.83,83.08 v1(121,83.08)
  L8_IN3 w0.076: v1(129.55,102.74) 129.55,101.79 128.11,100.35 120.89,100.35 120.74,100.21 120.62,100.21 120.51,100.1
  L8_IN3 w0.089: v1(121,83.08) 121.42,83.49 121.42,86.2 121.23,86.4 121.23,86.69 121.38,86.85 121.38,87.27 121.23,87.43 121.23,87.67 121.38,87.83 121.38,88.17 120.83,88.71 120.83,91.56 121.13,91.85 121.13,91.98 120.83,92.27 120.83,92.36 120.92,92.45 121.29,92.45 121.41,92.57 121.41,92.72 121.32,92.81 120.92,92.81 120.83,92.9 120.83,93.07 120.92,93.16 121.43,93.16 121.51,93.24 121.51,93.44 121.43,93.52 120.92,93.52 120.83,93.61 120.83,93.78 120.92,93.87 121.58,93.87 121.67,93.96 121.67,94.14 121.58,94.23 120.92,94.23 120.83,94.32 120.83,94.52 121.04,94.73 121.04,94.86 120.89,95.01 120.48,95.01 118.95,96.55 118.95,98.75 120.29,100.1 120.51,100.1
M_A_DQ61: length 35.7
  TOP w0.076: v1(128.69,101.88) 128.46,102.11 128.46,102.54 129.16,103.23 129.16,104.44 U26.M2
  TOP w0.102: CN1.233 121.12,89.27 121.12,88.48 120.45,87.81 v1(120.44,87.81)
  L8_IN3 w0.076: v1(128.69,101.88) 128.69,101.39 127.97,100.68 120.57,100.68
  L8_IN3 w0.089: v1(120.44,87.81) 120.11,88.14 120.11,89.81 119.82,90.1 119.82,91.02 119.55,91.29 119.55,91.42 119.82,91.68 119.82,91.87 119.73,91.96 119.37,91.96 119.29,92.05 119.29,92.22 119.37,92.31 119.73,92.31 119.82,92.4 119.82,92.58 119.73,92.67 119.39,92.67 119.3,92.76 119.3,92.94 119.39,93.02 119.76,93.02 119.82,93.08 119.82,93.32 119.76,93.38 119.34,93.38 119.25,93.47 119.25,93.65 119.34,93.74 119.73,93.74 119.82,93.82 119.82,94.17 119.5,94.48 119.38,94.48 119.16,94.27 119.04,94.27 118.91,94.39 118.91,94.52 119.13,94.73 119.13,94.86 119,94.98 118.87,94.98 118.66,94.77 118.53,94.77 118.41,94.9 118.41,95.02 118.92,95.54 118.92,95.74 118.36,96.31 118.36,99 118.44,99.07 118.44,99.2 118.24,99.4 118.24,99.52 118.36,99.65 118.49,99.65 118.69,99.45 118.81,99.45 118.94,99.57 118.94,99.7 118.74,99.9 118.74,100.02 118.87,100.15 118.99,100.15 119.19,99.95 119.32,99.95 119.44,100.08 119.44,100.2 119.24,100.4 119.24,100.53 119.37,100.65 119.49,100.65 119.69,100.45 119.82,100.45 120.05,100.68 120.57,100.68
M_A_DQ62: length 40.1
  TOP w0.076: v1(127.69,106.34) U26.L5
  TOP w0.102: CN1.250 116.9,83.16 117.27,83.53 v1(117.44,83.53)
  L8_IN3 w0.089: v1(117.44,83.53) 117.04,83.53 116.89,83.68 116.89,84.27 116.98,84.36 117.15,84.36 117.27,84.48 117.27,84.63 117.18,84.72 116.98,84.72 116.89,84.81 116.89,84.98 116.98,85.07 117.21,85.07 117.3,85.16 117.3,85.3 117.18,85.43 116.98,85.43 116.89,85.52 116.89,89.51 115.56,90.84 115.56,100.27 118.29,103.01 124.02,103.01 124.25,103.23 124.25,103.36 123.75,103.86 123.75,103.99 123.87,104.11 124,104.11 124.5,103.61 124.62,103.61 124.75,103.74 124.75,103.86 124.21,104.4 124.21,104.52 124.34,104.65 124.47,104.65 125,104.11 125.13,104.11 127.35,106.34 v1(127.69,106.34)
M_A_DQ63: length 36.5
  TOP w0.076: U26.L1 128.03,104.06 v1(127.72,103.76)
  TOP w0.102: CN1.249 117.15,87.25 117.57,86.82 v1(117.69,86.82)
  L8_IN3 w0.089: v1(127.72,103.76) 126.34,103.76 124.71,102.13 118.66,102.13 116.44,99.91 116.44,94.69 117.68,93.45 117.68,90.18 118.66,89.2 118.66,86.99 118.95,86.7 119.08,86.7 119.15,86.62 119.15,86.41 119.08,86.34 118.95,86.34 118.86,86.25 118.86,86.07 118.95,85.99 119.09,85.99 119.15,85.93 119.15,85.69 119.09,85.63 118.95,85.63 118.86,85.54 118.86,84.72 118.74,84.6 118.29,84.6 118.16,84.72 118.16,86.65 117.99,86.82 v1(117.69,86.82)
M_A_DQS0: length 39.4
  TOP w0.076: v1(163.95,105.25) 163.91,105.29 163.91,106.01 163.34,106.58 162.05,106.58 161.82,106.8 161.39,106.8 161.02,106.44 U26.BP5
  TOP w0.114: CN1.13 178.14,88.28 178.34,88.09 178.34,85.69 177.67,85.03 177.28,85.03 176.88,85.43 v1(176.88,85.58)
  L8_IN3 w0.076: v1(176.88,85.58) 176.73,85.58 176.59,85.44 176.59,85.28 176.66,85.2 177.3,85.2 177.84,85.74 177.84,88.63 177.56,88.91 177.56,94.51 167.98,104.08 165.51,104.08 164.77,104.83 164.77,104.96 164.18,105.54 164,105.54 163.88,105.42 163.88,105.31 v1(163.95,105.25)
M_A_DQS1: length 37.1
  TOP w0.076: 159,102.66 158.98,102.68 158.98,102.77 158.24,103.52 158.24,104.29 158.54,104.6 158.54,104.83 158.41,104.96 158.41,105.22 U26.BK3
  TOP w0.114: 159,102.66 160.79,100.88 v1(161.51,100.88) ; CN1.34 172.9,82.12 173.09,82.31 173.09,84.64 172.44,85.29 172.21,85.29 171.72,84.8 v1(171.66,84.8)
  L8_IN3 w0.076: v1(161.51,100.88) 161.88,101.25 162.12,101.25 163.26,100.11 166.87,100.11 171.7,95.29 171.7,90.81 172.65,89.86 172.65,87.6 172.01,86.96 171.5,86.96 171.02,86.48 171.02,85.4 171.3,85.13 171.54,85.13 171.66,85.01 v1(171.66,84.8)
M_A_DQS2: length 32.9
  TOP w0.076: U26.BF3 155.97,105.2 155.97,104.95 156.08,104.83 156.08,103.87 155.94,103.73 155.94,102.78 157.06,101.65 157.06,101.21 157,101.14 157,101.13
  TOP w0.114: v1(167.12,87.31) 167.12,87.2 167.32,87 167.43,87 167.62,86.82 167.67,86.82 167.84,86.98 167.84,88.09 167.65,88.28 CN1.55 ; v1(158.61,99.42) 158.52,99.51 158.36,99.51 158.27,99.6 157.67,99.6 157,100.27 157,101.13
  L8_IN3 w0.076: v1(158.61,99.42) 158.61,99.52 158.92,99.83 158.98,99.83 159.1,99.71 159.1,98.86 160.29,97.67 160.29,97.54 160.28,97.53 160.28,97.35 160.98,96.66 163.8,96.66 167.64,92.81 167.64,92.18 167.58,92.11 167.58,91.71 167.64,91.64 167.64,91.29 167.41,91.05 167.41,90.79 167.64,90.55 167.64,90.15 167.57,90.07 167.23,90.07 167.05,89.89 167.05,89.59 167.23,89.41 167.57,89.41 167.64,89.33 167.64,89.18 167.57,89.11 167.22,89.11 167.04,88.92 167.04,88.63 167.22,88.44 167.57,88.44 167.64,88.37 167.64,87.79 167.55,87.69 167.55,87.44 167.64,87.35 167.64,87.06 167.57,86.98 167.13,86.98 167.06,87.06 167.06,87.24 v1(167.12,87.31)
M_A_DQS3: length 31.8
  TOP w0.076: U26.BC3 153.57,105.08 153.57,102.01 153.5,101.94 153.5,101.92
  TOP w0.114: 153.5,101.92 153.5,100.64 154.25,99.9 v1(155.16,99.9) ; CN1.76 162.39,83.95 162.82,84.37 163.15,84.37 v1(163.35,84.57)
  L8_IN3 w0.076: v1(155.16,99.9) 155.16,100.03 155.03,100.15 154.83,100.15 154.74,100.06 154.74,99.44 155.75,98.43 155.75,97.51 155.77,97.5 155.77,97.29 159.69,93.36 159.8,93.36 162.6,90.57 162.6,84.51 162.97,84.14 163.34,84.14 163.45,84.24 163.45,84.47 v1(163.35,84.57)
M_A_DQS4: length 29.2
  TOP w0.076: v1(136.77,99.4) 136.54,99.17 136.39,99.17 136.13,99.44 136.13,104.9 136.02,105.01 136.02,105.26 136.13,105.37 U26.AB3
  TOP w0.114: v1(133.65,85.9) 133.65,85.56 133.72,85.49 134.06,85.49 134.26,85.69 134.26,86.94 134.84,87.52 134.84,88.09 134.64,88.28 CN1.179
  L8_IN3 w0.076: v1(133.65,85.9) 133.65,85.72 133.81,85.57 133.95,85.57 134.13,85.75 134.13,87.68 132.79,89.02 132.79,95.19 134.33,96.74 134.33,97.48 134.36,97.51 134.36,97.61 135.9,99.16 136.53,99.16 v1(136.77,99.4)
M_A_DQS5: length 31
  TOP w0.076: v1(133.39,99.64) 133.36,99.61 133.03,99.61 132.94,99.7 132.94,101.43 133.62,102.11 133.62,105.26 133.72,105.37 U26.V3
  TOP w0.114: v1(131.16,85.16) 130.47,85.16 129.8,84.49 129.8,83.31 129.39,82.91 CN1.200
  L8_IN3 w0.076: v1(133.39,99.64) 133.39,99.3 133.47,99.22 133.47,98.9 132.77,98.21 131.38,98.21 130.52,97.35 130.36,97.35 129.02,96.02 129.02,86.61 130.89,84.74 131.04,84.74 131.16,84.86 v1(131.16,85.16)
M_A_DQS6: length 33.4
  TOP w0.076: U26.R3 131.23,105.37 131.11,105.24 131.11,103.4 129.1,101.39 129.1,99.45 129.38,99.16 129.82,99.16 130.33,99.66 130.33,100.18 130.15,100.35 130.05,100.35 129.94,100.24 v1(129.94,99.95)
  TOP w0.114: CN1.221 124.15,88.21 123.26,87.32 123.26,86.47 123.55,86.18 v1(124.31,86.18)
  L8_IN3 w0.076: v1(124.31,86.18) 124.07,86.42 123.89,86.42 123.67,86.64 123.67,87.25 123.92,87.5 123.92,93.42 123.92,93.57 125.01,94.66 125.01,95.79 125.04,95.81 125.04,97.6 126.25,98.81 128.6,98.81 129.04,99.25 129.78,99.25 130.35,99.83 130.35,99.94 130.23,100.06 130.05,100.06 v1(129.94,99.95)
M_A_DQS7: length 38.1
  TOP w0.076: v1(126.61,102.31) 127.42,102.31 128.59,103.48 128.59,105.08 U26.M3
  TOP w0.114: v1(120.41,85.76) 119.74,85.76 118.9,84.91 CN1.242
  L8_IN3 w0.076: v1(126.61,102.31) 126.74,102.44 126.74,102.64 126.5,102.87 126.19,102.87 124.77,101.46 118.94,101.46 117.1,99.62 117.1,94.97 118.34,93.73 118.34,90.45 119.32,89.47 119.32,87.49 119.82,86.99 119.82,85.66 120.14,85.34 120.53,85.34 120.61,85.42 120.61,85.64 120.49,85.76 v1(120.41,85.76)
M_A_DQS#0: length 39.5
  TOP w0.076: v1(163.51,105.7) 163.66,105.7 163.74,105.78 163.74,105.94 163.27,106.41 161.98,106.41 161.75,106.64 161.45,106.64 161.3,106.49 161.3,106.1 161.39,106.01 161.52,106.01 161.65,106.13 U26.BR5
  TOP w0.114: v1(176.89,84.72) 177.8,84.72 178.65,85.57 CN1.11
  L8_IN3 w0.076: v1(163.51,105.7) 163.74,105.7 163.75,105.72 164.26,105.72 164.94,105.03 164.94,104.9 165.58,104.26 168.06,104.26 177.73,94.58 177.73,88.99 178.02,88.7 178.02,85.67 177.38,85.03 177.2,85.03 v1(176.89,84.72)
M_A_DQS#1: length 37.2
  TOP w0.076: 159.21,102.88 159.11,102.88 158.4,103.59 158.4,104.22 158.71,104.53 158.71,104.9 158.58,105.03 158.58,105.08 158.86,105.37 U26.BL3
  TOP w0.114: CN1.32 173.39,84.76 172.56,85.6 v1(171.78,85.6) ; v1(161.46,101.59) 161.46,101.52 161.12,101.18 160.91,101.18 159.21,102.88
  L8_IN3 w0.076: v1(161.46,101.59) 161.61,101.43 162.2,101.43 163.33,100.29 166.95,100.29 171.88,95.36 171.88,90.89 172.83,89.93 172.83,87.53 172.08,86.78 171.58,86.78 171.2,86.4 171.2,85.48 171.37,85.3 171.61,85.3 171.78,85.47 v1(171.78,85.6)
M_A_DQS#2: length 32.9
  TOP w0.076: U26.BG3 156.33,105.57 156.22,105.57 156.13,105.48 156.13,105.01 156.25,104.9 156.25,103.8 156.1,103.66 156.1,102.85 157.23,101.72 157.23,101.21 157.3,101.14 157.3,101.13
  TOP w0.114: v1(158.56,100) 158.47,99.9 158.43,99.9 157.79,99.9 157.3,100.4 157.3,101.13 ; CN1.53 168.14,86.86 167.8,86.51 v1(167.23,86.51)
  L8_IN3 w0.076: v1(158.56,100) 158.58,99.98 159.04,99.98 159.25,99.78 159.25,98.93 160.45,97.73 160.45,97.5 160.46,97.48 160.46,97.43 161.05,96.84 163.87,96.84 167.82,92.88 167.82,92.11 167.75,92.04 167.75,91.79 167.82,91.72 167.82,91.22 167.59,90.98 167.59,90.86 167.82,90.63 167.82,90.07 167.64,89.89 167.3,89.89 167.22,89.82 167.22,89.66 167.3,89.59 167.64,89.59 167.82,89.41 167.82,89.11 167.64,88.93 167.29,88.93 167.22,88.85 167.22,88.7 167.29,88.62 167.64,88.62 167.82,88.44 167.82,87.71 167.73,87.62 167.73,87.52 167.82,87.42 167.82,86.99 167.64,86.81 167.52,86.81 v1(167.23,86.51)
M_A_DQS#3: length 31.8
  TOP w0.076: U26.BD3 153.89,105.5 153.78,105.5 153.65,105.38 153.65,105.25 153.74,105.16 153.74,102.01 153.81,101.94 153.81,101.92
  TOP w0.114: CN1.74 162.9,82.12 162.7,82.31 162.7,83.82 162.95,84.07 163.32,84.07 163.44,83.95 163.44,83.78 v1(163.32,83.66) ; v1(155.13,100.51) 155.05,100.51 154.75,100.2 154.37,100.2 153.81,100.77 153.81,101.92
  L8_IN3 w0.076: v1(163.32,83.66) 163.02,83.96 162.89,83.96 162.42,84.44 162.42,90.49 159.73,93.19 159.62,93.19 155.59,97.21 155.59,97.46 155.6,97.47 155.6,98.36 154.58,99.38 154.58,100.12 154.76,100.3 154.92,100.3 v1(155.13,100.51)
M_A_DQS#4: length 29.3
  TOP w0.076: v1(136.77,98.77) 136.53,99.01 136.33,99.01 135.96,99.37 135.96,104.83 135.85,104.94 135.85,105.2 U26.AA3
  TOP w0.114: CN1.177 135.15,87.39 134.57,86.81 134.57,85.56 134.19,85.18 133.89,85.18 v1(133.7,85)
  L8_IN3 w0.076: v1(136.77,98.77) 136.53,99.01 135.97,99.01 134.51,97.55 134.51,96.66 132.97,95.12 132.97,89.1 134.31,87.75 134.31,85.68 134.02,85.39 133.9,85.39 133.7,85.2 v1(133.7,85)
M_A_DQS#5: length 30.9
  TOP w0.076: U26.U3 133.2,105.37 133.46,105.1 133.46,102.17 132.78,101.49 132.78,99.63 132.94,99.47 v1(132.94,99.19)
  TOP w0.114: v1(131.16,84.22) 131.16,84.46 130.76,84.85 130.59,84.85 130.1,84.36 130.1,83.18 129.7,82.78 129.7,82.31 129.9,82.12 CN1.198
  L8_IN3 w0.076: v1(131.16,84.22) 131.16,84.3 130.9,84.56 130.82,84.56 128.84,86.53 128.84,96.09 129.82,97.06 129.85,97.06 130.3,97.51 130.46,97.51 131.31,98.36 132.71,98.36 133.32,98.97 133.32,99.16 133.28,99.19 v1(132.94,99.19)
M_A_DQS#6: length 33.3
  TOP w0.076: U26.P3 130.94,105.08 130.94,103.47 128.93,101.46 128.93,99.38 129.32,99 129.89,99 130.49,99.6 v1(130.49,100.53)
  TOP w0.114: CN1.219 124.64,88.49 124.45,88.29 124.45,88.08 123.56,87.19 123.56,86.6 123.68,86.48 123.84,86.48 123.95,86.6 123.95,86.82 124.07,86.94 124.23,86.94 v1(124.31,86.85)
  L8_IN3 w0.076: v1(130.49,100.53) 130.3,100.34 130.3,100.21 130.51,100 130.51,99.76 129.84,99.1 129.11,99.1 128.67,98.66 126.31,98.66 125.19,97.53 125.19,94.59 124.1,93.5 124.1,87.42 123.85,87.17 123.85,86.71 123.96,86.6 124.11,86.6 124.31,86.81 v1(124.31,86.85)
M_A_DQS#7: length 38
  TOP w0.076: U26.L3 128.25,105.47 128.45,105.47 128.53,105.4 128.53,105.25 128.42,105.15 128.42,103.55 127.35,102.48 127.14,102.48 127.06,102.56 v1(127.06,102.82)
  TOP w0.114: v1(120.44,84.87) 120.44,85.03 120.02,85.45 119.87,85.45 119.2,84.78 119.2,82.3 119.39,82.1 CN1.240
  L8_IN3 w0.076: v1(120.44,84.87) 120.14,85.17 120.06,85.17 119.64,85.59 119.64,86.92 119.15,87.41 119.15,89.4 118.16,90.38 118.16,93.65 116.93,94.89 116.93,99.7 118.87,101.64 120.64,101.64 120.66,101.61 124.71,101.61 126.12,103.03 126.57,103.03 126.77,102.82 v1(127.06,102.82)
M_A_EVENT#: length 3.4
  TOP w0.102: CN1.134 147.9,82.37 v1(147.79,82.48)
  BOTTOM w0.102: v3(147.29,82.96) 147.31,82.96 v1(147.79,82.48) 148.03,82.24 R206.1
M_B_A0: length 45.4
  TOP w0.076: v1(142.16,109.6) U26.AJ9
  TOP w0.165: CN11.144 145.4,69.07 v1(145.07,69.4)
  L3_IN1 w0.076: 141.74,97.48 141.74,99.26 141.48,99.52 141.48,107.73 141.78,108.03 141.78,109.22 v1(142.16,109.6)
  L3_IN1 w0.135: 141.74,97.48 141.74,94.57 139.89,92.72 139.89,90.95 141.28,89.57 141.28,88.22 142.14,87.35 142.14,85.53 142.22,85.45 142.22,83.61 142.25,83.58 142.25,74.27 143.5,73.02 143.5,70.97 v1(145.07,69.4)
M_B_A1: length 46.3
  TOP w0.076: U26.AK6 v1(142.78,106.99)
  TOP w0.165: CN11.133 148.14,75.05 146.14,73.05 146.14,72.47 145.06,71.39 v1(145.06,70.69)
  L3_IN1 w0.076: v1(142.78,106.99) 141.97,106.18 141.97,99.91 142.62,99.26 142.62,97.48
  L3_IN1 w0.135: v1(145.06,70.69) 144.91,70.84 144.91,71.25 143.94,72.21 143.94,75.27 143.86,75.36 143.86,79.89 143.74,80 143.74,85.43 143.59,85.58 143.59,86.12 143.21,86.5 143.21,87.52 142.15,88.58 142.15,90.41 141.58,90.99 141.58,92.46 142.62,93.51 142.62,97.48
M_B_A2: length 46.9
  TOP w0.076: v1(142.78,106.34) U26.AK5
  TOP w0.165: v1(148.6,70.18) 148.34,69.92 148.34,69.26 148.4,69.21 CN11.132
  L3_IN1 w0.135: v1(148.6,70.18) 148.27,70.18 148.16,70.29 148.16,70.76 148.03,70.89 147.76,70.89 147.63,70.76 147.63,70.05 147.49,69.91 146.62,69.91 146.42,70.11 146.42,70.54 146.5,70.62 146.5,70.81 146.31,71 146.12,71 145.95,70.82 145.76,70.82 145.4,71.18 145.4,71.37 145.65,71.61 145.65,71.8 145.46,71.99 145.27,71.99 145.12,71.84 144.93,71.84 144.38,72.39 144.38,73.01 144.59,73.21 144.59,73.51 144.38,73.72 144.38,74.48 144.56,74.66 144.56,75.28 144.3,75.54 144.3,80.12 144.18,80.24 144.18,85.62 144.03,85.77 144.03,86.3 143.73,86.61 143.73,87.63 142.59,88.76 142.59,90.6 142.02,91.17 142.02,92.28 143.06,93.33 143.06,98.17 142.87,98.36 142.87,103.69 142.39,104.17 142.39,105.94 v1(142.78,106.34)
M_B_A3: length 45.9
  TOP w0.076: v1(144.41,106.34) U26.AL5
  TOP w0.165: CN11.131 148.65,74.83 v1(147.28,73.46)
  L3_IN1 w0.076: 144.97,97.48 144.97,98.49 145.28,98.79 145.28,104.19 144.41,105.06 v1(144.41,106.34)
  L3_IN1 w0.135: v1(147.28,73.46) 147.28,74.25 147.41,74.39 147.84,74.39 147.97,74.52 147.97,74.79 147.84,74.93 147.15,74.93 146.93,75.15 146.93,75.9 146.64,76.18 146.64,76.58 146.51,76.71 146.3,76.71 146.17,76.85 146.17,77.12 146.3,77.25 146.51,77.25 146.64,77.39 146.64,79.78 146.42,80 146.42,80.25 146.64,80.47 146.64,80.63 146.51,80.77 146.26,80.77 146.13,80.9 146.13,81.17 146.26,81.3 146.51,81.3 146.64,81.44 146.64,81.71 146.51,81.84 146.17,81.84 146.04,81.97 146.04,82.25 146.17,82.38 146.48,82.38 146.62,82.52 146.62,85.96 146.42,86.15 146.42,86.58 146.62,86.77 146.62,87.81 146.48,87.94 146.08,87.94 145.94,88.08 145.94,88.35 146.08,88.48 146.48,88.48 146.62,88.62 146.62,88.89 146.48,89.02 146.08,89.02 145.94,89.16 145.94,89.42 146.08,89.56 146.48,89.56 146.62,89.69 146.62,90.1 146.48,90.23 145.6,90.23 145.47,90.37 145.47,90.64 145.6,90.77 145.81,90.77 145.94,90.91 145.94,91.3 145.69,91.55 145.69,91.75 145.94,92 145.94,92.65 145.81,92.79 145.14,92.79 144.97,92.96 144.97,97.48
M_B_A4: length 47.2
  TOP w0.076: v1(144.41,106.99) U26.AL6
  TOP w0.165: v1(148.65,71.63) 149.4,70.89 CN11.128
  L3_IN1 w0.076: v1(144.41,106.99) 144.82,106.58 144.82,105.21 145.45,104.57 145.45,98.59 145.41,98.54 145.41,97.48
  L3_IN1 w0.135: 145.41,97.48 145.41,93.81 146.59,92.63 146.59,92.39 146.38,92.18 146.38,91.94 146.53,91.79 146.53,91.49 146.38,91.34 146.38,91.05 147.08,90.35 147.08,87.11 147.22,86.97 147.39,86.97 147.53,86.84 147.53,86.57 147.39,86.43 147.22,86.43 147.08,86.3 147.08,86.03 147.22,85.89 147.39,85.89 147.53,85.76 147.53,85.49 147.39,85.35 147.22,85.35 147.08,85.22 147.08,84.95 147.22,84.82 147.39,84.82 147.53,84.68 147.53,84.41 147.39,84.28 147.22,84.28 147.08,84.14 147.08,83.87 147.22,83.74 147.39,83.74 147.53,83.6 147.53,83.34 147.39,83.2 147.22,83.2 147.08,83.07 147.08,82 147.22,81.87 147.58,81.87 147.71,81.73 147.71,81.46 147.58,81.33 147.22,81.33 147.08,81.19 147.08,76.37 147.37,76.08 147.37,75.5 147.5,75.36 148.16,75.36 148.43,75.09 148.43,73.93 148.3,73.79 147.9,73.79 147.78,73.67 147.78,73.38 147.9,73.25 148.3,73.25 148.43,73.12 148.43,72.85 148.3,72.72 148.04,72.72 147.9,72.58 147.9,72.31 148.04,72.18 148.52,72.18 148.65,72.04 v1(148.65,71.63)
M_B_A5: length 45.7
  TOP w0.076: v1(145.25,106.99) U26.AM6
  TOP w0.165: v1(149.34,72.78) 149.34,72.49 149.9,71.93 CN11.126
  L3_IN1 w0.076: v1(145.25,106.99) 145.65,106.58 145.65,97.76 145.85,97.56 145.85,97.48
  L3_IN1 w0.135: v1(149.34,72.78) 149.83,72.28 149.83,72.16 149.65,71.98 149.46,71.98 148.87,72.56 148.87,75.37 147.52,76.72 147.52,77.19 147.66,77.32 147.93,77.32 148.06,77.46 148.06,77.73 147.93,77.86 147.66,77.86 147.52,78 147.52,78.26 147.66,78.4 147.93,78.4 148.06,78.53 148.06,78.8 147.93,78.94 147.66,78.94 147.52,79.07 147.52,80.52 148.3,81.3 148.3,83 148.54,83.24 148.54,86.9 147.52,87.93 147.52,92.32 145.85,93.99 145.85,97.48
M_B_A6: length 46.4
  TOP w0.076: U26.AN7 v1(144.9,108.3)
  TOP w0.165: v1(149.39,73.56) 149.87,73.08 149.87,72.8 149.99,72.67 150.61,72.67 150.73,72.8 150.73,73.28 149.65,74.37 CN11.127
  L3_IN1 w0.076: 146.29,97.48 146.29,97.69 145.84,98.14 145.84,107.04 144.9,107.97 v1(144.9,108.3)
  L3_IN1 w0.135: 146.29,97.48 146.29,94.17 147.96,92.5 147.96,90.89 148.09,90.76 148.5,90.76 148.64,90.62 148.64,90.36 148.5,90.22 148.09,90.22 147.96,90.09 147.96,89.82 148.09,89.68 148.53,89.68 148.65,89.56 148.65,89.26 148.53,89.14 148.09,89.14 147.96,89.01 147.96,88.11 148.98,87.09 148.98,83.06 148.74,82.82 148.74,81.12 148.52,80.9 148.52,80.75 148.39,80.62 148.26,80.62 148.12,80.48 148.12,80.21 148.26,80.08 148.39,80.08 148.52,79.94 148.52,77.25 148.16,76.89 148.16,76.7 149.31,75.55 149.31,73.64 v1(149.39,73.56)
M_B_A7: length 46.8
  TOP w0.076: U26.AN10 v1(144.9,110.25)
  TOP w0.165: CN11.122 150.9,70.25 152.28,71.64 v1(152.28,72.32)
  L3_IN1 w0.076: 147.25,97.48 147.25,97.96 146.26,98.95 146.26,107.12 145.55,107.83 145.55,108.52 145.27,108.81 145.27,109.88 v1(144.9,110.25)
  L3_IN1 w0.135: v1(152.28,72.32) 150.51,74.1 150.51,75.6 150.04,76.07 150.04,80.88 149.87,81.05 149.87,87.44 149.53,87.78 149.53,90.66 150.15,91.29 150.15,92.42 147.25,95.32 147.25,97.48
M_B_A8: length 46.2
  TOP w0.076: U26.AN8 v1(144.9,108.95)
  TOP w0.165: CN11.125 150.14,74.53 151.5,73.18 v1(151.5,72.34)
  L3_IN1 w0.076: 146.73,97.48 146.73,97.77 146.06,98.44 146.06,107.07 145.34,107.79 145.34,108.47 144.9,108.91 v1(144.9,108.95)
  L3_IN1 w0.135: v1(151.5,72.34) 151.1,72.34 150.07,73.38 150.07,75.42 148.96,76.53 148.96,80.65 149.18,80.87 149.18,82.64 149.42,82.88 149.42,87.27 149.09,87.6 149.09,87.95 148.95,88.09 148.61,88.09 148.48,88.22 148.48,88.49 148.61,88.62 148.95,88.62 149.09,88.76 149.09,92.33 148.67,92.75 148.34,92.75 146.73,94.35 146.73,97.48
M_B_A9: length 43.1
  TOP w0.076: v1(146.73,110.9) U26.AR11
  TOP w0.165: CN11.121 151.14,75.5 151.45,75.2 151.45,74.45 151.61,74.28 v1(152.13,74.28)
  L3_IN1 w0.076: v1(146.73,110.9) 146.2,110.37 146.2,108.88 146.03,108.72 146.03,107.86 146.72,107.17 146.72,99.4 148.13,98 148.13,97.48
  L3_IN1 w0.135: 148.13,97.48 148.13,95.86 151.03,92.96 151.03,90.61 150.75,90.33 150.75,81.82 151.47,81.1 151.47,79.14 151.48,79.13 151.48,78.2 151.48,78.2 151.48,74.92 152.12,74.28 v1(152.13,74.28)
M_B_A10_AP: length 46.7
  TOP w0.076: v1(141.24,108.3) U26.AH7
  TOP w0.165: v1(142.48,70.46) 143.19,70.46 143.32,70.34 143.32,69.6 142.9,69.18 CN11.146
  L3_IN1 w0.076: v1(141.24,108.3) 141.04,108.1 141.04,98.17 140.87,97.99 140.87,97.48
  L3_IN1 w0.135: v1(142.48,70.46) 142.98,70.96 142.98,72.04 142.72,72.29 142.07,72.29 141.35,73.02 141.35,77.07 140.77,77.65 140.77,78.74 140.94,78.91 140.94,79.18 140.77,79.35 140.77,80.12 140.9,80.25 141.23,80.25 141.36,80.39 141.36,80.66 141.23,80.79 140.48,80.79 140.34,80.93 140.34,89.26 139.44,90.16 139.01,90.16 138.43,90.75 138.43,92.52 140.87,94.96 140.87,97.48
M_B_A11: length 47.3
  TOP w0.076: v1(144.9,110.9) U26.AN11
  TOP w0.165: CN11.120 151.4,70.01 v1(152.41,71.02)
  L3_IN1 w0.076: 147.69,97.48 147.69,97.96 146.49,99.15 146.49,107.14 145.77,107.87 145.77,108.54 145.43,108.87 145.43,110.37 v1(144.9,110.9)
  L3_IN1 w0.135: 147.69,97.48 147.69,95.68 150.59,92.77 150.59,91.11 150.31,90.83 150.31,81.23 151.04,80.51 151.04,78.96 151.04,78.95 151.04,78.39 151.04,78.38 151.04,74.27 152.78,72.53 152.78,72.11 152.41,71.74 v1(152.41,71.02)
M_B_A12: length 42.2
  TOP w0.076: v1(146.73,110.25) U26.AR10
  TOP w0.165: CN11.119 151.65,75.46 v1(152.14,74.96)
  L3_IN1 w0.076: v1(146.73,110.25) 146.36,109.88 146.36,108.81 146.2,108.65 146.2,107.95 146.95,107.19 146.95,103.62 147.84,102.73 147.84,100.03 149.38,98.49 149.38,97.48
  L3_IN1 w0.135: v1(152.14,74.96) 152.48,75.3 152.48,75.52 152.34,75.65 152.08,75.65 151.94,75.79 151.94,76.06 152.08,76.19 152.34,76.19 152.48,76.33 152.48,76.6 152.34,76.73 152.08,76.73 151.94,76.87 151.94,77.13 152.08,77.27 152.34,77.27 152.48,77.4 152.48,80.01 152.04,80.45 152.04,84.79 151.78,85.05 151.78,90.25 152.04,90.51 152.04,92.57 149.38,95.23 149.38,97.48
M_B_A13: length 49.1
  TOP w0.076: v1(139.41,109.6) U26.AF9
  TOP w0.165: v1(139.39,70.29) 139.92,69.76 139.92,69.31 139.9,69.29 CN11.158
  L3_IN1 w0.076: v1(139.41,109.6) 138.92,109.1 138.92,99.21 137.79,98.08 137.79,97.48
  L3_IN1 w0.135: 137.79,97.48 137.79,96.23 134.73,93.17 134.73,88.86 135.35,88.24 135.35,82.12 136.51,80.95 136.51,76.52 136.82,76.21 137.33,76.21 137.48,76.06 137.48,75.55 137.95,75.08 137.95,71.66 138.33,71.28 138.33,71.09 137.44,70.2 137.44,70.01 137.63,69.82 137.82,69.82 138.71,70.71 138.9,70.71 139.32,70.29 v1(139.39,70.29)
M_B_A14_MB_WE#: length 46.1
  TOP w0.076: v1(141.24,110.9) U26.AH11
  TOP w0.165: CN11.151 141.65,75.38 141.55,75.29 141.55,74.57 140.09,73.11 139.83,73.11 v1(139.78,73.05)
  L3_IN1 w0.076: v1(141.24,110.9) 140.7,110.36 140.7,108.78 140.52,108.6 140.52,108.02 139.69,107.19 139.69,98.36 139.55,98.22 139.55,97.48
  L3_IN1 w0.135: v1(139.78,73.05) 139.92,73.19 139.92,76.4 138.85,77.47 138.85,79.74 138.85,79.74 138.85,82.14 138.39,82.6 138.39,88.86 136.54,90.71 136.54,92.49 139.55,95.5 139.55,97.48
M_B_A15_MB_CAS#: length 47.6
  TOP w0.076: v1(139.41,108.96) U26.AF8
  TOP w0.165: v1(139.39,70.95) 139.65,70.95 140.4,70.2 CN11.156
  L3_IN1 w0.076: 139.13,104.89 139.13,108.68 v1(139.41,108.96)
  L3_IN1 w0.135: 139.13,104.89 139.13,98.98 138.23,98.08 138.23,96.05 135.17,92.99 135.17,89.04 136.11,88.1 136.11,86.83 136.39,86.55 136.39,84.44 135.82,83.87 135.82,82.27 136.95,81.14 136.95,78.01 137.09,77.88 137.38,77.88 137.52,77.74 137.52,77.47 137.38,77.34 137.09,77.34 136.95,77.2 136.95,76.72 137.03,76.65 137.81,76.65 137.94,76.52 137.94,76.1 138.07,75.97 138.49,75.97 138.6,75.86 138.6,74.57 138.39,74.36 138.39,71.95 v1(139.39,70.95)
M_B_A16_MB_RAS#: length 47.5
  TOP w0.076: v1(141.24,110.25) U26.AH10
  TOP w0.165: CN11.152 141.4,69.33 141.47,69.4 141.47,69.92 v1(141.02,70.36)
  L3_IN1 w0.076: 139.99,97.48 139.99,98.06 140.68,98.76 140.68,108.53 140.86,108.71 140.86,109.87 v1(141.24,110.25)
  L3_IN1 w0.135: 139.99,97.48 139.99,95.32 137.55,92.89 137.55,90.38 138.65,89.29 138.96,89.29 139.18,89.07 139.18,88.97 138.83,88.62 138.83,88.43 138.96,88.29 139.32,88.29 139.45,88.16 139.45,87.89 139.32,87.75 138.96,87.75 138.83,87.62 138.83,82.78 139.47,82.15 139.47,79.95 139.29,79.78 139.29,79.32 139.46,79.15 139.46,78.96 139.29,78.78 139.29,77.65 140.36,76.58 140.36,72.24 141.02,71.57 v1(141.02,70.36)
M_B_ACT_N: length 47.2
  TOP w0.076: v1(147.64,109.6) U26.AT9
  TOP w0.165: v1(154.45,71.15) 154.12,71.15 153.05,70.09 153.05,69.25 152.9,69.09 CN11.114
  L3_IN1 w0.135: v1(154.45,71.15) 154.52,71.15 156.29,72.92 156.29,80.87 156.11,81.04 156.11,86.5 155.85,86.75 155.85,93.41 154.74,94.52 154.74,94.52 152.08,97.18 152.08,97.95 150.89,99.14 150.89,101.88 149.9,102.86 149.9,102.89 149.82,102.97 149.82,107.05 147.64,109.23 v1(147.64,109.6)
M_B_BA0: length 45.7
  TOP w0.076: v1(141.24,108.95) U26.AH8
  TOP w0.165: v1(142.48,71.18) 142.28,70.98 142.27,70.98 141.96,70.68 141.96,70.66 141.94,70.63 141.94,68.24 CN11.150
  L3_IN1 w0.076: v1(141.24,108.95) 141.24,108.86 140.85,108.47 140.85,98.45 140.43,98.02 140.43,97.48
  L3_IN1 w0.135: 140.43,97.48 140.43,95.14 137.99,92.7 137.99,90.57 138.83,89.72 139.15,89.72 139.9,88.97 139.9,87.23 139.27,86.6 139.27,82.97 139.9,82.33 139.9,80.74 140.33,80.32 140.33,77.23 140.8,76.77 140.8,72.42 142.04,71.18 v1(142.48,71.18)
M_B_BA1: length 47.7
  TOP w0.076: v1(141.24,109.6) U26.AH9
  TOP w0.165: CN11.145 143.15,75.55 142.49,74.9 142.49,73.95 v1(141.94,73.4)
  L3_IN1 w0.076: v1(141.24,109.6) 141.61,109.23 141.61,108.1 141.24,107.73 141.24,99.41 141.31,99.35 141.31,97.48
  L3_IN1 w0.135: 141.31,97.48 141.31,94.77 138.87,92.34 138.87,92.09 139.15,91.81 139.15,91.65 138.87,91.37 138.87,90.93 139.2,90.6 139.62,90.6 140.78,89.44 140.78,88.09 141.17,87.7 141.17,87.49 140.85,87.18 140.85,87 140.92,86.93 141.56,86.93 141.7,86.8 141.7,86.53 141.56,86.39 140.92,86.39 140.78,86.26 140.78,84.83 140.98,84.63 140.98,84.48 140.78,84.28 140.78,84.05 141.05,83.78 141.05,83.51 140.78,83.25 140.78,82.76 140.92,82.62 141.68,82.62 141.81,82.49 141.81,82.17 141.68,82.04 140.93,82.04 140.79,81.9 140.79,81.63 140.93,81.5 141.68,81.5 141.81,81.36 141.81,74.08 141.94,73.95 v1(141.94,73.4)
M_B_BG0: length 44.1
  TOP w0.076: U26.AR9 v1(146.73,109.6)
  TOP w0.165: CN11.115 152.65,75.13 152.89,74.88 152.89,74.88 152.95,74.82 152.95,73.88 v1(153.48,73.36)
  L3_IN1 w0.076: 150.76,97.48 150.76,98.14 148.43,100.48 148.43,106.82 148.2,107.05 148.2,107.17 147.99,107.38 147.72,107.38 147.11,108 147.11,108.75 147.1,108.76 147.1,109.2 147.11,109.2 147.11,109.22 v1(146.73,109.6)
  L3_IN1 w0.135: v1(153.48,73.36) 153.99,73.88 153.99,77.15 154.38,77.54 154.38,80.16 153.85,80.7 153.85,81.71 154.13,81.99 154.13,92.34 150.76,95.71 150.76,97.48
M_B_BG1: length 44.9
  TOP w0.076: U26.AR7 v1(146.73,108.3)
  TOP w0.165: v1(153.47,74.09) 153.82,74.44 153.82,74.98 153.64,75.16 153.33,75.16 153.14,75.34 CN11.113
  L3_IN1 w0.076: v1(146.73,108.3) 146.73,108.08 147.38,107.42 147.38,103.65 148.22,102.81 148.22,100.36 150.33,98.25 150.33,97.48
  L3_IN1 w0.135: 150.33,97.48 150.33,95.52 152.92,92.93 152.92,90.75 153.05,90.62 153.58,90.62 153.69,90.5 153.69,90.19 153.58,90.08 153.05,90.08 152.92,89.94 152.92,89.67 153.05,89.54 153.59,89.54 153.69,89.44 153.69,89.1 153.59,89 153.05,89 152.92,88.87 152.92,88.6 153.1,88.42 153.56,88.42 153.68,88.3 153.68,87.93 153.37,87.62 153.37,87.44 153.68,87.13 153.68,82.16 153.41,81.89 153.41,80.44 153.93,79.93 153.93,79.15 153.79,79.01 153.5,79.01 153.37,78.88 153.37,78.61 153.5,78.48 153.79,78.48 153.93,78.34 153.93,77.7 153.47,77.25 v1(153.47,74.09)
M_B_DQ0: length 54.2
  TOP w0.076: v1(164.86,110.05) 164.45,109.65 164.08,109.65 163.59,110.14 163.36,110.14 163.09,110.41 163.08,110.41 162.97,110.52 U26.BT11
  TOP w0.102: CN11.4 180.4,69.32 v1(179.35,70.36)
  L3_IN1 w0.076: 167.11,109.04 166.69,109.45 166.24,109.45
  L3_IN1 w0.089: v1(179.35,70.36) 177.68,72.03 177.68,75.56 177.25,76 177.25,78.89 176.73,79.4 176.73,80.29 176.82,80.38 177.1,80.38 177.19,80.47 177.19,80.65 177.1,80.74 176.82,80.74 176.73,80.83 176.73,81 176.82,81.09 177.12,81.09 177.21,81.18 177.21,81.36 177.12,81.45 176.82,81.45 176.73,81.54 176.73,81.72 176.82,81.8 177.03,81.8 177.42,82.19 177.42,88.14 176.66,88.9 176.66,91.17 175.21,92.62 175.21,93.81 173.38,95.65 173.38,98.32 169.04,102.66 169.04,106.4 167.82,107.62 167.82,108.33 167.11,109.04 ; v1(164.86,110.05) 165.46,109.45 166.24,109.45
M_B_DQ1: length 55
  TOP w0.076: v1(165.5,110.05) 164.92,109.48 164.01,109.48 163.52,109.97 163.3,109.97 163.04,110.23 161.93,110.23 U26.BR11
  TOP w0.102: CN11.8 v1(179.4,69.62)
  L3_IN1 w0.089: v1(179.4,69.62) 179.84,70.06 179.84,71.76 178,73.6 178,75.66 177.54,76.12 177.54,80.92 177.71,81.08 177.71,88.26 176.96,89.02 176.96,89.69 177.05,89.78 177.43,89.78 177.52,89.86 177.52,90.04 177.43,90.13 177.05,90.13 176.96,90.22 176.96,90.4 177.05,90.49 177.42,90.49 177.51,90.58 177.51,90.75 177.42,90.84 177.05,90.84 176.96,90.93 176.96,91.29 175.54,92.72 175.54,93.9 173.67,95.77 173.67,98.44 169.33,102.79 169.33,106.52 168.11,107.74 168.11,108.45 166.9,109.66 165.89,109.66 v1(165.5,110.05)
M_B_DQ2: length 52.5
  TOP w0.076: U26.BT9 v1(162.86,109.85)
  TOP w0.102: CN11.17 177.15,75.39 175.57,73.81 v1(174.37,73.81)
  L3_IN1 w0.076: 165.34,106.74 162.86,109.23 v1(162.86,109.85)
  L3_IN1 w0.089: 165.34,106.74 165.36,106.73 165.81,106.73 166.98,105.56 166.98,101.69 170.69,97.98 170.69,92.12 170.99,91.82 171.11,91.82 171.6,92.3 171.72,92.3 171.85,92.18 171.85,92.05 171.37,91.57 171.37,91.44 171.75,91.06 171.75,90.64 172.52,89.87 172.64,89.87 173.06,90.29 173.19,90.29 173.31,90.16 173.31,90.04 172.9,89.62 172.9,89.49 173.02,89.37 173.15,89.37 173.57,89.78 173.69,89.78 173.82,89.66 173.82,89.53 173.4,89.12 173.4,88.99 173.68,88.71 173.68,86.06 174.63,85.12 174.63,84.84 174.54,84.75 174.4,84.75 174.31,84.66 174.31,84.48 174.4,84.39 174.54,84.39 174.63,84.31 174.63,83.97 174.46,83.8 174.46,83.61 174.63,83.44 174.63,83.26 174.46,83.09 174.46,82.9 174.63,82.73 174.63,82.55 174.54,82.46 174.44,82.46 174.35,82.37 174.35,82.19 174.44,82.11 174.54,82.11 174.63,82.02 174.63,81.84 174.54,81.75 174.37,81.75 174.28,81.66 174.28,81.48 174.37,81.39 174.54,81.39 174.63,81.31 174.63,80.79 174.54,80.7 174.42,80.7 174.33,80.61 174.33,80.43 174.42,80.34 174.6,80.34 174.69,80.25 174.69,77.22 174.45,76.99 174.45,73.9 v1(174.37,73.81)
