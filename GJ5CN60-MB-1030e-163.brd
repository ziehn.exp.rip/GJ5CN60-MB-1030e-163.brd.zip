# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N26162920: length 8.1
  TOP w0.3: 107.59,14.58 U28.BG5
  TOP w0.305: v1(107.65,14.52) 107.59,14.58
  BOTTOM w0.381: R389.1 111.87,15.05 C283.1 110.69,13.64 110.29,13.24 108.79,13.24 107.65,14.37 v1(107.65,14.52)
N26166714: length 2.7
  TOP w0.076: v1(107.32,23.09) 107.32,23.15 U28.AK3
  BOTTOM w0.102: R383.2 109.09,22.56 107.85,22.56 v1(107.32,23.09)
N26182237: length 5.2
  TOP w0.102: Q105.S 93.05,20.32 R435.1 92.79,20.2 v4(92.79,19.43) 92.79,18.77 93.45,18.11 CNWLAN1.55
N26195158: length 1.7
  BOTTOM w0.508: R1010.2 182,74.48 Q106.G
N26195204: length 3.3
  BOTTOM w0.508: Q100.3 183.52,70.89 184.02,71.39 R510.1
N26195271: length 2.1
  BOTTOM w0.305: R1014.2 C1349.2 184.17,69.29 Q100.2
N26196507: length 7
  BOTTOM w0.102: Q148.D 104.41,10.3 Q147.G 102.95,9.41 102.95,7.06 103.2,6.81 R3240.2
N26288217: length 1.3
  BOTTOM w0.508: R925.1 21.73,75.02 C720.1
N26288246: length 1.4
  TOP w0.508: C1043.1 13.94,74.48 R422.1
N26288248: length 0.9
  BOTTOM w0.203: R958.2 C544.1
N26289109: length 4.9
  BOTTOM w0.203: R961.2 17.47,73.74 18.11,73.1 18.11,72.22 17.9,72.01 17.9,70.65 18.12,70.44 U721.13
N26289115: length 5.3
  BOTTOM w0.203: U721.4 23.74,70.04 R939.1 24.23,69.55 R956.2 R944.2
N26289147: length 6.5
  TOP w0.203: R795.1 C1367.1 13.61,65.56 Q123.D 15.19,67.39 14.17,68.41 Q124.G
N26289174: length 2.2
  TOP w0.102: R927.1 11.89,72.52 11.89,70.44
N26289193: length 3.9
  BOTTOM w0.203: R968.1 17.78,67.39 R967.2 18.54,68.15 19.38,68.15 19.61,68.39 U721.9
N26289201: length 2.5
  BOTTOM w0.203: U721.5 23.15,69.64 R949.2
N26289253: length 8.8
  BOTTOM w0.203: R923.1 R938.1 26.57,66.81 25.17,65.41 22.12,65.41 C796.1 20.32,65.89 R930.1
N26289271: length 6.5
  BOTTOM w0.203: U721.7 20.41,68.51 20.78,68.15 22.17,68.15 22.5,67.82 R960.2 24.18,67.64 C798.1 25.17,67.19 R938.2
N26289273: length 3.4
  BOTTOM w0.203: U721.6 20.81,68.74 21.02,68.53 23.37,68.53 R922.2
N26289275: length 1.1
  BOTTOM w0.203: R922.1 25.04,68.53 R923.2
N26289279: length 1.7
  BOTTOM w0.203: R928.1 19.48,65.84 19.76,66.12 19.76,66.5 20.01,66.75 R930.2
N26289296: length 0.9
  BOTTOM w0.203: R960.1 21.64,67.59 R962.2
N26319346: length 3.3
  BOTTOM w0.102: R247.2 19.13,138.97 U14.1
N26319364: length 3.2
  BOTTOM w0.102: U14.3 16.52,141.28 R230.2
N26351252: length 5.2
  TOP w0.102: Q146.G 192.8,117.68 192.48,117.68 Q45.C 192.81,119.54 R3197.1
N26351618: length 2.4
  TOP w0.254: R3202.1 188.7,103.41 C154.2 188.34,103.86 188.39,103.86 v1(188.49,103.97) 188.11,104.35 R3201.2
N26351797: length 1.6
  TOP w0.254: R842.1 182.74,103.29 C581.1
N26351954: length 1.3
  TOP w0.102: Q45.B 188.3,119.4 R305.1
N26369347: length 0.9
  TOP w0.254: C3645.1 103.25,159.11 R3379.1
N26369876: length 6.1
  BOTTOM w0.102: R3820.2 R3821.1 99.31,161.45 99.64,161.12 99.64,159.69 99.4,159.45 U24.1 97.3,159.45 C3638.2
N26372282: length 2.6
  TOP w0.254: U19.5 64.12,62.67 64.44,63 64.74,63 C231.2 64.69,63.71 R93.1
N26380768: length 1.2
  TOP w0.508: C330.1 89.99,62.96 R409.2
N26383954: length 6.1
  TOP w0.203: U107.5 75.41,59.75 76.07,59.08 C3913.1 76.07,57.31 76.4,56.98 D27.C 76.82,55.78 R966.2
N26385077: length 4
  TOP w0.102: Q128.5 92.91,63.83 93.04,63.96 93.42,63.96 93.56,63.82 Q128.6 93.5,63.19 C1374.1 R828.1
N26385142: length 3.5
  TOP w0.102: Q128.3 91.57,65.87 91.26,65.87 90.59,66.54 R934.1
N26394971: length 5
  TOP w0.102: D26.A 77.94,47.96 76.73,47.96 R963.2 76.45,48.24 C412.2 75.77,49.79 Q96.2
N26464311: length 4
  TOP w0.076: U28.AM47 128.36,22.34 128.6,22.57 128.99,22.57 129.4,22.98 130.92,22.98 131.14,23.19
  TOP w0.102: 131.14,23.19 v1(131.37,23.19)
  BOTTOM w0.102: R146.1 v1(131.37,23.19)
N26464376: length 3.8
  TOP w0.076: U28.AM48 129.22,22.3 129.43,22.09 130.16,22.09 v1(130.63,22.56)
  BOTTOM w0.102: v1(130.63,22.56) 130.68,22.56 131.82,21.42 R102.1
N26527034: length 5.9
  TOP w0.102: Q20.C 88.98,57.36 89.69,56.65 R257.2 89.69,54.77 88.47,53.55 Q19.G
N26527036: length 3.8
  TOP w0.102: R255.1 92.91,57.15 C295.1 92.57,57.17 Q20.B 91.26,56.29 R256.1
N26527291: length 3.9
  TOP w0.102: R1925.1 99.82,51.51 R260.2 99.95,51.64 C248.1 101.36,51.64 Y2.1
N26527487: length 8.2
  TOP w0.102: Q68.G 102.96,43.82 R1920.2
N26530187: length 1.4
  TOP w0.203: C140.2 TP150.1 C141.2
N26544075: length 4.2
  BOTTOM w0.203: C3627.2 119.28,124.77 116.74,124.77 116.15,125.36 U105.12
N26544079: length 1.8
  BOTTOM w0.203: C3625.2 116.71,126.06 116.27,126.06 116.17,126.16 U105.10
N26588054: length 1
  TOP w0.254: C310.2 R223.1
N26588611: length 3.2
  TOP w0.102: R900.2 R897.2 C309.1 48.79,69.04 Q88.5
N26590368: length 0.9
  TOP w0.305: C68.1 R66.1
N26592108: length 1.6
  BOTTOM w0.102: C3616.2 172.16,60.96 172.16,60.28 172.27,60.17 U104.10
N26592112: length 1.6
  BOTTOM w0.102: C3617.2 173.07,60.86 U104.12
N26594780: length 1.4
  BOTTOM w0.102: U106.10 168.78,15.24 168.68,15.14 C3620.2
N26594784: length 1.4
  BOTTOM w0.102: U106.12 169.38,16.05 168.05,16.05 C3621.2
N26604944: length 0.9
  TOP w0.203: R554.1 C166.1
N26604971: length 1
  TOP w0.203: R549.1 C165.1
N26605053: length 0.9
  TOP w0.203: C158.1 R535.1
N26782510: length 5.3
  TOP w0.102: R199.1 R217.2 C653.1 186.26,162 186.5,161.77 Q116.3 186.5,160.37 186.64,160.23 187.02,160.23 187.15,160.35 Q116.2
N27015590: length 1.7
  TOP w0.102: D29.A 136.2,12.4 R299.1
N27015623: length 1.3
  TOP w0.102: D3.2 138.31,11.24 R301.1
N27015645: length 1.4
  TOP w0.102: R302.1 140.87,11.01 D3.1
N27019998: length 4.6
  TOP w0.076: 124.92,13.41 124.92,13.5 124.96,13.54 124.96,15.3 124.88,15.37 124.88,15.58 124.88,15.58 124.88,15.9 124.83,15.94 U28.BE40
  TOP w0.102: 124.92,13.41 124.92,12.93 v1(124.68,12.69)
  BOTTOM w0.102: v1(124.68,12.69) 124.66,12.68 TP50.1
N27250731: length 2.8
  TOP w0.254: R3367.1 R3395.2 C3604.1 R3365.2
N27251032: length 1.3
  TOP w0.254: R3361.1 C3603.1
N27251259: length 1.9
  TOP w0.254: R3368.2 R3402.2 R3385.1
N27441446: length 1.1
  TOP w0.508: R1065.2 C1185.1
N27441743: length 1.9
  TOP w0.508: C1179.1 19.85,148.05 R1054.2
N27442312: length 2
  BOTTOM w0.508: R242.2 25.22,149.87 24.71,150.37 23.95,150.37 C274.1
N27442322: length 1.4
  TOP w0.381: C1180.1 20.22,149.94 R1064.2
N27450736: length 3
  TOP w0.254: R128.2 R2751.1 R2773.2 1.9,110.45 Q129.S
N27450822: length 2.4
  TOP w0.254: R812.1 1.85,104.22 1.35,104.73 1.35,105.44 C559.1
N27450930: length 1.4
  TOP w0.102: R1934.1 Q137.D
N27451075: length 1.3
  TOP w0.508: C540.1 R552.1
N27451111: length 1.2
  TOP w0.508: C665.1 11.07,100.98 R838.1
N27451164: length 1.3
  TOP w0.203: R1125.2 4.32,108.59 R1126.1
N27451174: length 1.9
  TOP w0.203: R1126.2 5.14,110.33 5.14,111.09
  TOP w0.254: 5.14,111.09 4.77,111.46 Q129.D
N27451176: length 1.5
  TOP w0.254: R124.2 R128.1
N27451317: length 4.6
  TOP w0.102: Q137.G 13.6,104.84 C1371.1 R1795.1 12.22,106.96 Q136.D
N27502534: length 2.8
  BOTTOM w0.102: C875.2 R2735.1 R2733.1 79.65,135.28 v3(79.48,135.11)
N27502635: length 6
  TOP w0.4: R2693.2 80.21,145.77 80.83,146.38 Q59.D
N27513223: length 2.8
  BOTTOM w0.102: C876.2 R2736.1 R2734.1 81.02,135.39 v3(81.05,135.36)
N27520900: length 2.7
  BOTTOM w0.102: v3(46,135.33) 45.85,135.49 R2739.1 R2740.1 C878.2
N27541184: length 4
  TOP w0.102: U1.10 6.78,70.79 7.31,71.33 8.46,71.33 8.97,71.83 8.97,72.6 TP4.1
N27541202: length 1.7
  TOP w0.102: TP5.1 3.9,69.53 U1.13
N27541212: length 2.8
  TOP w0.102: U1.16 3.95,67.58 3.63,67.26 3.63,65.61 TP6.1
N27541791: length 1.1
  TOP w0.102: R158.1 166.13,25.59 Q63.G
N27543467: length 3.2
  TOP w0.102: R259.1 R307.2 C435.2 56.13,168.86 Q53.B
N27580537: length 2
  TOP w0.203: C801.1 15.49,72.6 C802.2 15.87,72.98 R973.1
N27581046: length 2
  TOP w0.254: C804.1 R981.1 C805.2
N27581205: length 1.9
  TOP w0.254: C807.2 R982.1 C806.1
N27581374: length 1.9
  TOP w0.254: C809.2 C808.1 R983.1
N27588103: length 1.4
  TOP w0.508: C1219.1 148.77,153.66 R581.2
N27591192: length 1.2
  TOP w0.508: R579.2 132.93,154.79 C1216.1
N27607596: length 1.4
  TOP w0.508: R580.2 140.56,153.68 C1217.1
N27608201: length 1.2
  TOP w0.508: C1220.1 R582.2
N27609663: length 1.3
  TOP w0.508: C1221.1 159.46,149.61 159.83,149.24 R583.2
N27618113: length 1.9
  TOP w0.102: U16.1 189.18,160.73 R248.2
N27618129: length 2.1
  TOP w0.508: U16.3 R214.2
N27698754: length 1
  TOP w0.254: R955.1 24.54,110.52 C2552.1
N27698937: length 2.9
  TOP w0.254: R992.1 C2549.2 23.62,110.57 C2552.2 R957.2
N27699396: length 1.1
  TOP w0.254: C2553.1 22.1,110.32 R994.1
N27699400: length 4
  TOP w0.254: R1002.2 20.75,108.36 R952.2 C2553.2 21.18,110.34 R996.1 C2550.1
N27823376: length 1.8
  BOTTOM w0.102: D30.A 165.56,15.14 R557.2
N27824089: length 14.9
  TOP w0.254: 83.15,163.29 82.91,163.53 80.59,163.53 80.15,163.08 LT2.1 ; 83.15,163.29 83.51,163.66 85.86,163.66 86.15,163.37 ; 83.15,163.29 LT2.4 ; 86.15,163.37 LT2.7 ; 86.15,163.37 86.44,163.66 88.97,163.66 89.15,163.48 LT2.10 89.15,160.87 C529.1
N27824103: length 12.5
  TOP w0.508: R625.2 90.06,173.52 89.71,173.86 88.11,173.86 87.31,173.06 R626.2 86.83,173.12 86.83,173.3 86.38,173.75 85.16,173.75 R627.2 84.47,173.16 83.89,173.74 83.17,173.74 82.69,173.26 ; 82.69,173.26 82.69,173.27 81.37,174.59 C629.1 ; 82.69,173.26 R624.2
N27824173: length 2.7
  TOP w0.508: R624.1 80.46,173.06 80.15,172.75 LT2.24
N27824188: length 1.4
  TOP w0.508: LT2.21 83.15,172.48 83.56,172.89 R627.1
N27824214: length 1.3
  TOP w0.508: R626.1 86.15,172.88 LT2.18
N27824236: length 1.3
  TOP w0.508: LT2.15 89.14,171.8 R625.1
N27866744: length 3.9
  BOTTOM w0.254: CN12.24 9.88,60.86 v3(10.26,61.24) 10.14,61.36 CN12.25
  BOTTOM w0.508: v3(10.26,61.24) 10.84,61.83 R3721.1
N27867045: length 13.8
  BOTTOM w0.203: R3627.1 R3628.1 16.71,57.41 16.71,55.32 v3(17.04,54.99) 17.04,54.77 14.14,51.86 CN12.6
N27867078: length 15.2
  BOTTOM w0.114: R3710.1 11.17,47.2 9.64,47.2 6.18,50.65 6.18,56.08 6.97,56.86 CN12.16
N27867098: length 15.2
  BOTTOM w0.114: CN12.15 8.44,56.36 8.18,56.62 7.07,56.62 6.43,55.98 6.43,55.64 6.55,55.51 6.55,55.17 6.43,55.04 6.43,54.7 6.55,54.58 6.55,54.23 6.43,54.11 6.43,53.77 6.55,53.64 6.55,53.3 6.43,53.17 6.43,52.83 6.55,52.71 6.55,52.36 6.43,52.24 6.43,50.75 9.01,48.17 9.19,48.17 9.43,47.92 9.43,47.75 9.74,47.44 10.78,47.44 R3711.1
N27873712: length 1.7
  TOP w0.114: CNKB1.34 117.76,4.82 117.6,4.98 117.6,5.82 R139.2
N27873763: length 3.5
  TOP w0.102: CNKB1.32 118.76,6.04 R122.2 118.37,6.55 118.37,7.74 v4(118.44,7.8)
N27873827: length 1.7
  TOP w0.114: CNKB1.35 117.26,4.87 117.36,4.97 117.36,5.73 R153.2
N27875269: length 6.3
  BOTTOM w0.102: R687.2 122.5,170.21 C198.1 122.33,171.38 SW5.1 121.89,171.68 Q55.D 119,170.13 R16.1
N27875273: length 6.3
  BOTTOM w0.102: Q55.G 120.47,167.85 119.12,169.19 R3654.2 115.85,169.19 Q183.D
N27876704: length 192.9
  TOP w0.102: v1(168.35,12.27) 167.97,11.89 165.3,11.89 164.29,12.91 162.38,12.91 161.62,12.14 Q48.D ; v1(181.43,161.88) 181.3,162 R222.1 180.78,162.56 Q50.G
  L3_IN1 w0.089: v1(189.43,40.3) 187.87,40.3 187.78,40.39 187.78,40.78 184.79,43.77 183.84,43.77 183.2,44.41 183.2,47.91 184.76,49.46 184.76,58.62 191.45,65.31 191.45,76.38 192.13,77.07 192.13,92.63 190.78,93.98 190.78,97.64 192.88,99.74 192.88,102.59 193.53,103.23 193.53,133.87 191.3,136.09 191.3,138.51 192.35,139.56 192.35,147.65 191.75,148.26 191.75,149.83 192.63,150.7 192.63,154.59 192.27,154.95 192.27,155.93 192.03,156.16 190.7,156.16 187.53,159.34 187.53,160.61 186.26,161.88 v1(181.43,161.88)
  L6_IN2 w0.089: v1(168.35,12.27) 168.55,12.47 175.03,12.47 178.59,16.03 178.59,18.85 189.96,30.22 189.96,39.77 v1(189.43,40.3)
N27876766: length 25.8
  TOP w0.102: v1(181.96,167.31) 182.19,167.08 R31.1 182.69,165.78 C13.1
  BOTTOM w0.102: v1(181.96,167.31) 181.96,167.24 180.8,166.07 168.48,166.07 166.58,167.96 SW6.2 SW6.1
N27877142: length 3
  TOP w0.102: R3723.2 C4114.1 174.5,156.47 173.81,155.78 Q190.G
N27877177: length 10.1
  TOP w0.102: R3724.2 180.66,165.24 Q54.G 179.77,165.24 v1(179.3,164.77) ; Q49.D v1(186.16,164.77)
  L8_IN3 w0.089: v1(186.16,164.77) v1(179.3,164.77)
N27877224: length 19.7
  TOP w0.102: v1(173.18,163.27) 173.23,163.22 C738.1 173.91,163.33 R653.2
  BOTTOM w0.102: v1(173.18,163.27) 171.65,164.8 161.62,164.8 158.5,167.91 LED2.A
N27877504: length 2.8
  TOP w0.102: R3625.2 28.7,161.75 C445.1 27.88,162.44 Q182.B
N27877536: length 5.2
  BOTTOM w0.102: R586.2 21.57,158 LED4.A
N27877746: length 3.1
  TOP w0.102: v1(174.57,162.26) 174.9,162.59 C15.1 R5.1
  BOTTOM w0.102: LED1.3 174.74,162.43 v1(174.57,162.26)
N27877768: length 3.3
  TOP w0.102: R13.2 v1(175.84,158.19)
  BOTTOM w0.102: v1(175.84,158.19) 176.04,158.39 LED1.2
N27877784: length 3
  TOP w0.102: v1(177.06,162.33) 176.73,162.33 C4.1 176.61,162.72 R15.1
  BOTTOM w0.102: v1(177.06,162.33) 176.97,162.43 LED1.1
N27877788: length 3.9
  TOP w0.102: v1(175.18,159.94) 174.52,159.29 R10.2
  BOTTOM w0.102: LED1.4 v1(175.18,159.94)
N27961480: length 3.8
  TOP w0.203: v1(17.35,69.93) 17.6,69.93 17.91,70.23 R993.1
  BOTTOM w0.203: U721.11 17.75,69.64 17.46,69.93 v1(17.35,69.93) 17.22,70.06 R997.1 R999.1
N27962552: length 6.2
  TOP w0.203: C2551.1 17.42,72.67 v1(17.6,72.85) 17.6,72.72 18.24,72.09 R993.2
  BOTTOM w0.203: R988.2 15.08,72.72 15.54,73.18 16.38,73.18 16.79,72.77 C544.2 17.47,72.72 v1(17.6,72.85)
N27962987: length 1
  BOTTOM w0.203: R997.2 15.44,70.06 15.26,70.23 C2554.2
N27963579: length 5.2
  BOTTOM w0.203: C2555.1 15.62,69.42 14.93,69.42 14.43,69.93 14.43,70.44 13.92,70.95 R959.1 14.86,71.02 C2554.1 15.19,70.95 R999.2
N28420063: length 3.6
  TOP w0.102: v4(103.73,7.93) 103.78,7.88 R3716.2 R3521.1 105.85,7.51 CN17.9
N28420086: length 2.8
  TOP w0.102: CN17.6 107.35,7.28 107.26,7.37 R1000.1 107.49,8.11 v4(108.18,8.11)
N28420111: length 4
  TOP w0.102: CN17.7 106.85,7.4 R940.1 105.92,8.33 105.92,9.2 v4(106.3,9.58)
N28421453: length 3.9
  TOP w0.102: CN18.1 150.6,8.11 150.87,8.38 150.87,9.25 C492.1 150.55,9.79 L51.1
N28421455: length 4.1
  TOP w0.102: L51.4 151.35,9.92 C493.1 151.08,9.17 151.08,8.46 151.6,7.94 CN18.2
N28421527: length 1.7
  TOP w0.102: L48.4 154.4,7.45 CN18.5
N28421551: length 1.6
  TOP w0.102: CN18.4 153.6,7.25 L48.1
N28421578: length 2.4
  TOP w0.508: CN18.6 155.6,8.69 C294.1 R235.2
N28458362: length 6.5
  BOTTOM w0.102: Q161.D 154.89,4.32 R3520.2 154.27,3.95 Q160.G Q162.G
N28458364: length 52.5
  L3_IN1 w0.508: v1(147.65,1.48) 146.76,2.37 126.31,2.37 125.2,1.25 103.05,1.25 v1(102.31,1.98)
  BOTTOM w0.508: v1(102.31,1.98) 102.18,1.86 R3519.2 ; v1(147.65,1.48) Q162.D Q160.D
N28458368: length 2.3
  BOTTOM w0.102: Q161.G 157.82,3.31 C3903.1 R3518.1
N28459330: length 7.9
  BOTTOM w0.102: Q159.G Q157.G 142.57,3.25 142.82,3 Q158.D 143.97,4.96 R3517.2
N28459365: length 41
  L3_IN1 w0.508: v1(103.45,1.98) 104.22,2.75 110.69,2.75 111.45,3.51 121.74,3.51 v1(122.38,2.87)
  BOTTOM w0.508: R3516.2 102.06,3.25 103.33,1.98 v1(103.45,1.98) ; Q157.D Q159.D 125.93,3 125.04,2.11 122.88,2.11 122.38,2.62 v1(122.38,2.87)
N28459409: length 2
  BOTTOM w0.102: Q158.G R3515.1 C3901.1
N28460272: length 7.9
  BOTTOM w0.102: R662.2 111.2,3.74 Q70.D 110.04,3 Q69.G 108.9,4.14 105.96,4.14 Q71.G
N28460315: length 5.9
  BOTTOM w0.508: R664.2 102.21,4.65 Q71.D 106.22,3.58 Q69.D
N28460401: length 2.3
  BOTTOM w0.102: R661.1 C2746.1 112.09,4.61 Q70.G
N28460991: length 1.3
  TOP w0.102: Q66.D 173.1,10.06 R2667.1
N28460993: length 2
  TOP w0.102: Q66.G C2745.1 R2665.1
N28461285: length 8.8
  BOTTOM w0.102: v3(85.75,158.25) 86.66,158.25 R3693.2 86.82,159.57 86.31,160.07 86.31,160.99 85.29,162 84.28,162 ; 84.28,162 84.28,162.26 84.14,162.4 CN41.2 ; 84.28,162 84.17,161.9 CN41.1
N28461351: length 2.4
  BOTTOM w0.102: Q188.D 88.39,157.48 R3693.1
N28461365: length 2.3
  BOTTOM w0.102: R3692.1 C4094.1 90.56,156.42 Q188.G
N28475358: length 3.2
  TOP w0.102: R95.1 R96.2 C290.2 96.29,25.87 Q51.B
N28637804: length 5.3
  BOTTOM w0.102: Q148.G 106.41,8.69 107.68,8.69 108.77,9.78 C299.1 109.09,9.73 R258.2
N28935332: length 5.7
  TOP w0.076: v1(125.05,37.98) 124.68,37.6 124.68,37.27 124.72,37.22 124.72,37.02 U28.B40
  BOTTOM w0.114: v1(125.05,37.98) 125.05,37.97 124.99,37.91 124.84,37.91 124.77,37.84 123.1,37.84 122.63,37.37 121.49,37.37 121.31,37.54 C241.2
N28935334: length 5.7
  TOP w0.076: U28.C40 124.94,36.54 124.94,37.32 v1(125.04,37.42)
  BOTTOM w0.114: C242.2 121.31,36.66 121.78,37.13 122.73,37.13 123.2,37.6 124.74,37.6 124.85,37.49 124.93,37.49 125,37.42 v1(125.04,37.42)
N29198335: length 2.3
  TOP w0.254: R228.2 189.68,97.38 v1(189.68,96.85) U9.3
  BOTTOM w0.381: v1(189.68,96.85) 190.12,96.42 R69.1
N116328469: length 2.8
  BOTTOM w0.102: U5.12 164.26,22.71 164.41,22.56 165.1,22.56 C168.1
N174219019: length 2.1
  TOP w0.102: R319.1 R337.1 54.76,54.38 U2.3
N174219031: length 2
  TOP w0.102: U2.4 57.4,54.62 R348.2 R319.2
N179219122: length 1.4
  BOTTOM w0.381: C76.1 R45.1
N190033853: length 2.8
  BOTTOM w0.102: C72.1 R40.1 130.73,81.66 v3(129.97,82.43)
N190076837: length 1.8
  TOP w0.102: TP184.1 83.7,7.77 CNWLAN1.16
N190076855: length 1.9
  TOP w0.102: CNWLAN1.44 v1(90.7,10.69)
  BOTTOM w0.102: TP185.1 90.68,10.67 v1(90.7,10.69)
N190076857: length 2.9
  TOP w0.102: v1(90.7,11.38) 91.2,10.88 CNWLAN1.46
  BOTTOM w0.102: TP186.1 91.24,11.92 v1(90.7,11.38)
N190076859: length 2.6
  TOP w0.102: TP187.1 90.81,7.9 91.7,8.79 CNWLAN1.48
N192354995: length 1.7
  TOP w0.254: Q113.3 67.27,162.24 R912.2
N192365706: length 1.6
  TOP w0.102: D41.1 55.75,165.05 R494.1
N192948383: length 2
  TOP w0.203: C3579.1 61.35,42.14 U97.24
N192948531: length 1.7
  TOP w0.203: R3319.2 65.1,38.38 U97.4
N192948533: length 1.7
  TOP w0.203: U97.3 64.7,39.05 64.46,38.81 R3322.2
N192948565: length 77.6
  TOP w0.508: v1(66.5,35.39) 67.27,34.61 R3321.1 ; Q8.4 16.59,53.29 16.71,53.17 v1(18.74,53.17)
  L6_IN2 w0.508: v1(66.5,35.39) 66.45,35.43 66.45,35.69 65.02,37.11 63.96,37.11 62.87,36.02 58.37,36.02 57.61,36.78 57.23,36.78 53.92,40.08 14.68,40.08 13.41,41.35 13.41,47.83 v1(18.74,53.17)
N192948575: length 2
  TOP w0.203: U97.18 65.1,45.6 R3327.1
N192948802: length 5.4
  TOP w0.203: R3299.1 71.37,40.59 69.8,40.59 69.47,40.26 C3557.2 68.02,40.08 67.57,40.54 U97.8
N192948836: length 1.2
  TOP w0.508: R3312.1 C3543.1
N192950176: length 2.1
  TOP w0.203: R3336.1 65.86,45.16 65.5,44.8 U97.17
N192950201: length 2
  TOP w0.203: R3330.1 61.37,41.74 U97.25
N192950211: length 0.9
  TOP w0.254: C3541.1 R3330.2
N193847777: length 1.4
  TOP w0.203: D28.3 61.37,38.05 R3331.1
N193982561: length 3.7
  TOP w0.203: R3335.1 68.15,45.47 67.46,44.78 66.24,44.78 65.9,44.44 U97.16
N194433908: length 5.1
  TOP w0.102: R495.2 54.18,164.54 55.45,165.81 57.54,165.81 D41.2

## Copper pours and planes (outline as drawn)
1V8_AON on TOP (solid shape): 73.85,65.37 73.85,63.71 74.14,63.42 74.14,63.36 74.38,63.12 74.38,62.55 74.38,62.55 74.38,62.28 74.23,62.13 72.14,62.13 71.58,62.69 71.58,65.23 71.96,65.61 73.61,65.61
1V8_AON on BOTTOM (solid shape): 89.75,89.68 89.75,89.21 89.68,89.14 89.57,89.16 89.52,89.21 89.52,89.22 88.93,89.49 88.97,88.85 88.97,86.95 88.98,86.95 89.23,86.69 89.48,86.69 89.61,86.57 89.61,86.06 89.48,85.93 88.72,85.93 88.43,86.23 88.43,87.17 88.55,87.3 88.55,88.17 88.43,88.29 87.92,88.29 87.87,88.34 87.87,89.68 88.01,89.82 88.54,89.82 88.81,90.08 89.34,90.08
1V8_AON on L5_VCC2: 72.52,61.34 72.21,61.65 72.21,64.52 73.49,65.79 73.49,65.92 72.21,65.92 72.21,66.88 80.52,66.88 88.85,75.21 88.85,78.27 89.35,78.77 95.96,78.77 99.32,82.12 102.31,82.12 103,81.43 103,71.33 102.03,70.36 92.98,70.36 89.41,66.78 89.41,62.08 88.67,61.34
1V8_MAIN on TOP (solid shape): 81.47,69.21 81.47,62.33 81.25,62.11 78.16,62.11 78.05,62.22 75.73,62.22 75.68,62.27 75.68,63.16 75.74,63.23 75.74,63.59 76.29,64.13 76.29,66.55 79.08,69.34 81.34,69.34
1V8_MAIN on TOP (solid shape): 87.6,88.18 87.6,87.41 87.23,87.04 87.15,87.01 87.08,86.96 86.31,86.96 86.2,87.03 86.08,87.06 86.07,87.06 85.92,87.2 85.9,87.25 85.88,87.28 85.88,87.44 85.95,87.56 85.65,88.16 85.34,87.56 85.42,87.44 85.42,87.28 85.4,87.26 85.05,86.91 84.82,86.91 84.7,87.03 84.42,87.03 84.3,86.91 84.16,86.91 84.07,87.02 83.94,87.09 83.93,87.1 83.83,87.2 83.8,87.25 83.78,87.28 83.78,87.44 83.85,87.56 83.55,88.16 83.24,87.56 83.32,87.44 83.32,87.28 83.3,87.26 83.1,87.06 83.08,87.05 82.93,87 82.82,86.88 82.13,86.88 82.13,86.89 82.01,87.04 81.83,87.11 81.82,87.11 81.73,87.2 81.7,87.25 81.67,87.28 81.67,87.44 81.75,87.56 81.82,87.85 81.65,88.1 81.65,88.21 81.8,88.36 87.42,88.36
1V8_MAIN on TOP (solid shape): 90.16,102.64 90.16,102.49 90.13,102.48 89.97,102.34 89.93,102.15 89.91,102.07 89.83,102.03 89.74,102.01 89.67,101.96 89.41,101.96 88.83,101.78 89.41,101.6 89.67,101.6 89.94,101.55 90.1,101.77 90.13,101.84 90.21,101.87 90.27,101.86 90.64,101.49 90.64,101.46 90.65,101.26 90.78,101.11 90.78,100.88 90.53,100.63 90.52,100.63 90.45,100.61 90.39,100.58 90.27,100.58 90.05,100.36 90.05,100.33 90.03,100.32 89.95,100.19 89.93,100.05 89.91,99.97 89.83,99.93 89.74,99.91 89.67,99.86 89.41,99.86 88.83,99.68 89.41,99.5 89.67,99.5 89.94,99.45 90.1,99.67 90.13,99.74 90.21,99.77 90.27,99.76 90.33,99.77 90.48,99.77 90.55,99.79 90.62,99.83 90.68,99.85 90.75,99.83 90.79,99.81 90.84,99.73 90.81,99.65 90.77,99.61 90.77,99.55 90.63,99.28 90.77,99.02 90.77,98.8 90.5,98.53 90.48,98.53 90.37,98.46 90.3,98.34 90.3,98.33 90.27,98.3 90.25,98.3 89.99,98.18 89.94,97.9 89.95,97.87 89.91,97.83 89.88,97.83 89.79,97.83 89.71,97.79 89.7,97.79 88.83,97.79 88.56,98.06 88.56,102.49 88.87,102.8 90,102.8
1V8_MAIN on BOTTOM (solid shape): outline of 198 points within 81.6,86.29 87.59,89.09
1V8_MAIN on BOTTOM (solid shape): outline of 206 points within 87.9,97.16 90.5,102.74
1V8_MAIN on L6_IN2: outline of 298 points within 84.94,85.4 91.13,103.05
1V8_MAIN on L8_IN3: 82.71,80.87 82.7,80.88 82.7,88.17 82.84,88.31 88.02,88.31 88.57,87.76 88.57,87.05 88.52,87.01 88.48,86.96 88.4,86.91 88.31,86.96 87.73,86.78 88.31,86.61 88.4,86.65 88.48,86.61 88.52,86.56 88.57,86.52 88.57,84.36 88.11,83.9 88.11,79.87 87.7,79.46 87.7,74.37 86.94,73.61 86.94,70.68 83.09,66.83 78.75,66.83 78.15,67.43 78.15,69.78 82.71,74.33
+0.6V_DDR on BOTTOM: outline of 117 points within 114.11,65.26 123.66,82.86
+1.00V_CPU on BOTTOM (solid shape): 117.63,127.66 117.63,126.52 117.5,126.39 116.4,126.39 116.38,126.41 115.26,126.41 115.17,126.51 115.17,127.24 115.31,127.38 115.75,127.38 116.18,127.82 117.47,127.82
+1.00V_CPU on L8_IN3: 124.03,130.51 126.06,128.48 126.06,126.57 125.55,126.06 116.41,126.06 116.15,126.32 116.15,129.11 117.55,130.51
+1.0VA_PCH on BOTTOM (solid shape): 113.96,124.99 113.96,124.45 114.04,124.36 115.15,124.36 115.28,124.23 115.28,123 114.78,122.5 112.95,122.5 112.83,122.62 112.83,125 112.91,125.08 113.87,125.08
+1.0VA_PCH on BOTTOM (solid shape): 115.06,128.02 115.06,127.36 114.86,127.16 114,127.16 113.93,127.09 113.93,126.49 113.86,126.42 112.99,126.42 112.85,126.56 112.85,127.41 112.85,127.94 113.23,128.32 114.76,128.32
+1.0VA_PCH on TOP: 118.54,27.77 119.69,27.77 120.86,26.6 120.86,24.78 120.72,24.64 120.52,24.64 120.15,25 119.69,25 119.62,24.93 119.33,24.93 119.24,25.02 119.24,25.53 119.29,25.58 119.29,25.95 118.95,26.29 118.55,26.29 118.44,26.17 118.44,25.23 118.13,24.92 117.77,24.92 117.7,24.99 117.7,26.93
+1.0VA_PCH on TOP: 117.82,30.14 120.24,30.14 120.82,29.56 120.82,28.35 120.72,28.25 120.63,28.25 120.41,28.04 120.06,28.04 120,28.09 120,28.44 120.13,28.56 120.13,28.81 120.03,28.9 119.68,28.9 119.61,28.82 119.34,28.82 119.26,28.91 118.96,28.91 118.86,28.8 118.59,28.8 118.49,28.9 118.17,28.9 118.08,28.82 117.75,28.82 117.69,28.88 117.4,28.88 117.23,28.71 117.09,28.71 116.91,28.53 116.68,28.53 116.56,28.65 116.25,28.65 116.1,28.51 115.93,28.51 115.85,28.59 115.85,28.75 116.1,29 116.1,29.2 116.51,29.61 117.29,29.61
+1.0VA_PCH on TOP: 115.89,28.08 116.06,28.08 116.2,27.94 116.56,27.94 116.69,28.07 116.85,28.07 117.02,27.9 117.17,27.9 117.43,27.64 117.43,27.45 116.93,26.94 116.93,25.51 116.8,25.38 116.8,25.17 116.56,24.93 116.25,24.93 116.14,25.04 116.14,25.34 116.26,25.46 116.26,25.68 116.12,25.82 116.12,26.09 116.23,26.2 116.23,26.49 116.12,26.6 115.85,26.6 115.62,26.37 115.54,26.37 115.44,26.27 114.91,26.27 114.56,26.63 114.56,26.9 114.81,27.15 114.95,27.15 115.1,27.31 115.3,27.31 115.42,27.18 115.81,27.18 115.99,27.37 115.99,27.6 115.8,27.8 115.8,27.98
+1.0VA_PCH on TOP: 95.96,32.46 92.52,32.46 92.26,32.72 92.26,40.48 92.71,40.93 105.28,40.93 105.61,40.59 105.61,39.67 105.61,39.67 105.61,38.56 105.51,38.32 105.6,38.07 105.61,38.06 105.86,37.81 105.86,37.79 105.91,37.51 106.19,37.45 106.2,37.45 106.48,37.45 106.49,37.45 106.59,37.43 106.69,37.45 106.7,37.45 106.95,37.45 107.01,37.39 107.01,37.1 106.91,37 106.5,37 106.4,36.91 106.4,36.5 106.35,36.45 106.33,36.45 106.27,36.43 106.2,36.4 106.19,36.4 106.05,36.4 105.84,36.61 105.66,36.61 104.48,37.79 104.47,37.79 104.09,38.17 104.09,39.2 103.71,39.58 102.07,39.58 102.06,39.57 101.29,39.57 97.48,35.77 97.48,33.99
+1.0VA_PCH on BOTTOM: 113.58,29.64 120.56,29.64 121.63,28.56 121.63,25.93 120.7,25 117.65,25 117.43,24.78 117.43,24.26 117.16,23.99 115.64,23.99 115.23,24.4 115.23,25.53 114.56,25.53 114.31,25.28 113.58,25.28 113.07,25.79 113.07,29.12
+1.0VA_PCH on L3_IN1: 92.94,41.79 97.87,41.79 99.24,40.42 99.24,33.69 97.94,32.39 97.94,26.95 100.21,24.68 109.05,24.68 111.38,27 112.86,27 113.27,27.42 113.27,28.39 114.56,29.68 118.39,29.68 118.63,29.44 120.84,29.44 121.44,28.83 121.44,23.57 121.4,23.53 121.4,20.75 120.8,20.15 120.8,19.03 117.98,16.21 111.17,16.21 107.8,12.83 94.72,12.83 90.68,16.87 90.68,39.53
+1.0VA_PCH on L4_VCC1: 89.72,12.78 87.45,15.17 87.45,40.72 88.32,41.58 97.68,41.58 98.63,40.64 98.63,34.22 97.23,32.82 97.23,26.77 99.67,24.34 110.67,24.34 114.5,28.17 114.5,30.35 116.72,32.57 117.45,32.57 121.51,28.5 121.51,20.33 119,17.81 118.84,17.76 114.9,17.73 111.98,14.81 109.06,14.81 107.03,12.78
+1.0VA_PCH on L6_IN2: 115.01,127.97 116.03,127.97 119.63,124.36 119.63,116.46 114.38,111.2 114.12,111.2 110.95,108.03 110.95,91.01 108.79,88.85 108.79,78.18 106.76,76.15 106.76,64.85 112.6,59.01 112.6,45.29 117.04,40.85 117.04,33.48 121.11,29.42 121.11,24.84 120.73,24.46 113.36,24.46 107.9,29.92 107.9,44.53 110.06,46.69 110.06,49.61 109.93,49.74 109.93,55.83 105.49,60.28 105.49,61.42 104.72,62.18 104.72,78.31 106.37,79.96 106.37,89.11 109.04,91.77 109.04,108.92 113.87,113.74 113.87,126.83
+1.0VA_PCH on L8_IN3: 115.17,128.01 115.55,128.01 116.08,127.49 116.08,123.5 116.48,123.09 117.63,123.09 118.44,123.9 119.35,123.9 119.73,123.52 119.73,121.72 118.95,120.93 115.21,120.93 114.26,121.88 114.26,124.42 114.55,124.72 114.55,128.22 114.68,128.35 114.83,128.35
+1.00VS_CPU on BOTTOM (solid shape): 116.66,124.54 117.52,124.54 117.63,124.44 117.63,123.45 117.52,123.34 115.73,123.34 115.43,123.64 115.43,124.29 115.25,124.48 115.25,125.04 115.28,125.07 116.13,125.07
+1.00VS_CPU on BOTTOM: 127.41,125.23 130.63,125.23 130.76,125.1 130.76,123.73 130.4,123.37 127.18,123.37 126.85,123.7 126.85,124.67
+1.00VS_CPU on L8_IN3: 126.49,125.22 126.49,124.12 125.66,123.29 120.38,123.29 119.58,124.08 118.29,124.08 117.47,123.27 116.66,123.27 116.28,123.65 116.28,124.79 117.21,125.72 125.99,125.72
+1.0VS_LAN on TOP: 98.37,47.2 102.89,47.2 103.28,46.82 103.28,45.16 102.89,44.78 99.39,44.78 98.47,45.7 98.37,45.7 98.14,45.93 98.14,46.97
+1.0VS_LAN on L8_IN3: 96.42,55.95 98.03,54.34 98.03,49.33 99.7,47.66 99.7,45.26 99.51,45.06 96.69,45.06 95.86,45.89 95.86,52.58 95.83,52.61 95.83,52.63 95.72,52.93 95.42,53.04 95.4,53.04 95.3,53.13 92.64,53.13 92.63,53.14 92.18,53.14 91.97,53.35 91.97,53.37 91.95,53.46 91.91,53.55 91.47,53.98 91.47,55.24 92.18,55.95
+1.2VS on TOP (solid shape): 154.14,91.62 154.14,90.48 154.01,90.35 138.14,90.35 138.01,90.48 138.01,91.62 138.14,91.75 154.01,91.75
+1.2VS on BOTTOM (solid shape): 153.88,68.13 153.88,65.33 153.38,64.82 142.59,64.82 141.81,65.59 141.81,65.62 141.71,65.86 141.48,65.99 141.46,65.99 141.22,66.23 141.17,66.23 140.87,66.54 139.44,66.54 139.26,66.71 139.26,68.08 139.43,68.25 153.76,68.25
+1.2VS on L8_IN3 (solid shape): outline of 1887 points within 125.44,106.74 150.58,111.17
+1.2VS on TOP: 178.89,103.08 178.7,102.89 172.35,102.89 171.53,103.71 171.53,111.33 172.92,112.73 178.51,112.73 178.89,112.35
+1.2VS on BOTTOM: outline of 358 points within 125.77,106.13 152,111.83
+1.2VS on L6_IN2: 181.04,66.4 180.59,65.95 170.16,65.95 163.17,58.96 122.55,58.96 119.98,61.53 119.98,75.63 118.82,76.79 118.82,78.18 119.84,79.2 119.84,88.73 118.57,90 118.57,91.36 119.2,92 121.92,92 124.76,94.84 124.76,104.71 124.83,104.81 124.94,104.78 125.57,104.88 125.23,105.42 125.7,105.89 125.7,107.83 126.47,108.59 126.47,111.1 126.69,111.33 162.61,111.33 164.01,109.93 165.71,109.93 167.36,108.28 170.08,108.28 170.64,108.84 170.64,109.78 170.65,109.79 170.65,110.84 172.03,112.22 176.48,112.22 178.13,110.57 178.13,93.04 181.04,90.13 181.04,88.32 181,88.31 180.72,87.94 181,87.57 181.04,87.56
+1.8VA on TOP (solid shape): 77.85,60.73 77.85,59.72 77.7,59.57 75.96,59.57 75.68,59.85 75.68,60.87 75.7,60.9 77.69,60.9
+1.8VA on TOP (solid shape): 74.36,60.86 74.36,59.79 74.29,59.73 74.29,59.72 74.12,59.54 72.45,59.54 72.35,59.65 72.35,60.83 72.42,60.91 74.31,60.91
+1.8VA on TOP (solid shape): 70.48,62.18 70.48,60.15 70.23,59.9 69.59,59.9 69.34,59.64 69.34,58.5 69.09,58.25 66.8,58.25 66.29,57.74 65.78,57.74 65.66,57.86 65.66,59.39 65.78,59.52 66.29,59.52 66.8,60.02 66.8,62.44 67.18,62.82 69.85,62.82
+1.8VA on BOTTOM: 68.78,62.06 77.55,62.06 78.05,61.55 78.05,59.01 77.8,58.75 69.16,58.75 68.53,59.39 68.53,61.8
+1.8VA_PCH on BOTTOM: 114.64,23.49 115.17,24.02 115.17,24.63 114.94,24.87 113.05,24.87 112.15,23.96 112.15,23.96 111.45,23.26 111.45,21.16 111.2,20.91 109.17,20.91 108.91,20.65 108.91,20.02 109.17,19.76 109.8,19.76 109.93,19.64 109.93,17.35 110.06,17.22 112.72,17.22 112.98,17.48 112.98,22.46 114.01,23.49
+2.5VS on TOP (solid shape): 114.8,88.42 114.99,88.42 114.99,90.18 115.3,90.18 115.3,88.42 115.33,88.42 115.33,87.72 115.06,87.45 114.16,87.45 113.85,87.75 113.85,90.11 113.92,90.18 114.8,90.18
+2.5VS on TOP (solid shape): 115.4,78.21 115.4,77.46 115.39,77.44 115.39,77.28 115.3,77.28 115.3,75.63 115.23,75.56 114.99,75.56 114.99,77.28 114.8,77.28 114.8,75.56 114.03,75.56 113.87,75.72 113.87,78.43 113.89,78.46 113.94,78.47 113.99,78.48 115.13,78.48
+2.5VS on TOP: 184.77,107.71 185.14,107.71 185.24,107.61 185.24,106.31 185.47,106.08 185.85,106.08 186.2,105.73 186.2,105.09 185.64,104.53 185.64,104.16 185.57,104.09 184.5,104.09 184.43,104.17 184.43,106.01 184.67,106.25 184.67,107.61
+2.5VS on BOTTOM: 108.41,68.47 108.41,88.47 108.58,88.65 114.32,88.65 114.6,88.37 114.6,87.73 114.17,87.3 114.07,87.3 113.77,87 113.77,86.5 113.73,86.42 113.65,86.4 112.84,86.31 112.26,85.74 112.18,85.52 112.14,85.28 112.57,84.26 113.64,84 113.73,83.98 113.77,83.9 113.77,80.01 115.48,78.3 115.48,70.91 115.01,70.44 115.01,66.35 114.27,65.61 111.27,65.61
+2.5VS on L3_IN1: 184.05,105.87 186.38,105.87 186.51,105.74 186.51,104.98 186,104.47 183.84,104.47 183.59,104.73 183.59,105.41
+3.3V on TOP (solid shape): 59.13,160.61 59.13,159.34 59,159.21 56.34,159.21 55.96,159.59 55.96,160.48 56.21,160.73 59,160.73
+3.3V on TOP (solid shape): 160.22,31.19 160.22,29.16 159.84,28.78 156.79,28.78 156.41,29.16 156.41,31.45 159.97,31.45
+3.3V on TOP (solid shape): 168.99,14.94 168.99,13.16 168.86,13.03 167.97,13.03 167.84,12.91 166.83,12.91 166.7,13.03 166.7,14.94 166.95,15.19 168.73,15.19
+3.3V on TOP (solid shape): 181.3,31.32 181.3,28.4 181.18,28.27 179.15,28.27 178.56,28.86 178.56,29.64 178.66,29.75 179.3,29.75 179.4,29.85 179.4,31.52 179.45,31.58 181.05,31.58
+3.3V on TOP (solid shape): 143.74,31.65 143.74,29.1 142.78,28.15 139.01,28.15 138.76,28.4 138.76,31.32 139.01,31.58 140.03,31.58 140.16,31.45 140.16,29.8 140.28,29.67 141.75,29.67 141.93,29.86 141.93,31.61 142.05,31.73 143.66,31.73
+3.3V on TOP (solid shape): 166.72,31.65 166.72,29.8 167.21,29.31 167.21,28.53 166.83,28.15 162.13,28.15 161.87,28.4 161.87,31.32 162.13,31.58 163.02,31.58 163.14,31.45 163.14,29.8 163.27,29.67 164.73,29.67 164.92,29.86 164.92,31.61 165.04,31.73 166.65,31.73
+3.3V on TOP (solid shape): 85.04,158.45 85.04,157.31 84.78,157.05 83.89,157.05 83.56,157.06 83.39,156.77 83.36,156.7 83.28,156.67 81.99,156.67 81.61,157.05 81.61,158.32 81.74,158.45 82.24,158.45 82.63,158.83 84.66,158.83
+3.3V on BOTTOM: 56.72,163.27 80.59,163.27 83.01,160.86 83.01,159.97 84.02,158.96 84.91,158.96 85.17,158.7 85.17,157.56 84.53,156.92 83.39,156.92 82.98,156.52 82.98,155.86 82.83,155.71 81.86,155.71 81.61,155.96 81.61,157.89 80.92,158.58 80.21,158.58 79.83,158.19 78.43,158.19 76.78,159.85 70.94,159.85 69.54,161.24 63.83,161.24 62.43,159.85 56.21,159.85 55.7,160.35 55.7,162.26
+3.3V on BOTTOM: 118.44,12.27 121.61,12.27 121.87,12.02 122.45,12.02 122.74,12.3 124,12.3 124.09,12.21 124.09,10.88 123.83,10.62 118.69,10.62 118.31,11 118.31,12.14
+3.3V on BOTTOM: 142.82,156.79 142.9,156.83 145.18,156.83 146.04,155.97 147.95,155.97 150.39,153.54 150.37,153.5 150.41,153.02 150.9,152.97 150.93,152.99 151.16,152.77 155.48,152.77 156.08,152.17 156.08,150.39 156.82,149.64 159.12,149.64 160.16,150.68 160.58,150.68 160.76,150.5 160.76,150.14 160.83,150.06 161.28,150.06 161.49,149.85 161.49,149.04 160.96,148.51 160.51,148.51 160.39,148.39 160.38,148.39 160.07,148.14 160.14,147.76 160.17,147.72 159.95,147.5 151.85,147.5 147.43,151.92 123.39,151.92 123.35,151.88 117.87,151.88 116.53,153.21 116.53,155.53 117.16,156.16 119.54,156.16 120.18,155.52 124.01,155.52 124.51,155.22 125.01,155.52 125.97,155.52 126.64,154.85 139.58,154.85 140.75,156.02 140.83,156.05 140.9,156 141.49,155.94 141.43,156.53 141.39,156.61 141.42,156.69 141.56,156.83 141.99,156.83 142.07,156.79 142.08,156.69 142.08,156.44 142.24,156.25 142.25,156.24 142.27,156.19 142.26,156.17 142.74,155.67 142.83,156.36 142.82,156.36 142.79,156.41 142.8,156.43 142.82,156.56 142.8,156.69
+3.3V on BOTTOM: 168.55,14.94 169.75,14.94 169.87,14.81 169.87,13.03 169.75,12.91 167.59,12.91 167.08,13.41 167.08,14.43 167.33,14.68 168.3,14.68
+3.3V on L5_VCC2: 99.85,13.03 96.65,16.24 96.65,31.81 93.39,35.06 93.39,40.72 81.08,53.04 50.35,53.04 48.34,55.05 48.34,63.35 50.6,65.61 70.61,65.61 71.7,64.52 71.7,61.44 72.31,60.84 88.88,60.84 89.91,61.87 89.91,66.57 93.2,69.85 102.03,69.85 103.35,68.53 103.35,60.22 110.34,53.24 110.34,45.36 116.76,38.94 116.76,33.48 118.16,32.08 123.32,32.08 124.48,33.25 124.48,45.98 119.94,50.53 119.94,60.63 122,62.69 180.18,62.69 180.67,62.2 180.67,17.33 176.37,13.03 ; 1 cut-out
+3.3V on L6_IN2: 91.26,156.04 118.19,156.04 119.52,154.7 119.52,146.83 112.98,140.29 112.98,126.44 109.8,123.27 109.8,110.7 108.28,109.17 108.28,98.12 108.25,98.09 108.25,92.12 105.19,89.06 105.19,88.29 105.28,88.2 105.28,80.55 103.72,78.98 103.72,62.53 102.97,61.79 94.43,61.79 91.75,64.47 91.75,83.98 92.41,84.64 94.74,84.64 97.38,87.28 97.38,94.21 104.72,101.55 104.72,109.55 107.5,112.33 107.5,125.81 109.68,127.98 109.68,149.05 104.47,154.26 88.98,154.26 85.17,158.07 83.13,158.07 82.75,158.45 82.75,159.97 82.88,160.1 87.2,160.1
+3.3V on L8_IN3: 147.7,13.42 147.7,11.03 146.78,10.11 146.78,5.8 145.7,4.72 141.24,4.72 140.83,5.14 140.83,6.9 141.29,7.36 142.67,7.36 143.38,8.06 143.38,11.74 145.72,14.08 147.04,14.08
+3.3VA on TOP (solid shape): 89.09,56.35 89.09,54.81 88.85,54.56 87.45,54.56 86.94,54.05 86.94,52.91 86.56,52.53 85.8,52.53 84.97,53.36 83.32,53.36 83.01,53.67 83.01,54.56 83.26,54.82 84.53,54.82 85.13,55.42 85.13,56.42 85.2,56.49 88.95,56.49
+3.3VA on TOP (solid shape): 192.52,20.67 192.52,15.82 193.62,14.72 193.62,8.21 193.24,7.83 190.58,7.83 190.32,8.08 190.32,8.84 189.94,9.22 189.05,9.22 188.42,9.86 188.42,16.46 187.91,16.97 184.48,16.97 183.34,18.11 183.34,20.53 183.84,21.03 192.16,21.03
+3.3VA on TOP (solid shape): 117.98,11.38 117.3,11.38 117.16,11.24 117.09,11.21 117.02,11.24 116.68,11.31 116.46,11.05 116.45,11 115.77,11 115.52,11.26 115.52,12.14 115.65,12.27 117.98,12.27
+3.3VA on BOTTOM (solid shape): 117.3,12.02 117.3,11.39 117.15,11.25 117.08,11.22 117.01,11.25 116.67,11.31 116.46,11.03 116.45,10.98 115.66,10.98 115.39,11.26 115.39,12.02 115.65,12.27 117.04,12.27
+3.3VA on TOP: 122.26,27.82 123.29,27.82 123.42,27.69 123.42,25.15 123.22,24.95 122.24,24.95 122.08,25.11 122.08,27.64
+3.3VA on TOP: 143.59,28.78 144.47,28.78 144.6,28.65 144.6,27.89 144.09,27.38 144.09,25.61 143.97,25.48 142.44,25.48 142.19,25.73 142.19,27.77 142.32,27.89 142.7,27.89
+3.3VA on TOP: 166.95,19 166.95,16.46 166.57,16.08 165.81,16.08 164.79,15.07 164.16,15.07 164.03,15.19 164.03,19 164.67,19.64 166.32,19.64
+3.3VA on BOTTOM: 102.69,5.78 102.56,5.65 101.38,5.65 101.1,5.94 101.1,7.39 100.28,8.21 100.28,8.97 100.66,9.35 102.44,9.35 102.69,9.1
+3.3VA on BOTTOM: 173.3,14.68 173.3,13.54 173.18,13.41 171.27,13.41 171.14,13.54 171.14,14.94 173.05,14.94
+3.3VA on BOTTOM: 184.1,21.16 187.65,21.16 188.16,20.65 188.16,15.57 187.65,15.07 184.23,15.07 183.21,16.08 183.21,20.27
+3.3VA on BOTTOM: 171.4,18.11 172.03,18.11 172.29,18.37 172.92,18.37 173.3,17.99 173.3,16.46 173.18,16.34 171.27,16.34 171.14,16.46 171.14,17.86
+3.3VA on L3_IN1: 68.74,46.55 78.08,46.55 79.97,44.65 79.97,39.84 82.06,37.75 82.06,33.95 81.01,32.9 54.58,32.9 54.12,33.36 54.12,34.72 53.62,35.21 43.79,35.21 42.74,36.26 42.74,39.8 43.6,40.66 53.35,40.66 56.56,43.87 59.29,43.87 59.51,43.65 59.51,42.91 58.67,42.07 58.67,37.65 61.51,34.81 66.06,34.81 66.57,35.32 66.57,37.96 66.92,38.31 67.62,38.31 67.64,38.29 71.52,38.29 71.93,38.7 71.93,41.61 71.54,42 70.55,42 68.35,44.2 68.35,46.16
+3.3VA on L4_VCC1: outline of 82 points within 68.93,1.83 188.09,164.32
+3.3VA on L6_IN2: 119.17,22.56 121.33,22.56 121.63,22.26 127.4,22.26 128.57,21.09 128.57,19.96 128.05,19.45 126.82,19.45 126.34,19.92 124.79,19.92 124.55,20.16 122.55,20.16 121.17,18.79 117.63,18.79 115.53,16.69 109.34,16.69 108.72,17.31 108.72,19.78 110.68,21.74 114.54,21.74 114.87,22.07 118.69,22.07
+3.3VA_RTC on TOP: 132.16,14.36 131.49,15.03 129.46,17.06 129.27,17.06 129.2,16.99 129.2,16.36 129.32,16.24 129.68,16.24 131,14.92 131,14.32 131.52,13.8 131.52,11.64 131.65,11.51 132.79,11.51 132.92,11.64 132.92,12.53 132.16,13.29
+3.3VS on TOP (solid shape): 169.85,18.95 169.85,16.89 169.39,16.44 167.89,16.44 167.66,16.67 167.66,19.18 167.77,19.28 169.52,19.28
+3.3VS on TOP: 104.47,6.94 105.36,6.94 105.49,6.81 105.49,5.54 105.36,5.41 104.6,5.41 104.22,5.79 104.22,6.68
+3.3VS on BOTTOM: 169.75,16.97 169.75,16.34 168.6,16.34 168.48,16.46 167.46,16.46 167.21,16.72 167.21,19.76 167.72,20.27 169.87,20.27 170,20.15 170,17.22
+3.3VS on L3_IN1: 163.91,19.8 170.28,19.8 171.21,18.87 171.21,7.88 167.14,3.81 157.05,3.81 156.84,4.02 149.94,4.02 149.17,4.78 110.69,4.78 110.18,4.27 108.61,4.27 107.22,5.66 104.33,5.66 104,5.99 104,8.15 104.29,8.44 108.67,8.44 108.91,8.19 114.38,8.19 115.97,9.79 120.42,9.79 122.4,11.76 123.14,11.76 124.03,10.87 148.9,10.87 148.97,10.8 153.76,10.8 154.41,10.15 157.16,10.15 159.46,7.85 160.1,7.85 160.43,8.18 160.43,10.25 163.2,13.02 163.2,19.09
+3.3VS_LAN on TOP (solid shape): 88.85,52.15 89.99,52.15 90.12,52.02 90.12,51.9 89.86,51.64 89.86,51.13 89.74,51.01 89.1,51.01 88.98,50.88 86.56,50.88 86.44,51.01 86.44,52.02 86.82,52.4 88.59,52.4
+3.3VS_LAN on L6_IN2: 92.56,56.47 98.83,56.47 99.52,55.78 99.52,52.17 98.86,51.51 96.39,51.51 96.04,51.87 90.75,51.87 90.55,51.67 90.55,49.43 91.49,48.49 97.56,48.49 98.5,47.55 98.5,44.91 97.69,44.1 93.14,44.1 91.08,46.15 88.98,46.15 88.34,46.79 88.34,49.74 87.78,50.3 87.78,52.94 89.94,55.1 91.18,55.1
+5V on TOP (solid shape): 59.26,161.88 59.26,161.12 59.13,160.99 56.59,160.99 56.46,161.12 56.46,161.62 56.97,162.13 59,162.13
+5V on TOP (solid shape): 59.49,171.77 61.22,171.77 61.26,171.73 61.26,169.33 61.13,169.21 58.11,169.21 57.94,169.38 57.94,172.06 58.03,172.15 59.12,172.15
+5V on TOP (solid shape): 78.2,161.64 78.2,159.75 78.08,159.63 76.52,159.63 76.4,159.75 76.4,161.4 76.62,161.62 76.66,161.59 76.72,161.55 76.79,161.51 76.9,161.5 77,161.51 77.07,161.53 77.18,161.61 77.26,161.72 77.27,161.73 77.27,161.78 78.06,161.78
+5V on BOTTOM (solid shape): 93.8,168.74 93.8,167.72 93.55,167.47 93.55,166.12 91.13,163.71 82.15,163.71 82.02,163.58 80.26,163.58 80.03,163.81 80.03,165.08 80.44,165.48 89.66,165.48 93.04,168.86 93.67,168.86
+5V on L3_IN1 (solid shape): 81.48,164.54 81.48,163.4 78.56,160.48 77.04,160.48 76.78,160.73 76.78,161.52 77.29,161.88 76.78,162.24 76.78,163.02 78.69,164.93 81.1,164.93
+5V on TOP: 190.45,162 190.83,162 190.96,161.88 190.96,158.83 190.83,158.7 189.81,158.7 189.69,158.83 189.69,159.46 190.32,160.1 190.32,161.88
+5V on BOTTOM: 173.4,59.13 173.35,59.19 173.35,60.42 175.67,62.73 175.67,75.39 177.65,77.37 180.34,77.37 180.57,77.6 180.57,78.18 180.75,78.36 183.29,78.36 183.36,78.29 183.36,75.29 182.98,74.91 180.95,74.91 180.92,74.93 179.88,74.93 179.32,74.37 179.32,59.44 179.02,59.13
+5V on L3_IN1: 58.75,170.51 60.27,170.51 60.91,169.88 60.91,162.26 57.1,158.45 55.19,158.45 53.92,157.18 33.86,157.18 31.32,154.64 31.32,137.62 30.05,136.35 22.43,136.35 21.79,136.99 21.79,138.51 22.17,138.89 28.65,138.89 29.03,139.27 29.03,156.16 31.95,159.08 51.38,159.08 56.84,164.54 56.84,168.61
+5V on L6_IN2: 91.83,166.77 92.79,167.72 105.23,167.72 107.39,169.88 118.69,169.88 122,173.18 144.32,173.18 144.65,173.51 158.39,173.51 163.4,168.51 165.12,168.51 165.15,168.53 170.23,168.53 171.68,167.08 178.71,167.08 179.45,166.35 179.45,156.57 181.56,154.46 182.88,154.46 183.54,155.12 190.37,155.12 193.09,152.4 193.09,139.63 191.97,138.51 191.97,137.37 194,135.33 194,94.31 192.99,93.3 192.99,77.3 191.97,76.28 191.97,61.55 188.04,57.61 174.95,57.61 173.3,59.26 173.3,61.42 174.19,62.31 186,62.31 188.8,65.1 188.8,87.33 187.27,88.85 187.27,130.51 189.31,132.54 189.31,144.86 184.23,149.94 178.43,149.94 173.43,154.94 173.43,158.98 167.41,165 153.9,165 152.32,166.58 142.34,166.58 138.4,170.52 124.63,170.52 122.44,168.33 122.44,166.13 121.36,165.05 109.55,165.05 109.17,164.67 94.94,164.67 93.55,163.27 79.07,163.27 73.67,168.67 60.34,168.67 57.86,166.2 57.1,166.2 56.46,166.83 56.46,169.62 59.38,172.55 74.62,172.55 80.4,166.77
+5V on L8_IN3: 190.07,160.1 190.7,160.1 191.46,159.34 191.46,153.5 191.34,153.37 190.96,153.37 189.69,154.64 189.69,159.72
+5V_3.3V_L on TOP (solid shape): 60.4,162.73 60.4,162.01 60.48,161.92 61.41,161.92 61.62,162.13 62.56,162.13 62.77,161.92 62.77,159.85 62.62,159.7 61.03,159.7 60.84,159.51 59.62,159.51 59.55,159.58 59.55,162.78 59.63,162.87 60.26,162.87
+5V_3.3V_LCD on TOP (solid shape): 65.23,162.86 65.23,162.39 65.23,162.39 65.23,161.99 65.68,161.54 65.68,160.21 65.46,159.99 65.46,159.14 65.1,158.78 63.65,158.78 63.15,159.28 63.15,162.79 63.36,163.01 65.09,163.01
+5V_3.3V_LCD on BOTTOM (solid shape): 65.58,160.86 65.58,160.11 65.5,160.04 65.5,158.27 65.45,158.21 64.69,158.21 64.61,158.29 64.61,159.65 64.41,159.85 64.08,159.85 63.83,160.1 63.83,160.86 63.96,160.99 65.45,160.99
+5V_HDD on BOTTOM: 185.62,72.22 185.55,72.29 185.55,72.82 183.58,74.79 183.58,79.31 183.59,79.33 183.59,80.47 183.84,80.72 183.84,82.86 184.1,83.11 185.01,83.11 185.24,82.88 186.89,82.88 187.15,82.63 187.15,79.84 186.89,79.58 185.62,79.58 185.5,79.45 185.5,75.79 185.28,75.35 185.67,75.06 186.51,74.22 186.48,73.85 186.68,73.55 186.72,73.47 186.69,73.39 186.53,73.11 186.54,72.79 186.54,72.27 186.49,72.22
+5V_TYPEC on BOTTOM (solid shape): 146.38,176.99 146.38,175.59 144.73,173.94 144.73,171.28 144.22,170.77 142.44,170.77 141.93,171.28 141.93,175.85 142.44,176.36 144.35,176.36 145.11,177.12 146.25,177.12
+5V_TYPEC on TOP: 142.44,176.36 144.35,176.36 145.11,177.12 146.25,177.12 146.38,176.99 146.38,175.69 144.62,173.93 144.62,169.65 144.22,169.24 142.32,169.24 141.93,169.62 141.93,175.85
+5V_TYPEC on L6_IN2: 150.06,182.71 152.6,182.71 152.86,182.45 152.86,178.77 150.44,176.36 145.24,176.36 145.11,176.48 145.11,177.75
+5VA on TOP (solid shape): 58.16,60.46 58.16,57.74 57.91,57.48 56.39,57.48 56.01,57.86 56.01,60.28 56.23,60.51 58.11,60.51
+5VA on TOP (solid shape): 117.49,170.94 117.49,170.66 117.64,170.51 119.21,170.51 119.28,170.44 119.28,169.42 119.22,169.36 115.75,169.36 115.45,169.65 115.42,169.94 115.18,170.12 115.18,170.93 115.39,171.14 117.29,171.14
+5VA on TOP: 110.33,57.19 168.97,57.19 169.61,57.84 172.64,57.84 172.67,57.86 183.46,57.86 187.4,61.8 187.4,81.88 187.92,82.39 191.71,82.39 192.12,81.98 192.12,58.9 185.3,52.09 146.95,52.09 145.36,50.5 110.57,50.5 109.42,49.36 108.53,49.36 107.9,49.99 107.9,54.76
+5VA on BOTTOM: 171,57.84 171.97,57.84 172.01,57.8 172.01,55.76 171.81,55.57 170.9,55.57 170.71,55.76 170.71,57.55
+5VA on BOTTOM: 173.39,57.86 174.53,57.86 174.65,57.74 174.65,54.67 174.47,54.5 173.36,54.5 173.32,54.54 173.32,57.79
+5VA on BOTTOM: 57.48,64.98 63.58,64.98 64.08,64.47 64.08,62.82 63.83,62.56 62.56,62.56 61.8,61.8 61.8,57.99 65.35,54.44 71.58,54.44 72.59,53.42 72.59,53.04 72.78,52.85 74.94,52.85 76.4,51.39 83.64,51.39 91.26,43.77 93.29,43.77 93.67,44.15 101.68,44.15 105.08,47.55 105.08,50.86 107.26,53.04 109.93,53.04 110.18,52.78 110.18,51.01 109.68,50.5 108.42,50.5 107.25,49.33 107.25,46.45 102.41,41.61 102.4,41.61 101.65,40.86 89.88,40.86 82.28,48.47 74.12,48.47 72.59,49.99 62.31,49.99 56.34,55.96 56.34,63.83
+5VA on L3_IN1: 113.09,127.84 113.09,130.63 113.99,131.53 116.3,131.53 116.34,131.49 117.39,132.53 117.39,134.05 113.95,137.49 113.95,166.88 114.52,167.45 114.52,168.11 114.54,168.13 114.54,170.13 114.96,170.55 116.31,170.55 117.36,169.51 117.36,166.07 116.42,165.14 116.42,155.81 118.5,153.73 118.5,138.17 122.13,134.54 122.13,129.42 121.07,128.36 118.75,128.36 115.77,125.39 115.77,112.22 108.78,105.23 108.78,91.56 107.01,89.79 107.01,82.33 108.3,81.04 108.3,53.93 109.5,52.73 109.5,49.9 108.83,49.23 106.76,49.23 105.79,50.19 105.79,76.84 104.86,77.77 104.86,91.58 106.17,92.89 106.17,106.13 111.9,111.86 111.9,126.66 112.6,127.36
+5VS on TOP (solid shape): 95.81,5.79 95.81,3.99 95.73,3.91 93.83,3.91 93.27,4.47 93.27,5.72 93.52,5.97 95.63,5.97
+5VS on TOP (solid shape): 140.1,170.15 140.1,169.22 140.02,169.14 137.75,169.14 137.11,168.5 134.86,168.5 134.6,168.76 134.6,170.07 134.83,170.3 139.95,170.3
+5VS on BOTTOM (solid shape): 95.83,5.79 95.83,4.35 95.68,4.19 93.85,4.19 93.75,4.3 93.75,5.67 94.08,6 95.63,6
+5VS on BOTTOM (solid shape): 193.18,58.92 193.18,54.17 191.51,52.5 191.51,49.32 191.11,48.91 188.48,48.91 188.26,49.13 188.26,52.38 188.57,52.68 188.95,52.68 189.31,53.04 189.31,58.19 190.31,59.2 192.9,59.2
+5VS on TOP: 160.35,7.45 162,7.45 162.13,7.32 162.13,5.29 162,5.16 160.73,5.16 160.1,5.79 160.1,7.19
+5VS on TOP: 102.76,166.01 104.47,166.01 104.6,166.14 104.6,167.08 104.98,167.47 106.37,167.47 106.63,167.21 106.63,165.05 106.42,164.84 102.95,164.84 102.69,165.1 102.69,165.94
+5VS on TOP: 116.15,6.18 116.15,5.29 115.9,5.04 115.9,4.17 115.85,4.12 114.58,4.12 114.25,4.45 114.25,6.3 114.4,6.46 115.87,6.46
+5VS on TOP: 109.2,6.87 109.27,6.94 109.56,7.04 109.68,7.33 111.5,7.33 111.54,7.28 111.54,5.76 111.18,5.4 109.29,5.4 109.2,5.49
+5VS on BOTTOM: 8.33,62.31 8.2,62.44 8.2,64.34 8.33,64.47 9.62,64.47 9.63,64.44 9.97,64.21 10.32,64.43 10.33,64.43 11,65.1 11.63,65.1 11.63,65.06 12.05,64.72 12.39,65.13 12.39,65.23 12.5,65.33 13.23,65.33 13.36,65.2 13.36,62.78 13.16,62.58 12.61,62.58 12.34,62.31 9.83,62.31 9.82,62.32 9.79,62.31
+5VS on BOTTOM: 171.86,61.22 171.86,60.31 171.97,60.2 171.97,59.21 171.94,59.17 167.04,59.17 166.7,59.52 166.7,61.17 167.11,61.58 171.51,61.58
+5VS on L3_IN1: 137.11,173.18 137.95,172.34 137.95,169.15 137.42,168.63 134.93,168.63 134.78,168.78 134.78,169.25 134.24,169.79 122.88,169.79 122.06,170.61 117.34,170.61 116.54,171.41 114.51,171.41 113.36,170.26 110.02,170.26 108.39,168.64 108.39,167.09 106.99,165.69 103.45,165.69 103.33,165.81 103.45,165.94 103.71,165.94 103.91,166.14 103.91,170.69 105.75,172.54 111.99,172.54 112.28,172.83 112.83,172.83 113.28,173.28 115.19,173.28 116.01,174.1 121.26,174.1 122.19,173.18
+5VS on L6_IN2: 109.88,7.62 111.59,7.62 112.98,6.24 120.92,6.24 122.31,4.85 122.31,1.52 122.05,1.27 80.4,1.27 79.04,2.63 79.04,30.65 76.93,32.76 76.19,32.76 76.02,32.59 54.3,32.59 53.92,32.97 53.92,34.75 53.54,35.13 20.01,35.13 18.62,36.53 10.49,36.53 8.84,38.18 8.84,50.12 11.51,52.78 11.51,55.32 14.93,58.75 14.93,60.91 12.9,62.94 10.49,62.94 8.71,64.72 8.71,66.75 9.35,67.39 11.25,67.39 12.27,66.37 15.57,66.37 18.43,63.52 18.43,63.33 19.89,61.86 19.89,55.45 12.78,48.34 12.78,41.1 14.3,39.58 53.8,39.58 57.1,36.27 57.48,36.27 58.24,35.51 65.23,35.51 65.73,35 68.91,35 71.59,37.68 79.84,37.68 83.04,34.48 83.04,10.15 87.07,6.13 108.38,6.13
+5VS on L6_IN2: 167.7,62.55 167.72,62.55 170.65,65.48 180.94,65.48 182.91,67.45 182.91,89.23 179.09,93.04 179.09,110.14 176.73,112.5 176.73,123.9 182.45,129.62 182.45,137.11 184.86,139.53 184.86,140.54 183.4,142 180.1,142 177.62,144.48 172.09,144.48 167.21,149.36 138.57,149.36 136.22,151.72 136.22,165.52 136.89,166.2 136.89,167.55 136.57,167.88 135.21,167.88 134.82,168.26 134.82,169.75 135.08,170.01 137.36,170.01 137.37,170 138.15,170 142.09,166.07 152.09,166.07 153.49,164.67 167.08,164.67 173.18,158.58 173.18,154.26 177.75,149.69 183.84,149.69 188.92,144.61 188.92,132.79 186.89,130.76 186.89,88.74 188.23,87.4 188.23,65 185.83,62.6 173.47,62.6 172.54,61.67 172.54,59.01 174.7,56.85 190.58,56.85 191.46,55.96 191.46,49.1 191.06,48.69 185.67,48.69 181.2,53.17 170.89,53.17 167.7,56.36
+5VS on L8_IN3: 159.94,6.79 161.93,6.79 162.22,6.5 162.22,1.44 161.73,0.96 120.19,0.96 119.67,1.49 119.67,2.67 120.22,3.22 158.18,3.22 159.3,4.35 159.3,6.15
+VCCAMPHYPLL_1P05 on TOP: 129.22,35.76 129.22,36.95 129.26,36.99 129.57,36.99 129.9,37.32 134.06,37.32 134.14,37.24 134.14,36.4 134.01,36.27 133.07,36.27 132.94,36.4 130.63,36.4 129.93,35.7 129.28,35.7
+VCCCORE on TOP (solid shape): outline of 723 points within 126.59,111.61 146.86,114.13
+VCCCORE on TOP (solid shape): outline of 2697 points within 114.25,124.03 148.33,147.73
+VCCCORE on BOTTOM: outline of 97 points within 115.26,111.2 149.17,144.99 ; 2 cut-outs
+VCCCORE on L4_VCC1: 128.2,111.71 127.56,112.35 121.59,112.35 120.34,113.6 120.34,115.04 126.57,121.26 126.57,127.69 123.37,130.89 119.31,130.89 118.44,131.76 118.44,146.41 119.69,147.65 146.53,147.65 147.01,147.17 147.01,132.39 146.51,131.88 146.51,111.94 146.27,111.71
