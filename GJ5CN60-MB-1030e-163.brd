# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ3: length 53.1
  TOP w0.076: v1(164.94,108.63) 164.74,108.43 164.11,108.43 163.86,108.69 163.21,108.69 162.9,108.99 162.16,108.99 162.11,108.94 U26.BR8
  TOP w0.102: CN11.20 v1(176.4,69.47)
  L3_IN1 w0.076: v1(164.94,108.63) 165.85,108.63 166.22,108.25 166.22,107.81
  L3_IN1 w0.089: 166.22,107.81 166.22,107.55 167.87,105.91 167.87,102.16 172.19,97.84 172.19,94.99 174.06,93.12 174.06,92.14 174.07,92.12 174.07,91.38 174.7,90.75 174.7,90.27 174.79,90.18 175.38,90.18 175.46,90.09 175.46,89.91 175.38,89.82 174.79,89.82 174.7,89.73 174.7,89.42 174.82,89.3 175.4,89.3 175.51,89.2 175.51,81.31 175.57,81.25 175.57,75.66 175.99,75.23 175.99,74.59 175.81,74.41 175.81,73.72 175.72,73.63 175.39,73.63 175.3,73.54 175.3,73.37 175.39,73.28 175.72,73.28 175.81,73.19 175.81,73.01 175.72,72.92 175.39,72.92 175.3,72.83 175.3,72.66 175.39,72.57 175.72,72.57 175.81,72.48 175.81,72.08 176.84,71.05 176.84,69.91 v1(176.4,69.47)
M_B_DQ4: length 55
  TOP w0.076: v1(163.78,110.5) 163.72,110.56 163.16,110.56 162.93,110.8 161.27,110.8 U26.BP11
  TOP w0.102: v1(179.65,75.01) CN11.7
  L3_IN1 w0.089: v1(179.65,75.01) 179.25,75.4 179.05,75.4 178.92,75.28 178.92,73.62 178.85,73.55 178.46,73.55 178.29,73.72 178.29,75.78 177.85,76.22 177.85,80.8 178,80.95 178,88.92 177.91,89 177.45,89 177.36,89.09 177.36,89.27 177.45,89.36 177.91,89.36 178,89.45 178,90.03 177.84,90.2 177.84,90.39 178,90.55 178,90.83 175.83,93 175.83,94.03 173.96,95.89 173.96,98.57 169.62,102.91 169.62,106.64 169.39,106.87 169.39,106.99 169.6,107.2 169.6,107.32 169.47,107.45 169.35,107.45 169.14,107.24 169.02,107.24 168.89,107.37 168.89,107.5 169.08,107.68 169.08,107.81 168.95,107.94 168.83,107.94 168.64,107.75 168.51,107.75 168.4,107.86 168.4,108.69 166.44,110.65 163.92,110.65 v1(163.78,110.5)
M_B_DQ5: length 55.6
  TOP w0.076: v1(163.33,110.95) 163.27,111.01 160.84,111.01 U26.BN11
  TOP w0.102: v1(179.7,74.42) 179.98,74.42 180.65,75.08 CN11.3
  L3_IN1 w0.089: v1(179.7,74.42) 179.75,74.42 180.14,74.8 180.14,75.77 179.95,75.96 179.82,75.96 179.56,75.7 179.43,75.7 179.31,75.82 179.31,75.95 179.8,76.44 179.8,76.56 179.67,76.69 179.54,76.69 178.84,75.98 178.72,75.98 178.59,76.11 178.59,76.24 179.07,76.72 179.07,76.84 178.94,76.97 178.82,76.97 178.47,76.62 178.35,76.62 178.22,76.75 178.22,76.87 178.57,77.22 178.57,77.34 178.16,77.75 178.16,80.63 178.29,80.76 178.29,90.95 176.12,93.12 176.12,94.15 174.26,96.01 174.26,98.69 169.92,103.03 169.92,107.59 166.55,110.95 v1(163.33,110.95)
M_B_DQ6: length 53.5
  TOP w0.076: v1(163.85,109.08) 163.2,109.08 163.04,109.23 161.28,109.23 U26.BP8
  TOP w0.102: v1(175.32,74.3) 176.15,75.12 CN11.21
  L3_IN1 w0.089: v1(175.32,74.3) 175.32,74.35 175.7,74.73 175.7,75.11 175.27,75.53 175.27,81.12 175.21,81.18 175.21,88.22 174.41,89.02 174.41,90.58 173.41,91.57 173.41,91.91 173.5,92 173.66,92 173.75,92.09 173.75,92.27 173.66,92.36 173.5,92.36 173.41,92.44 173.41,92.58 173.32,92.68 173.32,92.8 173.57,93.06 173.57,93.18 173.44,93.31 173.32,93.31 173.06,93.05 172.94,93.05 172.81,93.18 172.81,93.31 173.07,93.56 173.07,93.68 172.94,93.81 172.81,93.81 172.56,93.56 172.44,93.56 172.31,93.68 172.31,93.81 172.56,94.06 172.56,94.19 172.44,94.31 172.31,94.31 172.06,94.06 171.93,94.06 171.81,94.19 171.81,94.31 172.06,94.56 172.06,94.69 171.93,94.82 171.81,94.82 171.56,94.56 171.43,94.56 171.27,94.72 171.27,95.27 171.36,95.36 171.79,95.36 171.88,95.45 171.88,95.63 171.79,95.72 171.36,95.72 171.27,95.81 171.27,95.98 171.36,96.07 171.8,96.07 171.89,96.16 171.89,96.34 171.8,96.43 171.36,96.43 171.27,96.52 171.27,96.7 171.36,96.78 171.79,96.78 171.88,96.87 171.88,97.05 171.79,97.14 171.36,97.14 171.27,97.23 171.27,97.41 171.36,97.5 171.77,97.5 171.86,97.58 171.86,97.76 171.77,97.85 171.36,97.85 171.27,97.94 171.27,98.23 167.56,101.93 167.56,105.8 166.04,107.33 165.5,107.33 163.85,108.97 v1(163.85,109.08)
M_B_DQ7: length 54.3
  TOP w0.076: v1(163.4,109.53) 163.09,109.53 163,109.44 160.84,109.44 U26.BN8
  TOP w0.102: v1(176.36,70.18) 177.4,69.15 CN11.16
  L3_IN1 w0.089: v1(163.4,109.53) 163.4,109 165.38,107.02 165.93,107.02 167.27,105.68 167.27,101.81 170.98,98.1 170.98,94.6 171.3,94.28 171.3,94.15 171.05,93.9 171.05,93.77 171.18,93.65 171.3,93.65 171.55,93.9 171.68,93.9 171.81,93.77 171.81,93.65 171.45,93.29 171.45,93.17 171.58,93.04 171.7,93.04 172.06,93.4 172.18,93.4 172.31,93.27 172.31,93.14 171.86,92.7 171.86,92.57 171.99,92.45 172.12,92.45 172.56,92.89 172.69,92.89 173.12,92.46 173.12,91.45 174.12,90.46 174.12,86.04 174.92,85.24 174.92,81.06 174.98,81 174.98,77 174.84,76.86 174.84,74.06 174.85,74.05 174.85,71.7 v1(176.36,70.18)
M_B_DQ8: length 52.9
  TOP w0.076: v1(159.37,110.91) U26.BL12
  TOP w0.102: CN11.25 175.15,75.42 173.36,73.64 v1(173.24,73.64)
  L3_IN1 w0.089: v1(159.37,110.91) 159.37,110.23 160.42,109.18 162.35,109.18 165.3,106.23 165.6,106.23 166.48,105.35 166.48,101.49 170.19,97.78 170.19,91.91 171.25,90.86 171.25,90.44 173.19,88.5 173.19,85.37 173.28,85.28 173.71,85.28 173.8,85.19 173.8,85.01 173.71,84.93 173.28,84.93 173.19,84.84 173.19,84.66 173.28,84.57 173.71,84.57 173.8,84.48 173.8,84.3 173.71,84.21 173.28,84.21 173.19,84.13 173.19,82.05 173.28,81.96 173.68,81.96 173.77,81.87 173.77,81.69 173.68,81.6 173.28,81.6 173.19,81.51 173.19,81.4 173.4,81.18 173.4,80.87 173.49,80.78 173.73,80.78 173.82,80.69 173.82,80.51 173.73,80.42 173.49,80.42 173.4,80.33 173.4,79.63 174.17,78.87 174.17,77.4 173.96,77.19 173.96,74.32 173.28,73.64 v1(173.24,73.64)
M_B_DQ9: length 52.5
  TOP w0.076: v1(158.57,110.9) U26.BL11
  TOP w0.102: v1(173.26,74.3) 174.15,75.18 CN11.29
  L3_IN1 w0.089: v1(173.26,74.3) 173.65,74.68 173.65,75.92 173.56,76.01 173.24,76.01 173.15,76.1 173.15,76.28 173.24,76.37 173.56,76.37 173.65,76.46 173.65,76.63 173.56,76.72 173.27,76.72 173.18,76.81 173.18,76.99 173.27,77.08 173.43,77.08 173.87,77.52 173.87,78.75 173.11,79.51 173.11,81.06 172.89,81.28 172.89,88.38 170.96,90.32 170.96,90.73 170.52,91.17 170.39,91.17 170.18,90.96 170.05,90.96 169.93,91.08 169.93,91.21 170.14,91.42 170.14,91.55 169.9,91.79 169.9,97.66 166.19,101.37 166.19,102.14 166.1,102.23 165.89,102.23 165.8,102.32 165.8,102.5 165.89,102.59 166.1,102.59 166.19,102.68 166.19,102.85 166.1,102.94 165.89,102.94 165.8,103.03 165.8,103.21 165.89,103.3 166.1,103.3 166.19,103.39 166.19,103.57 166.1,103.65 165.28,103.65 165.19,103.74 165.19,103.92 165.28,104.01 166.1,104.01 166.19,104.1 166.19,105.02 165.17,106.04 165.08,106.04 162.14,108.98 160.33,108.98 158.96,110.34 158.96,110.51 v1(158.57,110.9)
M_B_DQ10: length 50.4
  TOP w0.076: v1(159.37,109.33) U26.BL8
  TOP w0.102: CN11.28 v1(174.4,69.51)
  L3_IN1 w0.089: v1(174.4,69.51) 174.47,69.51 174.93,69.97 174.93,70.92 172.69,73.16 172.69,76.69 172.76,76.76 172.76,81 172.6,81.16 172.6,88.26 171.91,88.96 171.36,88.96 171.19,89.12 171.19,89.25 171.31,89.37 171.31,89.5 171.18,89.62 171.06,89.62 170.94,89.5 170.81,89.5 170.69,89.63 170.69,89.75 170.79,89.86 170.79,90.02 170.7,90.11 170.54,90.11 170.43,90 170.31,90 169.61,90.7 169.61,97.54 165.45,101.69 165.45,102.95 164.91,103.5 164.91,104.97 163.32,106.57 162.77,106.57 160.58,108.76 159.94,108.76 v1(159.37,109.33)
M_B_DQ11: length 51.5
  TOP w0.076: v1(157.7,108.95) U26.BJ8
  TOP w0.102: v1(170.88,70.39) 170.41,69.92 170.41,69.43 170.69,69.15 170.76,69.15 170.9,69.01 CN11.42
  L3_IN1 w0.089: v1(157.7,108.95) 157.7,108.87 158.15,108.42 158.15,107.98 159.27,106.86 159.64,106.86 160.89,105.61 160.89,103.91 162.27,102.54 162.27,100.59 166.32,96.54 166.32,94.79 166.53,94.58 167.45,94.58 167.54,94.49 167.54,94.32 167.45,94.23 166.74,94.23 166.66,94.14 166.66,93.96 166.74,93.87 167.45,93.87 167.54,93.78 167.54,93.6 167.45,93.52 166.79,93.52 166.7,93.43 166.7,93.25 166.79,93.16 167.45,93.16 167.54,93.07 167.54,89.73 168.83,88.45 168.83,82.06 170.19,80.7 170.19,79.31 169.59,78.72 169.59,76.87 170.12,76.35 170.12,72.12 170.4,71.84 170.4,71.08 170.88,70.6 v1(170.88,70.39)
M_B_DQ12: length 53
  TOP w0.076: v1(157.7,110.25) U26.BJ11
  TOP w0.102: CN11.37 172.15,75.58 170.95,74.38 v1(170.64,74.38)
  L3_IN1 w0.076: v1(157.7,110.25) 158.11,109.84 158.11,109.41 158.52,109 158.52,108.12 159.28,107.36
  L3_IN1 w0.089: 159.28,107.36 159.84,107.36 161.58,105.62 161.58,103.97 162.88,102.67 162.88,101.45 164.8,99.52 164.93,99.52 165.11,99.71 165.24,99.71 165.36,99.58 165.36,99.46 165.18,99.27 165.18,99.15 165.3,99.02 165.43,99.02 165.62,99.22 165.75,99.22 165.88,99.09 165.88,98.96 165.68,98.77 165.68,98.64 165.81,98.52 165.93,98.52 166.15,98.73 166.27,98.73 166.4,98.61 166.4,98.48 166.18,98.27 166.18,98.14 166.31,98.01 166.44,98.01 166.67,98.25 166.8,98.25 166.93,98.13 166.93,98 166.69,97.76 166.69,97.64 166.81,97.51 166.94,97.51 167.17,97.74 167.3,97.74 167.42,97.62 167.42,97.49 167.19,97.26 167.19,97.13 167.32,97.01 167.44,97.01 167.69,97.26 167.81,97.26 167.94,97.13 167.94,97 167.55,96.61 167.55,96.27 168.13,95.69 168.13,90.14 170.35,87.91 170.35,81.36 170.78,80.93 170.78,80.6 170.86,80.51 171.2,80.51 171.29,80.42 171.29,80.24 171.2,80.15 170.86,80.15 170.78,80.07 170.78,79.89 170.86,79.8 171.2,79.8 171.29,79.71 171.29,79.53 171.2,79.44 170.86,79.44 170.78,79.35 170.78,78.86 170.96,78.67 170.96,78.34 170.78,78.15 170.78,77.47 170.86,77.39 171.1,77.39 171.19,77.3 171.19,77.12 171.1,77.03 170.86,77.03 170.78,76.94 170.78,76.76 170.86,76.67 171.1,76.67 171.19,76.59 171.19,76.41 171.1,76.32 170.86,76.32 170.78,76.23 170.78,75.96 171.08,75.66 171.08,74.82 v1(170.64,74.38)
M_B_DQ13: length 52.5
  TOP w0.076: v1(157.7,109.6) U26.BJ10
  TOP w0.102: v1(170.6,75.04) 171.15,75.58 CN11.41
  L3_IN1 w0.089: v1(157.7,109.6) 157.7,109.54 158.1,109.14 158.1,108.75 158.33,108.52 158.33,108.05 159.27,107.12 159.83,107.12 161.25,105.69 161.25,103.9 162.6,102.55 162.6,100.68 162.88,100.39 163.01,100.39 163.17,100.56 163.3,100.56 163.42,100.43 163.42,100.31 163.26,100.14 163.26,100.02 163.39,99.89 163.51,99.89 163.7,100.08 163.83,100.08 163.95,99.95 163.95,99.83 163.76,99.64 163.76,99.51 163.89,99.39 164.01,99.39 164.2,99.58 164.33,99.58 164.46,99.45 164.46,99.33 164.27,99.14 164.27,99.01 164.39,98.89 164.52,98.89 164.68,99.05 164.81,99.05 164.93,98.92 164.93,98.8 164.77,98.63 164.77,98.51 164.89,98.38 165.02,98.38 165.18,98.55 165.31,98.55 165.43,98.42 165.43,98.29 165.27,98.13 165.27,98.01 165.4,97.88 165.52,97.88 165.69,98.04 165.81,98.04 165.94,97.92 165.94,97.79 165.77,97.63 165.77,97.5 165.99,97.29 166.12,97.29 166.27,97.44 166.4,97.44 166.52,97.32 166.52,97.19 166.37,97.03 166.37,96.91 166.51,96.77 166.69,96.77 167.08,96.38 167.08,96.07 166.62,95.61 166.62,95.49 166.75,95.36 166.87,95.36 167.33,95.82 167.46,95.82 167.65,95.62 167.65,95.47 167.4,95.21 167.4,95.05 167.83,94.61 167.83,89.85 169.13,88.56 169.13,86.23 169.22,86.14 169.97,86.14 170.05,86.06 170.05,85.88 169.97,85.79 169.22,85.79 169.13,85.7 169.13,85.52 169.22,85.43 169.97,85.43 170.05,85.34 170.05,85.17 169.97,85.08 169.32,85.08 169.27,85.03 169.27,84.84 169.86,84.25 169.86,81.44 170.48,80.81 170.48,77.32 170.39,77.24 170.05,77.24 169.96,77.15 169.96,76.97 170.05,76.88 170.39,76.88 170.48,76.79 170.48,75.16 v1(170.6,75.04)
M_B_DQ14: length 50
  TOP w0.076: v1(159.32,108.51) U26.BL7
  TOP w0.102: v1(174.41,70.18) 175.4,69.2 CN11.24
  L3_IN1 w0.089: v1(174.41,70.18) 172.37,72.22 172.37,76.78 172.46,76.88 172.46,80.88 172.31,81.03 172.31,81.41 172.22,81.5 171.89,81.5 171.8,81.59 171.8,81.77 171.89,81.86 172.22,81.86 172.31,81.95 172.31,82.19 172.15,82.35 172.15,82.54 172.31,82.7 172.31,82.9 172.19,83.01 172.19,83.3 172.31,83.41 172.31,83.61 172.19,83.73 172.19,84 172.31,84.12 172.31,84.32 172.2,84.43 172.2,84.73 172.31,84.84 172.31,88.14 171.78,88.66 171.23,88.66 169.32,90.58 169.32,97.41 164.41,102.32 164.41,103.82 163.61,104.63 163.61,104.88 163.39,105.1 163.3,105.1 163.19,105.21 163.19,105.27 162.98,105.49 162.91,105.49 162.82,105.58 162.78,105.58 162.49,105.87 162.49,106.56 160.54,108.51 v1(159.32,108.51)
M_B_DQ15: length 51
  TOP w0.076: v1(157.7,108.3) U26.BJ7
  TOP w0.102: v1(170.9,69.63) 171.36,69.63 171.9,69.1 CN11.38
  L3_IN1 w0.089: v1(157.7,108.3) 157.7,108.15 159.23,106.62 159.63,106.62 160.54,105.72 160.54,103.76 161.94,102.36 161.94,100.51 166.03,96.42 166.03,93.02 166.12,92.94 166.58,92.94 166.67,92.85 166.67,92.67 166.58,92.58 166.12,92.58 166.03,92.49 166.03,92.31 166.12,92.22 166.59,92.22 166.68,92.14 166.68,91.96 166.59,91.87 166.12,91.87 166.03,91.78 166.03,91.6 166.12,91.51 166.6,91.51 166.69,91.42 166.69,91.25 166.6,91.16 166.12,91.16 166.03,91.07 166.03,90.83 166.1,90.76 166.38,90.76 166.48,90.66 166.48,90.38 168.53,88.33 168.53,81.94 169.89,80.58 169.89,79.43 169.3,78.84 169.3,76.75 169.8,76.25 169.8,72.02 170.06,71.76 170.06,71 170.28,70.79 170.28,70.17 170.82,69.63 v1(170.9,69.63)
M_B_DQ16: length 51.3
  TOP w0.076: v1(155.87,110.89) U26.BG11
  TOP w0.102: CN11.45 170.15,75.46 169.76,75.07 169.76,74.88 169.14,74.27 v1(168.84,74.27)
  L3_IN1 w0.076: v1(155.87,110.89) 156.3,110.46 156.3,110.26 156.42,110.14 156.42,108.88 157.7,107.6 157.92,107.6 159.16,106.36 159.16,103.8 160.99,101.97 160.99,99.6 161.63,98.96 162.06,98.96
  L3_IN1 w0.089: 162.06,98.96 162.19,98.96 162.34,98.81 162.47,98.81 162.65,98.99 162.76,98.99 162.9,98.85 162.9,98.74 162.72,98.56 162.72,98.43 162.84,98.31 162.97,98.31 163.14,98.48 163.27,98.48 163.39,98.35 163.39,98.23 163.22,98.06 163.22,97.93 163.35,97.8 163.47,97.8 163.66,97.99 163.76,97.99 163.91,97.84 163.91,97.74 163.72,97.55 163.72,97.43 163.85,97.3 163.98,97.3 164.16,97.48 164.27,97.48 164.41,97.34 164.41,97.23 164.23,97.05 164.23,96.93 164.35,96.8 164.48,96.8 164.66,96.98 164.77,96.98 164.91,96.84 164.91,96.73 164.73,96.55 164.73,96.42 164.86,96.3 164.98,96.3 165.16,96.48 165.27,96.48 165.42,96.33 165.42,96.23 165.23,96.04 165.23,95.92 165.53,95.62 165.53,90.63 168.04,88.12 168.04,80.97 168.13,80.87 168.26,80.87 168.5,81.11 168.62,81.11 168.75,80.98 168.75,80.86 168.51,80.62 168.51,80.49 168.81,80.2 168.81,76.4 168.89,76.32 169.03,76.32 169.11,76.23 169.11,76.05 169.03,75.96 168.89,75.96 168.81,75.87 168.81,75.66 169.26,75.21 169.26,74.68 v1(168.84,74.27)
M_B_DQ17: length 50.9
  TOP w0.076: v1(155.87,110.25) U26.BG10
  TOP w0.102: v1(168.78,74.97) 169.15,75.33 CN11.49
  L3_IN1 w0.076: 162.06,98.55 161.98,98.63 161.73,98.63 160.64,99.71 160.64,101.65 157.44,104.86 157.44,107.54 156.25,108.73 156.25,109.87 v1(155.87,110.25)
  L3_IN1 w0.089: 162.06,98.55 164.68,95.93 164.68,95.65 164.77,95.57 165.13,95.57 165.22,95.48 165.22,95.3 165.13,95.21 164.77,95.21 164.68,95.12 164.68,94.94 164.77,94.85 165.13,94.85 165.22,94.77 165.22,94.59 165.13,94.5 164.77,94.5 164.68,94.41 164.68,94.23 164.77,94.14 165.13,94.14 165.22,94.05 165.22,93.88 165.13,93.79 164.77,93.79 164.68,93.7 164.68,93.48 164.77,93.39 165.1,93.39 165.19,93.3 165.19,93.2 165.03,93.04 165.03,92.85 165.19,92.69 165.19,90.55 165.45,90.29 165.45,90.17 165.19,89.91 165.19,89.79 165.32,89.66 165.45,89.66 165.7,89.91 165.82,89.91 165.95,89.79 165.95,89.66 165.7,89.41 165.7,89.29 165.82,89.16 165.95,89.16 166.2,89.41 166.33,89.41 166.45,89.28 166.45,89.16 166.2,88.91 166.2,88.78 166.33,88.66 166.45,88.66 166.7,88.91 166.83,88.91 166.91,88.83 166.91,88.5 167,88.41 167.33,88.41 167.72,88.02 167.72,87.23 167.54,87.06 167.54,86.88 167.72,86.7 167.72,86.06 167.64,85.98 167.64,85.82 167.72,85.75 167.72,85.43 167.63,85.35 167.52,85.35 167.44,85.26 167.44,85.08 167.52,84.99 167.63,84.99 167.72,84.9 167.72,84.72 167.63,84.63 167.52,84.63 167.44,84.55 167.44,84.37 167.52,84.28 167.63,84.28 167.72,84.19 167.72,84.01 167.63,83.92 167.52,83.92 167.44,83.83 167.44,83.66 167.52,83.57 167.63,83.57 167.72,83.48 167.72,83.3 167.63,83.21 167.52,83.21 167.44,83.12 167.44,82.95 167.52,82.86 167.63,82.86 167.72,82.77 167.72,82.59 167.63,82.5 167.52,82.5 167.44,82.41 167.44,82.23 167.52,82.15 167.63,82.15 167.72,82.06 167.72,81.88 167.63,81.79 167.52,81.79 167.44,81.7 167.44,81.52 167.52,81.43 167.63,81.43 167.72,81.35 167.72,80.88 168.51,80.08 168.51,75.24 v1(168.78,74.97)
M_B_DQ18: length 49.4
  TOP w0.076: v1(155.87,108.95) U26.BG8
  TOP w0.102: CN11.50 v1(168.9,69.5)
  L3_IN1 w0.076: 162.06,98.13 161.9,98.29 161.83,98.29 160.3,99.82 160.3,101.76 157.24,104.82 157.24,107.48 155.87,108.84 v1(155.87,108.95)
  L3_IN1 w0.089: v1(168.9,69.5) 169.37,69.98 169.37,71.21 168.22,72.37 168.22,79.96 167.13,81.04 167.13,85.23 167.04,85.32 166.68,85.32 166.55,85.45 166.55,85.6 166.64,85.69 167.12,85.69 167.21,85.78 167.21,85.96 167.12,86.05 166.64,86.05 166.55,86.14 166.55,86.6 166.75,86.79 166.75,87.01 166.55,87.2 166.55,87.41 166.7,87.55 166.7,87.86 164.9,89.66 164.9,92.57 164.39,93.07 164.39,95.73 164.3,95.82 164.18,95.82 164,95.64 163.88,95.64 163.75,95.77 163.75,95.9 163.96,96.11 163.96,96.23 162.06,98.13
M_B_DQ19: length 50.4
  TOP w0.076: v1(154.96,108.95) U26.BF8
  TOP w0.102: CN11.63 165.65,75.46 v1(165.18,74.99)
  L3_IN1 w0.076: 158.22,98.42 157.79,98.86 157.79,101.26 156.2,102.85 156.2,106.54 154.59,108.14 154.59,108.55 154.96,108.91 v1(154.96,108.95)
  L3_IN1 w0.089: v1(165.18,74.99) 165.26,75.07 165.26,79.05 164.78,79.52 164.78,80.05 164.7,80.14 164.39,80.14 164.3,80.23 164.3,80.41 164.39,80.5 164.7,80.5 164.78,80.59 164.78,80.77 164.7,80.86 162.99,80.86 162.9,80.94 162.9,81.12 162.99,81.21 164.7,81.21 164.78,81.3 164.78,81.48 164.7,81.57 162.98,81.57 162.89,81.66 162.89,81.83 162.98,81.92 164.7,81.92 164.78,82.01 164.78,82.8 164.65,82.94 164.65,83.05 164.78,83.19 164.78,83.62 164.7,83.71 164.48,83.71 164.39,83.79 164.39,83.97 164.48,84.06 164.7,84.06 164.78,84.15 164.78,84.34 164.34,84.78 164.22,84.78 164.08,84.65 163.96,84.65 163.83,84.77 163.83,84.9 163.97,85.03 163.97,85.16 163.84,85.29 163.71,85.29 163.58,85.15 163.46,85.15 163.33,85.28 163.33,85.4 163.46,85.54 163.46,85.66 163.18,85.95 163.18,88.92 162.65,89.45 162.65,93.99 158.22,98.42
M_B_DQ20: length 51.9
  TOP w0.076: v1(154.96,110.89) U26.BF11
  TOP w0.102: CN11.62 v1(165.9,69.48)
  L3_IN1 w0.076: 157.4,98.42 157,98.81 157,101.41 155.75,102.67 155.75,106.5 154.26,107.99 154.26,108.7 154.41,108.85 154.41,110.34 v1(154.96,110.89)
  L3_IN1 w0.089: v1(165.9,69.48) 164.39,70.98 164.39,77.07 163.76,77.7 163.76,78.36 162.3,79.82 162.3,85.51 162.59,85.8 162.59,88.68 161.95,89.32 161.95,91.68 161.86,91.77 161.72,91.77 161.63,91.86 161.63,92.04 161.72,92.13 161.86,92.13 161.95,92.21 161.95,92.39 161.86,92.48 161.23,92.48 161.14,92.57 161.14,92.75 161.23,92.84 161.86,92.84 161.95,92.93 161.95,93.1 161.86,93.19 161.21,93.19 161.12,93.28 161.12,93.46 161.21,93.55 161.86,93.55 161.95,93.64 161.95,93.86 157.4,98.42
M_B_DQ21: length 51.7
  TOP w0.076: v1(154.96,110.25) U26.BF10
  TOP w0.102: v1(165.92,70.24) 166.25,70.24 166.9,69.59 CN11.58
  L3_IN1 w0.076: v1(154.96,110.25) 154.59,109.88 154.59,108.78 154.42,108.62 154.42,108.06 155.97,106.52 155.97,102.75 157.32,101.39 157.32,98.91 157.81,98.42
  L3_IN1 w0.089: 157.81,98.42 162.24,93.98 162.24,89.44 162.89,88.8 162.89,85.66 162.59,85.37 162.59,84.56 162.68,84.47 162.82,84.47 162.91,84.38 162.91,84.2 162.82,84.11 162.68,84.11 162.59,84.02 162.59,82.76 162.68,82.67 163.15,82.67 163.23,82.58 163.23,82.4 163.15,82.32 162.68,82.32 162.59,82.23 162.59,80.62 162.68,80.54 163.49,80.54 163.58,80.45 163.58,80.27 163.49,80.18 162.68,80.18 162.59,80.09 162.59,79.94 164.06,78.48 164.06,77.82 164.68,77.19 164.68,71.47 v1(165.92,70.24)
M_B_DQ22: length 49.1
  TOP w0.076: v1(155.87,108.3) U26.BG7
  TOP w0.102: v1(168.9,70.31) 169.9,69.31 CN11.46
  L3_IN1 w0.076: v1(155.87,108.3) 157.06,107.12 157.06,104.68 159.97,101.76 159.97,99.45 160.11,99.31 160.11,99.11
  L3_IN1 w0.089: v1(168.9,70.31) 167.68,71.53 167.68,78.12 167.15,78.65 167.15,80.08 166.84,80.39 166.84,84.29 166.26,84.87 166.26,87.88 164.6,89.54 164.6,92.45 164.1,92.95 164.1,94.98 163.32,95.76 163.32,95.89 163.46,96.03 163.46,96.16 163.33,96.28 163.21,96.28 163.06,96.14 162.94,96.14 162.81,96.27 162.81,96.39 163.03,96.61 163.03,96.73 162.9,96.86 162.77,96.86 162.56,96.64 162.44,96.64 162.31,96.77 162.31,96.9 162.51,97.1 162.51,97.22 162.38,97.35 162.26,97.35 162.06,97.15 161.93,97.15 161.81,97.27 161.81,97.4 161.97,97.56 161.97,97.69 161.85,97.82 161.72,97.82 161.56,97.65 161.43,97.65 160.11,98.97 160.11,99.11
M_B_DQ23: length 50
  TOP w0.076: v1(154.96,108.3) U26.BF7
  TOP w0.102: CN11.59 166.65,75.48 165.48,74.31 v1(165.21,74.31)
  L3_IN1 w0.076: v1(154.96,108.3) 154.96,108.12 156.42,106.65 156.42,102.92 158.13,101.22 158.13,98.75 158.47,98.42 158.64,98.42
  L3_IN1 w0.089: 158.64,98.42 159.03,98.42 159.21,98.24 159.21,98.11 159.15,98.05 159.15,97.93 159.27,97.8 159.4,97.8 159.46,97.86 159.58,97.86 159.71,97.74 159.71,97.61 159.65,97.55 159.65,97.42 159.77,97.3 159.9,97.3 159.96,97.36 160.09,97.36 160.21,97.23 160.21,97.11 160.15,97.04 160.15,96.92 160.28,96.79 160.4,96.79 160.46,96.86 160.59,96.86 160.72,96.73 160.72,96.6 160.65,96.54 160.65,96.42 160.78,96.29 160.91,96.29 160.97,96.35 161.09,96.35 161.22,96.23 161.22,96.1 161.16,96.04 161.16,95.91 161.28,95.79 161.41,95.79 161.47,95.85 161.6,95.85 161.72,95.72 161.72,95.6 161.66,95.54 161.66,95.41 161.79,95.28 161.91,95.28 161.97,95.35 162.1,95.35 162.22,95.22 162.22,95.1 162.16,95.03 162.16,94.91 162.29,94.78 162.41,94.78 162.48,94.84 162.6,94.84 162.94,94.5 162.94,89.57 163.47,89.04 163.47,86.07 163.99,85.55 164.12,85.55 164.4,85.82 164.52,85.82 164.65,85.7 164.65,85.57 164.37,85.29 164.37,85.17 164.5,85.04 164.62,85.04 164.84,85.26 164.96,85.26 165.09,85.13 165.09,85.01 164.87,84.79 164.87,84.67 165.1,84.44 165.1,79.62 165.55,79.17 165.55,77.36 165.74,77.16 166.28,77.16 166.36,77.08 166.36,76.9 166.28,76.81 165.74,76.81 165.65,76.72 165.65,76.54 165.74,76.45 166.3,76.45 166.39,76.36 166.39,76.19 166.3,76.1 165.74,76.1 165.65,76.01 165.65,75.83 165.74,75.74 166.29,75.74 166.38,75.65 166.38,75.48 166.29,75.39 165.74,75.39 165.65,75.3 165.65,74.75 v1(165.21,74.31)
M_B_DQ24: length 49.5
  TOP w0.076: v1(152.21,110.9) U26.BB11
  TOP w0.102: CN11.84 v1(160.4,69.72)
  L3_IN1 w0.076: v1(152.21,110.9) 151.68,110.36 151.68,108.89 151.22,108.43
  L3_IN1 w0.089: 151.22,108.43 151.22,103 152.1,102.12 152.1,99.35 153.77,97.69 153.77,96.72 157.22,93.27 157.22,85.88 157.57,85.54 157.57,85.38 157.48,85.3 157.06,85.3 156.97,85.21 156.97,85.03 157.06,84.94 157.48,84.94 157.57,84.85 157.57,84.67 157.48,84.58 157.03,84.58 156.94,84.5 156.94,84.32 157.03,84.23 157.48,84.23 157.57,84.14 157.57,81.41 157.78,81.19 157.78,72.33 v1(160.4,69.72)
M_B_DQ25: length 48.7
  TOP w0.076: v1(153.13,110.89) U26.BC11
  TOP w0.102: v1(162.87,74.33) 163.65,75.1 CN11.71
  L3_IN1 w0.076: v1(153.13,110.89) 153.66,110.35 153.66,109.95 153.68,109.94 153.68,108.88 154.04,108.51 154.04,107.85 154.12,107.77 154.12,106.63 154.44,106.3 ; 156.76,98.09 156.76,97.84
  L3_IN1 w0.089: 156.76,97.84 160.31,94.29 160.31,89.88 161.89,88.3 161.89,85.83 161.81,85.74 161.81,78.92 162.66,78.07 162.66,77.37 162.57,77.28 161.7,77.28 161.61,77.19 161.61,77.01 161.7,76.92 162.57,76.92 162.66,76.83 162.66,76.66 162.57,76.57 161.74,76.57 161.65,76.48 161.65,76.3 161.74,76.21 162.57,76.21 162.66,76.12 162.66,75.95 162.57,75.86 161.86,75.86 161.77,75.77 161.77,75.59 161.86,75.5 162.33,75.5 162.47,75.36 162.47,74.73 v1(162.87,74.33) ; 154.44,106.3 154.62,106.13 154.62,102.55 156.1,101.06 156.1,99.14 156.76,98.48 156.76,98.09
M_B_DQ26: length 48.1
  TOP w0.076: v1(152.21,108.95) U26.BB8
  TOP w0.102: CN11.83 160.65,74.53 160.44,74.33 160.3,74.33 160.16,74.33 159.9,74.07 159.9,73.79 159.4,73.28 v1(159.22,73.28)
  L3_IN1 w0.089: v1(152.21,108.95) 152.21,108.84 151.84,108.46 151.84,103.09 152.68,102.24 152.68,99.55 154.35,97.88 154.35,96.97 157.99,93.33 157.99,88.58 158.37,88.21 158.37,84.44 158.17,84.24 158.17,81.63 158.64,81.16 158.64,80.9 158.55,80.81 158.47,80.81 158.38,80.72 158.38,80.54 158.47,80.45 158.55,80.45 158.64,80.36 158.64,80.19 158.55,80.1 158.47,80.1 158.38,80.01 158.38,79.83 158.47,79.74 158.55,79.74 158.64,79.65 158.64,79.48 158.55,79.39 158.47,79.39 158.38,79.3 158.38,79.12 158.47,79.03 158.55,79.03 158.64,78.94 158.64,78.76 158.55,78.68 158.47,78.68 158.38,78.59 158.38,78.41 158.47,78.32 158.55,78.32 158.64,78.23 158.64,78.05 158.55,77.96 158.45,77.96 158.37,77.88 158.37,77.7 158.45,77.61 158.55,77.61 158.64,77.52 158.64,77.34 158.55,77.25 158.47,77.25 158.38,77.16 158.38,76.99 158.47,76.9 158.75,76.9 158.84,76.81 158.84,76.63 158.75,76.54 158.47,76.54 158.38,76.45 158.38,76.28 158.47,76.19 158.75,76.19 158.84,76.1 158.84,75.92 158.75,75.83 158.47,75.83 158.38,75.74 158.38,75.56 158.47,75.48 158.76,75.48 158.85,75.38 158.85,75.12 158.76,75.03 158.51,75.03 158.42,74.94 158.42,74.76 158.52,74.66 158.72,74.66 158.9,74.48 158.9,74.31 158.81,74.22 158.64,74.22 158.55,74.13 158.55,73.95 v1(159.22,73.28)
M_B_DQ27: length 47.5
  TOP w0.076: v1(153.13,108.95) U26.BC8
  TOP w0.102: CN11.66 164.9,69.31 v1(163.89,70.31)
  L3_IN1 w0.076: v1(153.13,108.95) 153.13,108.84 153.55,108.41 153.55,107.69 153.76,107.48 153.76,105.99
  L3_IN1 w0.089: v1(163.89,70.31) 162.07,72.13 162.07,73.84 161.36,74.54 161.36,75.16 160.64,75.87 160.64,77.79 160.47,77.96 160.47,78.04 160.56,78.13 160.79,78.13 160.88,78.22 160.88,78.4 160.79,78.49 160.56,78.49 160.47,78.58 160.47,78.75 160.56,78.84 160.78,78.84 160.87,78.93 160.87,79.11 160.78,79.2 160.56,79.2 160.47,79.29 160.47,83.82 160.58,83.93 160.58,88.45 159.73,89.31 159.73,94.05 156.05,97.73 156.05,98.19 153.96,100.27 153.96,105.79 153.76,105.99
M_B_DQ28: length 48.5
  TOP w0.076: v1(153.13,110.25) U26.BC10
  TOP w0.102: v1(162.98,73.61) 163.16,73.8 163.27,73.8 164.65,75.17 CN11.67
  L3_IN1 w0.076: v1(153.13,110.25) 153.51,109.87 153.51,108.75 153.78,108.47 153.78,107.77 153.93,107.61 153.93,106.47 154.24,106.16
  L3_IN1 w0.089: 154.24,106.16 154.24,102.52 155.81,100.95 155.81,98.86 156.33,98.34 156.33,97.87 160.02,94.17 160.02,89.76 161.6,88.18 161.6,87.63 161.51,87.54 161.21,87.54 161.12,87.46 161.12,87.28 161.21,87.19 161.51,87.19 161.6,87.1 161.6,85.95 161.46,85.81 161.46,85.66 161.37,85.57 160.98,85.57 160.89,85.48 160.89,85.3 160.98,85.21 161.37,85.21 161.46,85.12 161.46,84.94 161.37,84.86 160.98,84.86 160.89,84.77 160.89,84.59 160.98,84.5 161.37,84.5 161.46,84.41 161.46,81.91 161.37,81.82 161.11,81.82 161.02,81.73 161.02,81.56 161.11,81.47 161.37,81.47 161.46,81.38 161.46,78.92 161.31,78.78 161.31,75.62 161.65,75.28 161.65,74.67 162.71,73.61 v1(162.98,73.61)
M_B_DQ29: length 49.6
  TOP w0.076: v1(152.21,110.25) U26.BB10
  TOP w0.102: CN11.80 161.4,69.4 v1(160.39,70.41)
  L3_IN1 w0.076: v1(152.21,110.25) 151.84,109.88 151.84,108.8 151.56,108.51
  L3_IN1 w0.089: v1(160.39,70.41) 158.07,72.73 158.07,81.31 157.86,81.53 157.86,84.34 158.07,84.56 158.07,85.9 157.98,85.99 157.65,85.99 157.57,86.08 157.57,86.26 157.65,86.35 158.01,86.35 158.07,86.41 158.07,86.65 158.01,86.7 157.65,86.7 157.57,86.79 157.57,86.97 157.65,87.06 157.98,87.06 158.07,87.15 158.07,87.33 157.98,87.41 157.65,87.41 157.57,87.5 157.57,87.68 157.65,87.77 157.98,87.77 158.07,87.86 158.07,88.05 157.7,88.42 157.7,93.21 154.06,96.85 154.06,97.82 152.48,99.4 152.48,102.12 151.56,103.04 151.56,108.51
M_B_DQ30: length 45.6
  TOP w0.076: v1(153.13,108.3) U26.BC7
  TOP w0.102: CN11.70 v1(163.9,69.57)
  L3_IN1 w0.076: 153.13,107.87 153.59,107.41 153.59,105.71 153.73,105.56
  L3_IN1 w0.089: v1(163.9,69.57) 161.78,71.69 161.78,73.72 161.07,74.42 161.07,75.03 160.35,75.75 160.35,77.67 160.18,77.84 160.18,81.91 160,82.08 160,82.49 160.18,82.66 160.18,83.08 159.9,83.35 159.9,83.67 160.29,84.05 160.29,88.33 159.44,89.18 159.44,93.93 155.7,97.67 155.7,98.15 153.73,100.11 153.73,105.56 ; v1(153.13,108.3) 153.13,107.87
M_B_DQ31: length 47.8
  TOP w0.076: v1(152.21,108.3) U26.BB7
  TOP w0.102: CN11.79 161.65,75.02 159.97,73.35 159.97,73.21 160.39,72.79 160.39,72.65 160.24,72.51 160.1,72.51 159.68,72.92 159.54,72.92 v1(159.23,72.61)
  L3_IN1 w0.089: v1(159.23,72.61) 159.78,73.16 159.78,74.02 159.14,74.65 159.14,77.24 158.94,77.45 158.94,81.28 158.46,81.76 158.46,83.87 158.66,84.07 158.66,84.44 158.88,84.67 158.99,84.67 159.08,84.75 159.08,84.93 158.99,85.02 158.75,85.02 158.66,85.11 158.66,85.29 158.75,85.38 159.02,85.38 159.11,85.47 159.11,85.64 159.02,85.73 158.75,85.73 158.66,85.82 158.66,86 158.75,86.09 159.02,86.09 159.11,86.18 159.11,86.35 159.02,86.44 158.75,86.44 158.66,86.53 158.66,88.33 158.28,88.71 158.28,93.45 154.65,97.09 154.65,97.99 152.91,99.72 152.91,102.3 152.21,103 v1(152.21,108.3)
M_B_DQ32: length 50.5
  TOP w0.076: v1(135.76,110.9) U26.AA11
  TOP w0.102: v1(131.33,74.25) 131.92,74.25 132.65,74.98 CN11.187
  L3_IN1 w0.076: v1(135.76,110.9) 135.22,110.37 135.22,108.87 134.86,108.51 134.86,107.82 134.5,107.46 134.5,101.8 131.8,99.1 131.8,97.27 131.49,96.95
  L3_IN1 w0.089: v1(131.33,74.25) 130.87,74.25 130.58,74.54 130.58,74.96 131.04,75.42 131.04,75.55 130.85,75.73 130.73,75.73 130.36,75.35 130.23,75.35 130.1,75.48 130.1,75.6 130.48,75.98 130.48,76.1 130.39,76.19 130.21,76.19 130.06,76.34 130.06,76.57 130.26,76.77 130.26,76.9 130.12,77.04 130,77.04 129.77,76.81 129.59,76.81 129.45,76.95 129.45,77.26 129.61,77.42 129.61,77.73 129.45,77.89 129.45,78.15 129.53,78.23 130.07,78.23 130.16,78.32 130.16,78.5 130.07,78.59 129.54,78.59 129.46,78.68 129.46,78.86 129.54,78.94 130.07,78.94 130.16,79.03 130.16,79.21 130.07,79.3 129.66,79.3 129.61,79.35 129.61,80.14 127.8,81.95 127.8,84.95 128.07,85.21 128.07,85.34 127.8,85.6 127.8,86.13 127.85,86.18 127.85,88.31 130.17,90.64 130.17,95.64 131.49,96.95
M_B_DQ33: length 50.1
  TOP w0.076: v1(135.76,110.25) U26.AA10
  TOP w0.102: v1(131.34,73.63) 132.01,73.63 133.65,75.27 CN11.183
  L3_IN1 w0.076: v1(135.76,110.25) 135.39,109.88 135.39,108.81 135.1,108.52 135.1,107.82 134.67,107.39 134.67,101.73 132.03,99.09 132.03,97.08 131.9,96.95
  L3_IN1 w0.089: v1(131.34,73.63) 131.39,73.63 132.11,74.35 132.11,75.06 131,76.17 131,76.63 130.91,76.72 130.64,76.72 130.55,76.81 130.55,76.99 130.64,77.08 130.91,77.08 131,77.17 131,77.34 130.91,77.43 130.64,77.43 130.59,77.49 130.59,77.73 130.64,77.79 130.91,77.79 131,77.88 131,78.06 130.91,78.14 130.61,78.14 130.52,78.23 130.52,78.41 130.61,78.5 130.94,78.5 131,78.56 131,78.79 130.94,78.86 130.59,78.86 130.5,78.94 130.5,79.12 130.59,79.21 130.77,79.21 130.86,79.3 130.86,79.51 130.77,79.6 130.58,79.6 130.49,79.69 130.49,80.02 130.21,80.3 129.86,80.3 129.65,80.52 129.65,80.64 129.81,80.81 129.81,80.93 129.68,81.06 129.56,81.06 129.39,80.89 129.27,80.89 128.1,82.07 128.1,84.76 128.85,85.51 128.85,88.9 130.46,90.52 130.46,95.52 131.9,96.95
M_B_DQ34: length 48.6
  TOP w0.076: v1(136.67,110.9) 136.85,110.77 U26.AC11
  TOP w0.102: v1(135.41,72.4) 136.48,73.46 136.48,74.9 137.15,75.56 CN11.169
  L3_IN1 w0.076: v1(136.67,110.9) 137.21,110.36 137.21,110.15 137.22,110.14 137.22,108.88 137.37,108.73 137.37,108.01 136.89,107.53 136.89,100.87 135.23,99.21 135.23,98.49
  L3_IN1 w0.089: 135.23,98.49 135.23,96.55 133.09,94.41 133.09,88.67 132.2,87.79 132.2,87.34 132.83,86.72 132.83,86.52 132.74,86.43 132.38,86.43 132.29,86.35 132.29,86.17 132.38,86.08 132.61,86.08 132.83,85.86 132.83,81.99 135.04,79.78 135.04,74.01 135.79,73.26 135.79,72.77 v1(135.41,72.4)
M_B_DQ35: length 47.9
  TOP w0.076: v1(136.67,110.25) 136.85,110.12 U26.AC10
  TOP w0.102: CN11.173 136.15,73.88 v1(135.31,73.04)
  L3_IN1 w0.076: 134.94,98.49 134.94,99.17 136.66,100.9 136.66,107.54 137.2,108.08 137.2,108.66 137.05,108.81 137.05,109.87 v1(136.67,110.25)
  L3_IN1 w0.089: v1(135.31,73.04) 134.75,73.61 134.75,79.66 134.12,80.29 133.94,80.29 133.55,80.68 133.55,80.86 133.35,81.06 133.17,81.06 133.09,81.14 133.09,81.32 132.96,81.45 132.78,81.45 132.66,81.57 132.66,81.75 132.49,81.92 132.31,81.92 131.87,82.36 131.87,83.86 131.95,83.94 131.95,84.41 132.04,84.5 132.43,84.5 132.52,84.59 132.52,84.76 132.43,84.85 132.04,84.85 131.95,84.94 131.95,85.12 132.04,85.21 132.43,85.21 132.52,85.3 132.52,85.47 132.43,85.56 132.04,85.56 131.95,85.65 131.95,86.42 132.27,86.74 132.27,86.86 131.89,87.24 131.89,87.89 132.8,88.8 132.8,94.53 134.94,96.67 134.94,98.49
M_B_DQ36: length 47.5
  TOP w0.076: v1(135.76,108.3) U26.AA7
  TOP w0.102: CN11.182 133.9,69.32 132.5,70.72 v1(132.37,70.72)
  L3_IN1 w0.076: v1(135.76,108.3) 135.63,108.18 135.63,101.22 133.19,98.78 133.19,98.41
  L3_IN1 w0.089: 133.19,98.41 133.19,97.42 131.05,95.28 131.05,90.28 129.43,88.66 129.43,82.14 131.45,80.12 131.45,79.27 131.59,79.13 131.59,77.38 131.68,77.29 132.35,77.29 132.46,77.18 132.46,77.03 132.37,76.94 131.68,76.94 131.59,76.85 131.59,76.41 132.69,75.3 132.69,74.11 132.15,73.57 132.15,73.34 131.73,72.92 131.73,71.36 v1(132.37,70.72)
M_B_DQ37: length 48
  TOP w0.076: v1(135.76,108.95) U26.AA8
  TOP w0.102: CN11.186 132.9,69.69 132.54,70.05 v1(132.36,70.05)
  L3_IN1 w0.076: 132.21,96.95 132.21,99.02 133.43,100.24 133.43,100.25 134.05,100.88 134.06,100.88 134.84,101.66 134.84,107.33 135.27,107.75 135.27,108.39 135.76,108.88 v1(135.76,108.95)
  L3_IN1 w0.089: 132.21,96.95 132.21,96.85 130.76,95.4 130.76,90.4 129.14,88.78 129.14,85.39 128.39,84.63 128.39,82.19 128.67,81.91 128.79,81.91 128.96,82.07 129.08,82.07 129.21,81.95 129.21,81.82 129.11,81.73 129.11,81.52 129.22,81.42 129.73,81.42 131.15,80 131.15,79.15 131.29,79.01 131.29,76.29 132.4,75.18 132.4,74.23 131.86,73.69 131.86,73.46 131.44,73.04 131.44,70.97 v1(132.36,70.05)
M_B_DQ38: length 46.3
  TOP w0.076: U26.AC8 136.85,108.82 v1(136.67,108.95)
  TOP w0.102: v1(136.4,70.84) 136.9,70.34 CN11.170
  L3_IN1 w0.076: 134.65,98.49 134.65,99.14 136.43,100.92 136.43,107.54 137.04,108.15 137.04,108.58 v1(136.67,108.95)
  L3_IN1 w0.089: 134.65,98.49 134.65,96.79 132.51,94.65 132.51,88.92 131.6,88.01 131.6,87.12 131.66,87.05 131.66,84.06 131.58,83.98 131.58,82.17 133.42,80.33 133.42,79.03 134.45,78 134.45,72.21 135.82,70.84 v1(136.4,70.84)
M_B_DQ39: length 46
  TOP w0.076: U26.AC7 136.85,108.17 v1(136.67,108.3)
  TOP w0.102: v1(136.41,70.13) 135.9,69.62 CN11.174
  L3_IN1 w0.076: 134.36,98.49 134.36,99.16 136.26,101.06 136.26,107.61 136.67,108.01 v1(136.67,108.3)
  L3_IN1 w0.089: v1(136.41,70.13) 136.11,70.13 134.16,72.08 134.16,77.11 133.13,78.15 133.13,80.21 130.6,82.74 130.6,88.11 132.22,89.73 132.22,94.78 134.36,96.92 134.36,98.49
M_B_DQ40: length 50.5
  TOP w0.076: v1(133.93,108.95) U26.W8
  TOP w0.102: CN11.195 130.65,74.76 129.83,73.94 v1(129.83,73.47)
  L3_IN1 w0.076: 129.7,96.95 130.81,98.07 130.81,98.81 134.01,102 134.01,107.86 134.3,108.15 134.3,108.45 133.93,108.82 v1(133.93,108.95)
  L3_IN1 w0.089: 129.7,96.95 128.46,95.72 128.46,95.6 128.6,95.46 128.6,95.35 128.51,95.26 128.11,95.26 128.03,95.19 128.03,94.99 128.11,94.91 128.51,94.91 128.6,94.82 128.6,94.64 128.51,94.55 128.11,94.55 128.03,94.48 128.03,94.27 128.11,94.2 128.51,94.2 128.6,94.11 128.6,93.93 128.51,93.84 128.11,93.84 128.03,93.76 128.03,93.57 128.11,93.49 128.51,93.49 128.6,93.4 128.6,93.22 128.51,93.13 128.12,93.13 128.03,93.05 128.03,92.86 128.12,92.78 128.51,92.78 128.6,92.69 128.6,92.51 128.51,92.42 128.12,92.42 128.04,92.33 128.04,92.15 128.12,92.06 128.51,92.06 128.6,91.98 128.6,91.68 128.51,91.59 128.12,91.59 128.03,91.51 128.03,91.32 128.12,91.23 128.51,91.23 128.6,91.15 128.6,90.9 128.54,90.84 128.11,90.84 128.03,90.76 128.03,90.58 128.24,90.37 128.24,90.24 126.77,88.76 126.77,86.62 126.72,86.58 126.72,81.44 128.37,79.8 128.37,76.51 129.02,75.85 129.02,74.55 129.2,74.37 129.2,74.24 129.09,74.13 129.09,74.01 129.22,73.88 129.34,73.88 129.45,73.99 129.58,73.99 129.83,73.74 v1(129.83,73.47)
M_B_DQ41: length 49.9
  TOP w0.076: v1(133.93,108.3) U26.W7
  TOP w0.102: v1(129.91,72.76) 130.34,73.18 130.34,74.02 130.96,74.65 130.96,74.92 131.65,75.6 CN11.191
  L3_IN1 w0.076: 129.29,96.95 130.58,98.25 130.58,98.81 133.77,102 133.77,108.15 v1(133.93,108.3)
  L3_IN1 w0.089: v1(129.91,72.76) 129.87,72.76 128.73,73.89 128.73,75.73 128.08,76.38 128.08,79.68 126.43,81.32 126.43,86.7 126.47,86.74 126.47,88.88 127.74,90.15 127.74,90.22 127.65,90.31 127.41,90.31 127.32,90.4 127.32,90.58 127.41,90.67 127.65,90.67 127.74,90.76 127.74,90.94 127.65,91.02 127.41,91.02 127.32,91.11 127.32,91.29 127.41,91.38 127.65,91.38 127.74,91.47 127.74,91.65 127.65,91.74 127.41,91.74 127.32,91.82 127.32,92 127.41,92.09 127.65,92.09 127.74,92.18 127.74,92.36 127.65,92.45 127.41,92.45 127.32,92.54 127.32,92.71 127.41,92.8 127.65,92.8 127.74,92.89 127.74,93.07 127.65,93.16 127.31,93.16 127.23,93.25 127.23,93.43 127.31,93.51 127.65,93.51 127.74,93.6 127.74,93.78 127.65,93.87 127.33,93.87 127.24,93.96 127.24,94.14 127.33,94.23 127.65,94.23 127.74,94.31 127.74,94.49 127.65,94.58 127.34,94.58 127.25,94.67 127.25,94.85 127.34,94.94 127.65,94.94 127.74,95.03 127.74,95.41 129.29,96.95
M_B_DQ42: length 51.7
  TOP w0.076: v1(133.01,110.25) U26.V10
  TOP w0.102: CN11.204 128.4,70.34 127.96,70.77 v1(127.85,70.77)
  L3_IN1 w0.076: 127.2,97.48 127.2,98.38 127.7,98.89 128.63,98.89 128.95,99.2 128.95,99.88 131.94,102.87 131.94,107.18 132.46,107.7 132.46,108.62 132.64,108.81 132.64,109.88 v1(133.01,110.25)
  L3_IN1 w0.089: v1(127.85,70.77) 127.85,72.37 126.69,73.53 126.69,74.11 126.58,74.22 126.58,74.55 125.94,75.19 125.94,75.44 125.86,75.53 125.86,79.41 124.69,80.58 124.69,81.02 123.68,82.04 123.68,84.04 123.45,84.26 123.45,88.34 124.87,89.75 124.87,90.01 124.78,90.1 124.52,90.1 124.43,90.19 124.43,90.37 124.52,90.45 124.78,90.45 124.87,90.54 124.87,90.72 124.78,90.81 124.52,90.81 124.43,90.9 124.43,91.08 124.52,91.17 124.78,91.17 124.87,91.25 124.87,91.43 124.78,91.52 124.52,91.52 124.43,91.61 124.43,91.79 124.52,91.88 124.78,91.88 124.87,91.97 124.87,92.14 124.78,92.23 124.52,92.23 124.43,92.32 124.43,94.57 127.2,97.34 127.2,97.48
M_B_DQ43: length 52.6
  TOP w0.076: v1(133.01,110.9) U26.V11
  TOP w0.102: CN11.208 127.39,69.65 v1(127.85,70.11)
  L3_IN1 w0.076: 126.88,97.48 126.88,98.31 128.28,99.71 128.52,99.71 131.74,102.92 131.74,107.33 132.29,107.89 132.29,108.69 132.48,108.87 132.48,110.37 v1(133.01,110.9)
  L3_IN1 w0.089: v1(127.85,70.11) 127.5,70.11 127.37,70.24 127.37,70.66 127.28,70.75 126.85,70.75 126.76,70.84 126.76,71.13 126.85,71.22 127.45,71.22 127.53,71.31 127.53,71.49 127.45,71.58 126.86,71.58 126.78,71.67 126.78,71.85 126.86,71.93 127.45,71.93 127.53,72.02 127.53,72.2 127.45,72.29 127.05,72.29 126.89,72.45 126.89,72.91 126.4,73.41 126.4,73.99 126.29,74.1 126.29,74.42 125.65,75.06 125.65,75.32 125.57,75.41 125.57,79.29 124.4,80.46 124.4,80.9 123.38,81.91 123.38,83.91 123.16,84.14 123.16,88.46 124.14,89.44 124.14,94.69 126.88,97.44 126.88,97.48
M_B_DQ44: length 52.5
  TOP w0.076: v1(133.93,110.9) U26.W11
  TOP w0.102: CN11.190 131.9,69.55 131.79,69.66 131.79,69.89 v1(130.94,70.73)
  L3_IN1 w0.076: v1(133.93,110.9) 134.45,110.38 134.45,109.96 134.47,109.94 134.47,108.79 134.63,108.64 134.63,107.91 134.34,107.62 134.34,101.86 131.5,99.02 131.5,97.67 130.79,96.95
  L3_IN1 w0.089: v1(130.94,70.73) 130.71,70.96 130.71,72.52 130.91,72.72 130.91,72.96 130.71,73.16 130.71,73.71 129.6,74.81 129.6,76.1 128.95,76.75 128.95,80.04 127.31,81.68 127.31,86.34 127.35,86.38 127.35,88.52 129.68,90.85 129.68,92.09 129.59,92.18 129.27,92.18 129.18,92.27 129.18,92.45 129.27,92.53 129.59,92.53 129.68,92.62 129.68,92.8 129.59,92.89 129.27,92.89 129.18,92.98 129.18,93.16 129.27,93.25 129.59,93.25 129.68,93.33 129.68,93.51 129.59,93.6 129.27,93.6 129.18,93.69 129.18,93.87 129.27,93.96 129.59,93.96 129.68,94.05 129.68,94.22 129.59,94.31 129.27,94.31 129.18,94.4 129.18,94.58 129.27,94.67 129.59,94.67 129.68,94.76 129.68,94.93 129.59,95.02 129.27,95.02 129.18,95.11 129.18,95.29 129.27,95.38 129.59,95.38 129.68,95.47 129.68,95.85 130.79,96.95
M_B_DQ45: length 51.8
  TOP w0.076: v1(133.93,110.25) U26.W10
  TOP w0.102: CN11.194 130.9,69.35 v1(130.72,69.53)
  L3_IN1 w0.076: v1(133.93,110.25) 134.31,109.87 134.31,108.72 134.46,108.57 134.46,108.08 134.17,107.79 134.17,101.93 131.15,98.91 131.15,98 130.11,96.95
  L3_IN1 w0.089: 130.11,96.95 128.89,95.73 128.89,91.86 128.98,91.77 129.29,91.77 129.38,91.68 129.38,91.51 129.29,91.42 128.98,91.42 128.89,91.33 128.89,91.19 129.11,90.97 129.11,90.69 127.06,88.64 127.06,86.5 127.02,86.46 127.02,81.56 128.66,79.92 128.66,76.63 129.31,75.97 129.31,74.67 130.4,73.58 130.4,71.76 130.31,71.67 129.77,71.67 129.68,71.59 129.68,71.41 129.77,71.32 130.31,71.32 130.4,71.23 130.4,71.05 130.31,70.96 129.8,70.96 129.71,70.87 129.71,70.7 129.8,70.61 130.24,70.61 130.33,70.52 130.33,70.31 130.2,70.18 129.87,70.18 129.77,70.08 129.77,69.89 129.86,69.8 130.44,69.8 v1(130.72,69.53)
M_B_DQ46: length 49.7
  TOP w0.076: v1(133.01,108.3) U26.V7
  TOP w0.102: v1(127.19,73.72) 127.19,73.28 127.27,73.21 128.57,73.21 128.65,73.28 CN11.203
  L3_IN1 w0.076: 127.79,97.48 127.79,97.67 128.1,97.98 128.81,97.98 133.13,102.3 133.13,108.18 v1(133.01,108.3)
  L3_IN1 w0.089: v1(127.19,73.72) 127.47,73.72 127.57,73.81 127.57,75.2 127.06,75.71 126.94,75.71 126.86,75.63 126.73,75.63 126.61,75.75 126.61,75.88 126.69,75.96 126.69,76.08 126.44,76.33 126.44,79.66 125.27,80.83 125.27,81.59 124.8,82.06 124.8,88.86 125.46,89.52 125.46,89.77 125.55,89.85 125.79,89.85 125.88,89.94 125.88,90.12 125.79,90.21 125.55,90.21 125.46,90.3 125.46,92.61 125.55,92.7 125.96,92.7 126.04,92.79 126.04,92.97 125.96,93.06 125.55,93.06 125.46,93.15 125.46,93.32 125.55,93.41 125.96,93.41 126.04,93.5 126.04,93.68 125.96,93.77 125.55,93.77 125.46,93.86 125.46,94.04 125.55,94.12 125.96,94.12 126.04,94.21 126.04,94.39 125.96,94.48 125.55,94.48 125.46,94.57 125.46,94.77 125.58,94.89 126,94.89 126.06,94.95 126.06,95.36 127.79,97.1 127.79,97.48
M_B_DQ47: length 50.4
  TOP w0.076: v1(133.01,108.95) U26.V8
  TOP w0.102: v1(127.09,74.45) 127.34,74.2 127.94,74.2 128.19,74.45 128.19,74.83 127.65,75.38 CN11.207
  L3_IN1 w0.076: v1(133.01,108.95) 133.01,108.94 132.64,108.56 132.64,107.58 132.17,107.11 132.17,102.86 129.11,99.81 129.11,99.13 128.7,98.72 127.89,98.72 127.5,98.33 127.5,97.48
  L3_IN1 w0.089: 127.5,97.48 127.5,97.23 125.17,94.9 125.17,94.6 125.08,94.51 124.81,94.51 124.72,94.42 124.72,94.24 124.81,94.15 125.08,94.15 125.17,94.06 125.17,93.89 125.08,93.8 124.81,93.8 124.72,93.71 124.72,93.53 124.81,93.44 125.08,93.44 125.17,93.35 125.17,93.17 125.08,93.09 124.81,93.09 124.72,93 124.72,92.82 125.17,92.37 125.17,89.64 124.51,88.98 124.51,88.63 124.33,88.46 123.99,88.46 123.84,88.31 123.84,88.1 123.93,88.02 124.39,88.02 124.47,87.93 124.47,87.75 124.39,87.66 123.93,87.66 123.84,87.57 123.84,85.83 124.06,85.61 124.39,85.61 124.47,85.52 124.47,85.34 124.39,85.26 123.84,85.26 123.75,85.17 123.75,84.99 123.84,84.9 124.39,84.9 124.47,84.81 124.47,84.63 124.39,84.54 123.94,84.54 123.85,84.46 123.85,84.28 123.94,84.19 124.39,84.19 124.47,84.1 124.47,83.92 124.39,83.83 124.06,83.83 123.97,83.74 123.97,82.16 124.98,81.14 124.98,80.71 126.15,79.54 126.15,75.65 126.23,75.56 126.23,75.31 v1(127.09,74.45)
M_B_DQ48: length 60
  TOP w0.076: v1(131.18,110.9) U26.R11
  TOP w0.102: CN11.211 126.65,75.4 126.57,75.33 126.57,72.97 v1(126.27,72.67)
  L3_IN1 w0.076: 126.23,97.48 126.38,97.63 126.38,98.22 128.03,99.87 128.45,99.87 131.51,102.93 131.51,107.33 132.13,107.95 132.13,108.47 131.73,108.87 131.73,108.88 131.73,108.88 131.73,109.16 131.73,109.16 131.73,110.15 131.72,110.15 131.72,110.79 131.61,110.9 v1(131.18,110.9)
  L3_IN1 w0.089: 126.23,97.48 123.64,94.9 123.64,89.64 122.05,88.05 122.05,87.92 122.19,87.78 122.19,87.67 122.12,87.59 121.95,87.59 121.86,87.5 121.86,87.24 121.95,87.15 122.12,87.15 122.21,87.06 122.21,86.89 122.12,86.8 121.92,86.8 121.86,86.73 121.86,86.38 121.94,86.3 122.57,86.3 122.66,86.21 122.66,86.03 122.57,85.95 121.9,85.95 121.86,85.9 121.86,85.64 121.9,85.59 122.59,85.59 122.67,85.52 122.67,85.31 122.59,85.23 121.93,85.23 121.86,85.16 121.86,84.95 121.93,84.88 122.59,84.88 122.67,84.81 122.67,84.6 122.59,84.52 122.08,84.52 121.99,84.43 121.99,84.21 122.08,84.12 122.38,84.12 122.47,84.03 122.47,83.85 122.38,83.76 122.24,83.76 122.15,83.67 122.15,83.4 122.24,83.31 122.33,83.31 122.42,83.22 122.42,83.04 122.33,82.95 122.24,82.95 122.15,82.87 122.15,82.78 122.32,82.61 122.32,82.51 122.15,82.34 122.15,82.25 122.32,82.08 122.32,81.96 122.25,81.89 122.25,81.76 122.38,81.64 122.5,81.64 122.67,81.8 122.79,81.8 122.93,81.66 122.93,81.57 122.75,81.39 122.75,81.26 122.88,81.14 123.01,81.14 123.18,81.31 123.29,81.31 123.45,81.15 123.45,81.04 123.07,80.66 123.07,80.31 123.35,80.03 123.47,80.03 123.73,80.29 123.85,80.29 123.98,80.16 123.98,80.04 123.72,79.78 123.72,79.65 124.16,79.22 124.58,79.22 124.69,79.11 124.69,78.69 125.07,78.31 125.07,75.2 125.16,75.12 125.16,74.49 125.24,74.4 125.61,74.4 125.7,74.31 125.7,74.13 125.61,74.04 125.24,74.04 125.16,73.95 125.16,73.79 125.5,73.45 125.5,73.33 125.22,73.05 125.22,72.93 125.34,72.81 125.48,72.81 125.82,73.15 125.95,73.15 126.27,72.82 v1(126.27,72.67)
M_B_DQ49: length 59.6
  TOP w0.076: v1(130.27,110.9) U26.P11
  TOP w0.102: CN11.228 122.39,69.57 122.86,70.03 v1(122.92,70.03)
  L3_IN1 w0.076: v1(130.27,110.9) 129.74,110.37 129.74,109.35 129.43,109.04 129.43,107.83 128.99,107.4 128.99,103.67 126.52,101.2 125.89,101.2 125.45,101.64 125.45,101.88 124.87,102.46 124.84,102.46
  L3_IN1 w0.089: 124.84,102.46 119.77,102.46 116.84,99.53 116.84,95.58 118.05,94.37 118.05,88.31 118.37,87.99 118.37,81.51 119.58,80.3 119.58,79.27 120.89,77.96 120.89,72.06 121.01,71.94 121.14,71.94 121.48,72.29 121.61,72.29 121.74,72.16 121.74,72.04 121.39,71.69 121.39,71.57 121.51,71.44 121.64,71.44 121.94,71.74 122.07,71.74 122.19,71.61 122.19,71.49 121.89,71.19 121.89,71.06 v1(122.92,70.03)
M_B_DQ50: length 55.7
  TOP w0.076: v1(130.27,108.3) U26.P7
  TOP w0.102: v1(121.68,73.36) 122.47,74.16 122.47,74.88 123.15,75.55 CN11.225
  L3_IN1 w0.076: v1(130.27,108.3) 130.27,107.68 129.78,107.19 129.78,103.76 126.73,100.71 125.66,100.71 124.86,101.51 124.84,101.51
  L3_IN1 w0.089: v1(121.68,73.36) 121.68,73.44 122.11,73.87 122.54,73.87 122.63,73.96 122.63,74.14 122.54,74.23 122.43,74.23 122.34,74.32 122.34,74.99 122.43,75.08 122.97,75.08 123.04,75.15 123.04,75.37 122.97,75.44 122.43,75.44 122.34,75.52 122.34,75.7 122.43,75.79 122.97,75.79 123.04,75.86 123.04,76.08 122.97,76.15 122.43,76.15 122.34,76.24 122.34,76.41 122.43,76.5 122.7,76.5 122.79,76.59 122.79,76.74 122.68,76.86 122.43,76.86 122.34,76.95 122.34,77.23 122.11,77.45 122.11,78.22 121.04,79.3 121.04,80.09 119.25,81.88 119.25,88.27 119.81,88.83 119.81,93.85 117.8,95.86 117.8,99.26 120.05,101.51 124.84,101.51
M_B_DQ51: length 56.4
  TOP w0.076: U26.R8 131.2,108.94 v1(131.18,108.94)
  TOP w0.102: CN11.212 126.39,71.94 v1(126.3,72.04)
  L3_IN1 w0.076: 125.4,97.49 125.86,97.95 125.86,98.54 127.53,100.2 128.28,100.2 131.16,103.08 131.16,107.53 131.57,107.93 131.57,108.56 v1(131.18,108.94)
  L3_IN1 w0.089: v1(126.3,72.04) 126.14,72.2 125.84,72.2 125.75,72.11 125.75,71.67 125.84,71.59 126.18,71.59 126.27,71.5 126.27,71.32 126.18,71.23 125.84,71.23 125.75,71.14 125.75,71.02 125.66,70.94 125.5,70.94 125.17,71.27 125.17,71.39 125.4,71.62 125.4,71.77 125.31,71.86 124.76,71.86 124.57,72.05 124.57,74.87 124.49,74.96 124.49,78.07 122.48,80.07 122.48,80.69 121.29,81.88 121.29,82.01 121.57,82.28 121.57,83.08 121.48,83.16 121.48,83.5 121.57,83.58 121.57,83.8 121.27,84.09 121.27,88.1 121.74,88.57 121.74,88.69 121.27,89.16 121.27,89.67 121.4,89.79 121.57,89.79 121.69,89.66 121.69,89.25 121.99,88.95 122.12,88.95 122.24,89.07 122.24,89.35 122.09,89.5 122.09,89.75 122.18,89.83 122.49,89.83 122.57,89.92 122.57,90.09 122.48,90.19 122.09,90.19 122,90.28 122,90.39 122,90.46 122.09,90.55 122.26,90.55 122.33,90.62 122.33,90.81 122.24,90.9 122.09,90.9 122,90.99 122,94.08 125.4,97.49
M_B_DQ52: length 58
  TOP w0.076: v1(131.18,110.25) U26.R10
  TOP w0.102: v1(125.23,72.34) 125.58,72.69 125.58,73.86 125.65,73.92 CN11.215
  L3_IN1 w0.076: 125.82,97.48 126.19,97.86 126.19,98.45 127.78,100.04 128.38,100.04 131.33,102.99 131.33,107.46 131.74,107.87 131.74,108.62 131.56,108.8 131.56,109.87 v1(131.18,110.25)
  L3_IN1 w0.089: 125.82,97.48 123.35,95.02 123.35,94.53 123.26,94.45 122.81,94.45 122.72,94.36 122.72,94.18 122.81,94.09 123.26,94.09 123.35,94 123.35,93.82 123.26,93.73 122.39,93.73 122.3,93.65 122.3,93.47 122.39,93.38 123.26,93.38 123.35,93.29 123.35,93.11 123.26,93.02 122.38,93.02 122.29,92.94 122.29,92.76 122.38,92.67 123.26,92.67 123.35,92.58 123.35,92.4 123.26,92.31 122.4,92.31 122.31,92.22 122.31,92.05 122.4,91.96 123.26,91.96 123.35,91.87 123.35,91.69 123.26,91.6 122.41,91.6 122.33,91.52 122.33,91.33 122.41,91.25 123.26,91.25 123.35,91.16 123.35,89.76 123.16,89.57 123.04,89.57 122.93,89.68 122.8,89.68 122.68,89.56 122.68,89.43 122.79,89.32 122.79,89.2 121.57,87.98 121.57,84.22 121.86,83.92 121.86,81.73 122.78,80.81 122.78,80.19 124.78,78.19 124.78,75.08 124.86,75 124.86,72.71 v1(125.23,72.34)
M_B_DQ53: length 58.6
  TOP w0.076: v1(130.27,110.25) U26.P10
  TOP w0.102: v1(122.92,70.74) 123.47,70.2 123.47,69.52 123.39,69.45 CN11.224
  L3_IN1 w0.076: v1(130.27,110.25) 129.9,109.88 129.9,109.25 129.63,108.97 129.63,107.73 129.27,107.37 129.27,103.72 126.59,101.04 125.83,101.04 125.29,101.58 125.29,101.81 124.93,102.17 124.84,102.17
  L3_IN1 w0.089: v1(122.92,70.74) 122.92,71.42 121.19,73.15 121.19,78.07 119.9,79.37 119.9,80.4 118.66,81.63 118.66,88.11 118.34,88.43 118.34,91.42 118.43,91.51 118.62,91.51 118.71,91.6 118.71,91.77 118.62,91.86 118.43,91.86 118.34,91.95 118.34,92.13 118.43,92.22 118.6,92.22 118.69,92.31 118.69,92.49 118.6,92.57 118.43,92.57 118.34,92.66 118.34,92.84 118.43,92.93 118.65,92.93 118.74,93.02 118.74,93.2 118.65,93.29 118.43,93.29 118.34,93.37 118.34,93.55 118.43,93.64 118.65,93.64 118.74,93.73 118.74,93.91 118.65,94 118.43,94 118.34,94.09 118.34,94.49 117.13,95.7 117.13,99.41 119.89,102.17 124.84,102.17
M_B_DQ54: length 54.3
  TOP w0.076: v1(131.2,108.29) 131.2,108.29 U26.R7
  TOP w0.102: v1(125.87,70.15) 125.39,69.68 CN11.216
  L3_IN1 w0.076: v1(131.2,108.29) 131,108.08 131,103.15 128.22,100.37 127.44,100.37 127.26,100.18 124.97,100.18 124.84,100.31
  L3_IN1 w0.089: 124.84,100.31 120.52,100.31 118.97,98.76 118.97,96.35 121.71,93.62 121.71,90.52 120.98,89.79 120.98,84.57 120.53,84.11 120.53,82.23 122.19,80.57 122.19,79.8 124.19,77.8 124.19,74.84 124.28,74.75 124.28,71.75 v1(125.87,70.15)
M_B_DQ55: length 56.4
  TOP w0.076: U26.P8 130.26,108.95 v1(130.25,108.95)
  TOP w0.102: CN11.229 122.15,74.62 121.68,74.15 v1(121.68,74.12)
  L3_IN1 w0.076: 124.84,101.83 125.12,101.54 125.12,101.51 125.76,100.87 126.66,100.87 129.53,103.74 129.53,107.27 129.83,107.57 129.83,108.54 v1(130.25,108.95)
  L3_IN1 w0.089: 124.84,101.83 124.79,101.88 120.01,101.88 117.51,99.38 117.51,95.74 119.52,93.73 119.52,93.6 119.43,93.51 119.16,93.51 119.07,93.42 119.07,93.25 119.16,93.16 119.43,93.16 119.52,93.07 119.52,92.89 119.43,92.8 119.16,92.8 119.07,92.71 119.07,92.53 119.16,92.45 119.43,92.45 119.52,92.36 119.52,92.18 119.43,92.09 119.16,92.09 119.07,92 119.07,91.82 119.16,91.73 119.43,91.73 119.52,91.64 119.52,91.47 119.43,91.38 119.16,91.38 119.07,91.29 119.07,91.11 119.16,91.02 119.43,91.02 119.52,90.93 119.52,90.42 119.44,90.33 119.18,90.33 119.09,90.24 119.09,90.07 119.18,89.98 119.44,89.98 119.52,89.9 119.52,89.7 119.44,89.62 118.78,89.62 118.72,89.56 118.72,89.33 118.78,89.27 119.44,89.27 119.52,89.19 119.52,88.96 119.41,88.84 118.83,88.84 118.74,88.76 118.74,88.55 118.96,88.34 118.96,81.75 120.74,79.97 120.74,79.18 121.82,78.1 121.82,77.12 122.05,76.9 122.05,74.49 v1(121.68,74.12)
