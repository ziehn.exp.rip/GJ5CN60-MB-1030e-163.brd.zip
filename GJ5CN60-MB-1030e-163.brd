# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_CLK0_P: length 39.6
  TOP w0.127: v1(38.15,82.76) 38.15,82.59 37.92,82.36 M45.J12 ; v6(64.95,90.88) 65,90.83 65,90.38 64.9,90.28 64.75,90.28 64.65,90.38 G1.G15
  L3_IN1 w0.109: v6(64.95,90.88) 64.95,90.74 64.74,90.54 61.76,90.54 61.52,90.78 55.46,90.78 51.95,87.28 50.1,87.28 49.32,86.5 48.58,86.5 48.47,86.39 48.47,85.83 48.22,85.58 47.87,85.58 47.62,85.83 47.62,86.39 47.52,86.5 47.3,86.5 47.19,86.39 47.19,85.45 46.94,85.2 46.59,85.2 46.34,85.45 46.34,86.39 46.24,86.5 40.62,86.5 40.51,86.39 40.51,86.05 40.65,85.91 v1(41.1,85.91) 40.89,85.7 40.69,85.7 40.44,85.44 40.44,85.16 40.05,84.77 39.36,84.77 37.96,83.37 37.96,82.96 v1(38.15,82.76)
  BOTTOM w0.127: v1(41.1,85.91) 40.76,85.91 40.58,86.09 40.58,86.59 40.7,86.72 R2741.2
FBC_CLK1_N: length 38.6
  TOP w0.127: G1.J21 v6(66.35,95.08) ; v1(38.15,94.56) M46.J11
  L8_IN3 w0.109: v6(66.35,95.08) 66.35,94.84 65.74,94.23 64.65,94.23 64.31,94.58 63.25,94.58 63.17,94.5 60.09,94.5 59.12,93.52 48.94,93.52 48.83,93.41 48.83,93.09 48.58,92.85 48.23,92.85 47.98,93.09 47.98,93.41 47.87,93.52 47.44,93.52 44.79,90.87 42.52,90.87 41.69,90.04 40.5,90.04 40.3,90.25 40.3,90.56 40.19,90.67 39.94,90.67 v1(39.8,90.81) 40.08,91.08 40.08,91.22 39.93,91.36 38.74,91.36 37.74,92.36 37.74,93.82 v1(38.15,94.56)
  BOTTOM w0.122: v1(39.8,90.81) 40.18,90.81 40.34,90.65 40.34,90.25 40.03,89.94 R2745.2
FBC_CLK1_P: length 38.9
  TOP w0.127: v1(38.15,93.76) 38.15,94.05 38.04,94.16 M46.J12 ; v6(65.65,95.08) 65.7,95.03 65.7,94.53 65.62,94.45 65.44,94.45 65.35,94.54 G1.H21
  L8_IN3 w0.109: v6(65.65,95.08) 65.88,95.08 65.98,94.99 65.98,94.75 65.66,94.44 64.73,94.44 64.39,94.78 63.16,94.78 63.09,94.7 60.01,94.7 59.03,93.73 48.85,93.73 48.62,93.5 48.62,93.18 48.5,93.05 48.31,93.05 48.19,93.18 48.19,93.5 47.96,93.73 47.36,93.73 44.7,91.07 42.43,91.07 42.37,91.01 41.6,90.24 40.59,90.24 40.5,90.33 40.5,90.57 40.6,90.67 40.96,90.67 v1(41.1,90.81) 41.02,90.89 40.46,90.89 40.28,91.07 40.28,91.31 40.02,91.57 38.83,91.57 37.95,92.45 37.95,93.55 v1(38.15,93.76)
  BOTTOM w0.127: R2746.2 40.58,90.21 40.58,90.66 40.73,90.81 v1(41.1,90.81)
FBC_CMD0: length 39.5
  TOP w0.127: M45.G3 36.55,74.76 36.55,73.42 36.35,73.22 36.35,72.88 38.4,70.83 40.42,70.83 40.43,70.82 48.34,70.82 57.29,79.77 57.29,85.83 58.64,87.18 60.75,87.18 61,87.43 61.5,87.43 G1.C11
FBC_CMD1: length 39.6
  TOP w0.127: G1.B11 60.94,87.78 60.59,87.43 58.62,87.43 58.62,87.43 58.31,87.43 56.91,86.03 56.91,80.41 48,71.5 38.69,71.5 38.65,71.53 38.53,71.53 37.3,72.76 37.3,73.17 37.35,73.22 v1(37.35,74.76)
  TOP w0.136: M45.J3 v1(37.35,74.76)
  BOTTOM w0.127: v1(37.35,74.76) 37.26,74.67 v3(37.26,73.89) 37.2,73.83 37.2,72.87 36.96,72.62 R915.2
FBC_CMD2: length 36.3
  TOP w0.127: G1.A11 58.21,87.78 56.47,86.05 56.47,80.86 47.69,72.08 40.08,72.08 40.08,72.09 38.92,72.09 38.25,72.76 38.25,73.06 38.15,73.16 v1(38.15,73.96)
  TOP w0.136: M45.J2 v1(38.15,73.96)
  BOTTOM w0.127: R917.1 39.65,72.42 39.23,72.84 39.23,73.37 v3(38.94,73.66) 38.81,73.79 38.32,73.79 v1(38.15,73.96)
FBC_CMD3: length 34.8
  TOP w0.127: M45.L3 38.95,74.76 38.95,73.36 39.64,72.67 44.99,72.67 45.54,73.22 45.54,73.61 46.96,75.03 48.62,75.03 56.05,82.47 56.05,86.13 58.05,88.13 62.2,88.13 G1.D11
FBC_CMD4: length 30
  TOP w0.127: G1.A12 60.39,88.43 57.8,88.43 55.56,86.19 55.56,83.63 52.02,80.09 52.02,79.26 48.38,75.62 46.06,75.62 44.53,77.15 38.94,77.15 M45.K5
FBC_CMD5: length 32
  TOP w0.1: G1.B12 60.95,88.48 60.64,88.78 60.01,88.78
  TOP w0.127: M45.K4 38.15,76.36 38.15,76.91 38.66,77.42 44.8,77.42 46.01,76.2 48.13,76.2 51.33,79.4 51.33,80.24 55.03,83.94 55.03,86.23 57.49,88.68 59.91,88.68 60.01,88.78
FBC_CMD6: length 32.1
  TOP w0.127: G1.C12 61.7,88.48 61.35,88.83 60.98,88.83 60.78,89.03 58.42,89.03 58.41,89.03 57.17,89.03 54.43,86.29 54.43,84.16 50.75,80.48 50.75,79.64 47.89,76.79 46.05,76.79 45.15,77.69 38.33,77.69 37.75,77.11 M45.J5
FBC_CMD7: length 33.4
  TOP w0.127: M45.J4 37.35,76.36 37.35,77.41 37.9,77.96 45.65,77.96 46.24,77.37 47.65,77.37 50.16,79.89 50.16,80.72 53.92,84.48 53.92,86.43 56.77,89.28 60.75,89.28 61,89.53 61.5,89.53 G1.C14
FBC_CMD8: length 31.8
  TOP w0.127: G1.B14 61,89.88 60.65,89.53 56.32,89.53 49.58,82.79 49.58,81.1 49.58,81.1 49.58,80.13 47.41,77.96 46.24,77.96 45.93,78.26 37.75,78.26 36.95,77.46 M45.H5
FBC_CMD9: length 32.3
  TOP w0.127: M45.H4 36.55,76.36 36.55,77.56 37.53,78.54 47.17,78.54 49,80.37 49,80.85 49,83.03 55.85,89.88 G1.A14
FBC_CMD10: length 35.5
  TOP w0.127: G1.D14 62.2,90.23 55.37,90.23 48.41,83.27 48.41,80.61 46.92,79.12 45.72,79.12 45.45,78.86 37.5,78.86 36.55,79.81 36.55,81.96 M45.G12
FBC_CMD11: length 30.9
  TOP w0.127: G1.A15 54.89,90.58 47.83,83.52 47.83,80.85 46.68,79.71 45.92,79.71 45.37,79.16 37.7,79.16 36.95,79.91 M45.H10
FBC_CMD12: length 32.2
  TOP w0.127: M45.H11 37.35,81.16 37.35,80.01 37.9,79.46 45.29,79.46 45.92,80.09 46.24,80.09 47.22,81.07 47.22,83.74 54.4,90.91 57.51,90.91 57.53,90.93 59.72,90.93 59.73,90.92 60.61,90.92 60.95,90.58 G1.B15
FBC_CMD13: length 32
  TOP w0.127: G1.C15 61.65,90.58 61.3,90.93 60.95,90.93 60.71,91.17 59.79,91.17 59.73,91.23 53.89,91.23 46.64,83.98 46.64,81.32 45.08,79.76 38.55,79.76 38.25,80.06 38.25,80.41 38.15,80.51 38.15,81.16 M45.K11
FBC_CMD14: length 30.6
  TOP w0.127: M45.K10 38.55,80.36 38.85,80.06 44.78,80.06 46.16,81.44 46.16,84.33 53.41,91.58 59.73,91.58 59.91,91.4 60.76,91.4 61,91.63 61.27,91.63 61.62,91.98 G1.C17
FBC_CMD15: length 31.2
  TOP w0.127: M45.L12 38.95,81.96 38.95,80.61 39.2,80.36 44.48,80.36 45.74,81.62 45.74,84.73 53.01,92 57.09,92 57.12,92.03 59.86,92.03 60.26,91.63 60.65,91.63 61,91.98 G1.B17
FBC_CMD16: length 31.5
  TOP w0.127: G1.B24 60.93,96.88 60.59,97.22 57.06,97.22 56.02,98.26 56.02,98.26 54.1,100.17 53.52,100.17 48.4,105.29 37.94,105.29 36.45,103.81 36.45,103.26 36.55,103.16 36.55,101.76 M46.L3
FBC_CMD17: length 32.3
  TOP w0.127: G1.A24 56.67,96.88 54.03,99.52 53.35,99.52 48.16,104.71 38.25,104.71 37.35,103.81 v1(37.35,101.76)
  TOP w0.136: M46.J3 v1(37.35,101.76)
  BOTTOM w0.127: v1(37.35,101.76) 37.35,102.91 v3(37.36,102.92) 37.35,102.93 37.35,103.9 36.96,104.29 R916.2
FBC_CMD18: length 32.5
  TOP w0.127: G1.D23 62.2,96.53 56.36,96.53 54.01,98.89 53.16,98.89 47.92,104.13 38.6,104.13 38.25,103.78 38.25,103.46 38.15,103.36 v1(38.15,102.56)
  TOP w0.136: M46.J2 v1(38.15,102.56)
  BOTTOM w0.127: v1(38.15,102.56) 38.5,102.91 38.92,102.91 v3(38.94,102.92) 39.34,103.33 39.34,103.74 39.65,104.04 R919.1
FBC_CMD19: length 26.8
  TOP w0.127: G1.A23 56.13,96.18 54.06,98.25 52.97,98.25 47.76,103.46 45.16,103.46 44.87,103.75 39.54,103.75 38.95,103.16 38.95,101.76 M46.G3
FBC_CMD20: length 25.6
  TOP w0.127: M46.H5 38.93,99.38 44.51,99.38 46.05,100.92 49.48,100.92 52.78,97.62 54.04,97.62 55.79,95.87 60.09,95.87 60.11,95.85 60.62,95.85 60.96,96.18 G1.B23
FBC_CMD21: length 27.7
  TOP w0.127: M46.H4 38.15,100.16 38.15,99.61 38.65,99.11 44.75,99.11 45.97,100.33 49.23,100.33 52.59,96.98 54.02,96.98 55.36,95.63 59.86,95.63 59.87,95.62 60.78,95.62 61,95.83 61.5,95.83 G1.C23
FBC_CMD22: length 27.2
  TOP w0.127: M46.J5 37.75,99.36 38.3,98.81 45.08,98.81 46.02,99.75 48.99,99.75 52.39,96.35 53.96,96.35 54.98,95.33 60.08,95.33 60.11,95.36 60.72,95.36 60.95,95.13 61.35,95.13 61.7,94.78 G1.C21
FBC_CMD23: length 27.8
  TOP w0.127: G1.B21 60.95,94.78 60.62,95.11 60.19,95.11 60.15,95.07 54.56,95.07 53.92,95.71 52.2,95.71 48.75,99.16 46.07,99.16 45.42,98.51 37.9,98.51 37.35,99.06 37.35,100.16 M46.J4
FBC_CMD24: length 26.3
  TOP w0.127: G1.A21 54.22,94.78 53.92,95.08 52.01,95.08 48.51,98.58 46.25,98.58 45.88,98.21 37.7,98.21 36.95,98.96 M46.K5
FBC_CMD25: length 29.9
  TOP w0.127: M46.K4 36.55,100.16 36.55,98.81 37.45,97.91 48.35,97.91 51.58,94.68 53.69,94.68 54.02,94.35 59.12,94.35 59.21,94.43 62.2,94.43 G1.D20
FBC_CMD26: length 28.5
  TOP w0.127: M46.L12 36.55,94.56 36.55,96.66 37.5,97.61 46.54,97.61 46.91,97.23 48.2,97.23 51.25,94.19 53.54,94.19 53.74,93.99 59.26,93.99 59.35,94.08 G1.A20
FBC_CMD27: length 27
  TOP w0.127: M46.K10 36.95,96.56 37.7,97.31 46.07,97.31 46.78,96.6 48.01,96.6 51,93.6 59.3,93.6 59.46,93.77 60.3,93.77 60.31,93.76 60.58,93.76 60.59,93.77 60.68,93.77 61,94.08 G1.B20
FBC_CMD28: length 28.5
  TOP w0.127: M46.K11 37.35,95.36 37.35,96.51 37.85,97.01 45.75,97.01 46.92,95.84 47.95,95.84 50.76,93.02 51.36,93.02 51.59,93.25 59.49,93.25 59.77,93.52 60.78,93.52 61,93.73 61.5,93.73 G1.C20
FBC_CMD29: length 27.8
  TOP w0.127: M46.H11 38.15,95.36 38.15,95.96 38.25,96.06 38.25,96.46 38.5,96.71 45.44,96.71 49.81,92.34 51.31,92.34 51.98,93 55.31,93 55.31,93 59.78,93 60.05,93.27 60.71,93.27 60.95,93.03 61.35,93.03 61.7,92.68 G1.C18
FBC_CMD30: length 26
  TOP w0.127: G1.B18 60.95,92.68 60.6,93.03 60.27,93.03 59.93,92.69 52.3,92.69 51.26,91.65 49.48,91.65 46.05,95.08 46.05,95.45 45.07,96.43 38.88,96.43 38.55,96.1 M46.H10
FBC_CMD31: length 26.7
  TOP w0.127: M46.G12 38.95,94.56 38.95,95.91 39.2,96.16 44.68,96.16 45.46,95.39 45.46,94.78 49.22,91.01 51.26,91.01 52.6,92.35 58.6,92.35 58.6,92.36 60.12,92.36 G1.A18
FBC_D0: length 23.1
  TOP w0.165: v6(62.14,84.62) 62.14,84.58 G1.C6 ; v1(45.01,75.35) 44.76,75.35 M45.V4
  L3_IN1 w0.135: v1(45.01,75.35) 45.38,75.35 46.1,74.63 49.26,74.63 51.08,76.45 56.3,81.67 58.13,83.5 59.66,83.5 59.9,83.74 61.26,83.74 v6(62.14,84.62)
FBC_D1: length 23
  TOP w0.165: M45.V2 v1(44.55,73.96) ; G1.D6 62.19,83.92 59.69,83.92 v6(58.81,83.04)
  L3_IN1 w0.135: v6(58.81,83.04) 58.24,83.04 57.49,82.3 57.49,81.98 57.12,81.61 56.74,81.23 49.47,73.96 v1(44.55,73.96)
FBC_D2: length 22.1
  TOP w0.165: v6(59.62,84.62) 59.96,84.28 G1.A6 ; M45.T4 v1(43.75,75.56)
  L3_IN1 w0.135: v1(43.75,75.56) 44.37,76.18 49.03,76.18 50.68,77.82 55.41,82.56 57.5,84.64 57.5,84.95 57.9,85.35 59.18,85.35 59.62,84.91 v6(59.62,84.62)
FBC_D3: length 23.4
  TOP w0.165: G1.B6 v6(60.85,84.58) ; M45.T2 v1(43.75,73.96)
  L3_IN1 w0.135: v1(43.75,73.96) 44.15,74.36 44.15,75.16 44.3,75.3 44.3,75.49 44.6,75.79 45.78,75.79 46.22,75.35 49.14,75.35 57.69,83.9 59.39,83.9 59.63,84.14 60.41,84.14 v6(60.85,84.58)
FBC_D4: length 28.6
  TOP w0.165: M45.N4 v1(40.55,75.56) ; v6(60.85,82.58) G1.B4
  L3_IN1 w0.135: v6(60.85,82.58) 60,81.73 59.09,81.73 57.67,80.31 52.89,75.52 52.75,75.52 49.05,71.82 41.99,71.82 40.95,72.86 40.95,75.16 v1(40.55,75.56)
FBC_D5: length 24.9
  TOP w0.165: G1.A4 59.92,82.88 v6(59.3,82.26) ; M45.N2 v1(41.35,73.96)
  L3_IN1 w0.135: v6(59.3,82.26) 58.92,82.26 57.32,80.65 52.61,75.94 52.33,75.94 48.94,72.55 42.06,72.55 41.75,72.86 41.75,73.56 v1(41.35,73.96)
FBC_D6: length 32.1
  TOP w0.165: M45.M4 v1(39.75,75.56) ; v6(59.3,80.93) 60.2,81.83 60.8,81.83 G1.B3
  L3_IN1 w0.135: v1(39.75,75.56) 39.25,75.06 39.25,72.36 41.41,70.2 49.14,70.2 59.3,80.36 v6(59.3,80.93)
FBC_D7: length 29.5
  TOP w0.165: G1.C4 v6(61.55,82.58) ; M45.M2 v1(40.55,73.96)
  L3_IN1 w0.135: v6(61.55,82.58) 61.05,82.08 60.75,82.08 60,81.33 59.12,81.33 58.8,81.02 58.8,80.74 58.02,79.95 51.77,73.7 49.08,71.01 41.84,71.01 40.15,72.7 40.15,73.56 v1(40.55,73.96)
FBC_D8: length 21
  TOP w0.165: v1(44.55,81.96) 44.47,81.88 M45.V11 ; G1.D9 v6(62.25,86.68)
  L8_IN3 w0.135: v6(62.25,86.68) 61.71,86.14 60.42,86.14 60.31,86.04 57.58,86.04 57.18,86.44 49.72,86.44 45.45,82.17 44.76,82.17 v1(44.55,81.96)
FBC_D9: length 19.7
  TOP w0.165: M45.V13 v1(44.55,83.56) ; G1.C9 v6(61.55,86.68)
  L8_IN3 w0.135: v6(61.55,86.68) 61.04,87.18 49.58,87.18 45.96,83.56 v1(44.55,83.56)
FBC_D10: length 22.7
  TOP w0.165: G1.E9 63.1,86.53 v6(63.1,86.81) ; M45.T11 v1(43.75,81.96)
  L8_IN3 w0.135: v1(43.75,81.96) 44.15,81.56 45.85,81.56 50.03,85.74 60.54,85.74 60.67,85.86 62.15,85.86 v6(63.1,86.81)
FBC_D11: length 20.2
  TOP w0.165: v6(59.77,86.46) 60.2,86.03 60.8,86.03 G1.B9 ; v1(43.75,83.56) M45.T13
  L6_IN2 w0.14: v1(43.75,83.56) 44.15,83.16 46.81,83.16 50.54,86.88 59.35,86.88 v6(59.77,86.46)
FBC_D12: length 24.7
  TOP w0.1: G1.B8 60.78,85.32 60.4,85.32
  TOP w0.165: M45.N11 41.15,81.76 v1(41.35,81.96)
  TOP w0.17: v6(58.76,84.32) 58.76,84.34 59.74,85.32 60.4,85.32
  L8_IN3 w0.135: v1(41.35,81.96) 41.35,81.79 41.72,81.42 41.72,80.68 43.12,79.28 46.52,79.28 50.84,83.6 58.05,83.6 v6(58.76,84.32)
FBC_D13: length 24.7
  TOP w0.165: G1.A8 58.77,85.68 58.12,85.03 v6(58.12,84.89) ; M45.N13 v1(41.35,83.56)
  L8_IN3 w0.135: v6(58.12,84.89) 57.77,84.54 50.75,84.54 46.14,79.93 43.48,79.93 42.55,80.86 42.55,81.36 42.35,81.56 41.95,81.56 41.9,81.61 41.75,81.76 41.75,83.16 41.63,83.29 v1(41.35,83.56)
FBC_D14: length 30.1
  TOP w0.165: M45.M11 v1(40.55,81.96) ; G1.F6 v6(63.65,83.98)
  L8_IN3 w0.135: v6(63.65,83.98) 63.42,83.75 59.81,83.75 59.43,83.37 59.43,82.99 58.23,81.8 52.64,81.8 48.63,77.79 42.76,77.79 40.07,80.48 40.07,81.48 v1(40.55,81.96)
FBC_D15: length 30.2
  TOP w0.165: v1(40.55,83.56) M45.M13 ; v6(63.55,84.58) G1.E6
  L8_IN3 w0.135: v6(63.55,84.58) 63.12,84.15 59.19,84.15 58.03,82.99 52.64,82.99 48.09,78.44 43.04,78.44 40.88,80.6 40.88,81.57 40.95,81.64 40.95,83.16 v1(40.55,83.56)
FBC_D16: length 47.1
  TOP w0.165: v1(30.95,81.16) M45.A11 ; G1.F18 v6(64.35,93.08)
  L8_IN3 w0.135: v1(30.95,81.16) 30.89,81.16 30.25,81.8 30.11,81.8 29.61,82.3 29.61,87.77 31.94,90.1 39.39,90.1 39.89,89.6 44.7,89.6 46.8,91.7 49.48,91.7 50.54,92.76 59.4,92.76 60.66,94.02 62.92,94.02 63.11,94.21 63.88,94.21 64.04,94.05 64.04,93.39 v6(64.35,93.08)
FBC_D17: length 40.7
  TOP w0.165: M45.A13 30.85,83.66 v1(30.85,83.65) ; G1.G18 v6(64.95,92.98)
  L8_IN3 w0.135: v1(30.85,83.65) 30.57,83.93 30.57,85.68 33.28,88.39 45.37,88.39 47.64,90.66 52.42,90.66 53.1,91.35 59.71,91.35 60.9,92.54 64.51,92.54 v6(64.95,92.98)
FBC_D18: length 43.3
  TOP w0.165: M45.B11 v1(31.75,81.16) ; v6(62.95,92.98) G1.E18
  L8_IN3 w0.135: v6(62.95,92.98) 62.25,93.68 61.5,93.68 60.89,93.07 60.56,93.07 60.02,92.54 59.58,92.09 53.03,92.09 52.11,91.17 47.19,91.17 44.98,88.96 32.45,88.96 30.24,86.75 30.24,82.96 30.56,82.64 30.56,82.49 30.72,82.33 31.15,82.33 31.35,82.13 31.35,81.56 v1(31.75,81.16)
FBC_D19: length 41.9
  TOP w0.165: G1.H18 v6(65.82,93.16) ; M45.B13 v1(31.75,82.76)
  L8_IN3 w0.135: v6(65.82,93.16) 64.76,92.09 61.38,92.09 60.06,90.77 53.51,90.77 52.76,90.01 47.91,90.01 45.66,87.76 34.31,87.76 32.29,85.74 31.69,85.74 31.18,85.23 31.18,84.11 31.28,84.01 31.28,83.23 v1(31.75,82.76)
FBC_D20: length 35.9
  TOP w0.165: M45.E11 34.15,81.96 v1(34.15,81.96)
  TOP w0.17: v6(62.07,91.12) 62.07,91.07 62.55,90.6 G1.D15
  L8_IN3 w0.135: v1(34.15,81.96) 33.75,82.36 33.75,84.6 33.8,84.65 33.8,85.48 33.75,85.54 33.75,85.86 35.02,87.13 45.92,87.13 48.22,89.43 52.88,89.43 53.69,90.23 60.51,90.23 61.22,90.94 61.9,90.94 v6(62.07,91.12)
FBC_D21: length 35.4
  TOP w0.165: v1(34.95,82.76) M45.E13
  TOP w0.17: v6(63.48,91.11) 63.48,90.81 G1.E15
  L8_IN3 w0.135: v6(63.48,91.11) 63.48,91.09 63.05,90.66 62.43,90.66 62.25,90.48 61.33,90.48 60.75,89.9 60.49,89.64 54.11,89.64 53.28,88.81 48.58,88.81 46.31,86.53 35.59,86.53 34.66,85.6 34.66,84.69 34.55,84.59 34.55,84.08 34.58,84.05 34.59,84.05 34.59,83.12 v1(34.95,82.76)
FBC_D22: length 36.1
  TOP w0.1: G1.G17 64.65,91.93 64.35,91.63 v6(64.35,91.58)
  TOP w0.165: M45.F11 v1(34.95,81.96)
  L8_IN3 w0.135: v1(34.95,81.96) 35.35,82.36 35.35,84.6 36.42,85.66 38.27,85.66 38.48,85.45 41.3,85.45 41.64,85.79 46.49,85.79 48.93,88.23 53.51,88.23 54.27,88.99 60.43,88.99 61.04,89.61 61.44,90 62.41,90 62.69,90.28 63.33,90.28 64,90.96 64,91.24 v6(64.35,91.58)
FBC_D23: length 34.7
  TOP w0.1: G1.H17 v6(65.65,91.68)
  TOP w0.165: M45.F13 v1(35.75,83.56)
  L8_IN3 w0.135: v6(65.65,91.68) 65.35,91.38 65.35,90.67 64.71,90.03 64.05,90.03 63.9,89.88 62.88,89.88 62.45,89.45 61.44,89.45 60.36,88.37 54.57,88.37 53.89,87.69 49.26,87.69 46.54,84.97 38.35,84.97 36.94,83.56 v1(35.75,83.56)
FBC_D24: length 43.9
  TOP w0.11: G1.J15 v6(66.35,90.88)
  TOP w0.165: v1(30.88,76.15) 31.16,76.15 M45.A4
  L3_IN1 w0.102: v6(66.35,90.88) 65.56,90.1 61.89,90.1 61.78,89.98
  L3_IN1 w0.135: v1(30.88,76.15) 30.65,76.39 30.65,77.92 31.68,78.96 33.42,78.96 34.1,79.64 37.9,79.64 38.29,80.03 45.39,80.03 50.61,85.25 52.4,85.25 56.95,89.8 60.43,89.8 60.53,89.89 60.62,89.98 61.78,89.98
FBC_D25: length 46.6
  TOP w0.11: G1.H15 v6(65.8,91.03)
  TOP w0.165: v1(30.95,74.76) M45.A2
  L3_IN1 w0.102: 61.38,90.32 61.4,90.3 65.07,90.3 v6(65.8,91.03)
  L3_IN1 w0.135: 61.38,90.32 56.75,90.32 52.25,85.82 49.94,85.82 44.71,80.59 39.17,80.59 39.08,80.68 33.52,80.68 33.18,80.34 33.18,80.01 32.66,79.49 31.47,79.49 29.66,77.69 29.66,76.05 v1(30.95,74.76)
FBC_D26: length 38.9
  TOP w0.165: M45.B4 v1(31.75,76.36) ; v6(63.5,89.46) 63.5,89.63 G1.E14
  L3_IN1 w0.102: 62.46,89.4 62.61,89.56 62.74,89.69 63.27,89.69 v6(63.5,89.46)
  L3_IN1 w0.135: v1(31.75,76.36) 32.15,76.76 32.15,77.46 32.42,77.73 33.97,77.73 34.67,78.43 38.1,78.43 38.63,78.95 46.04,78.95 50.87,83.77 52.57,83.77 57.54,88.74 60.76,88.74 61.34,89.31 61.42,89.4 62.46,89.4
FBC_D27: length 42.2
  TOP w0.165: v1(31.75,74.76) M45.B2 ; G1.F14 v6(64.25,89.58)
  L3_IN1 w0.102: 62.31,89.67 62.53,89.9 63.93,89.9 v6(64.25,89.58)
  L3_IN1 w0.135: 62.31,89.67 61.07,89.67 61.02,89.63 60.75,89.35 57.36,89.35 52.69,84.68 51.01,84.68 45.83,79.51 38.44,79.51 38.03,79.1 34.49,79.1 33.66,78.27 31.84,78.27 31.34,77.77 31.34,76.01 31.75,75.6 v1(31.75,74.76)
FBC_D28: length 39
  TOP w0.165: G1.H11 v6(65.65,87.48) ; M45.E4 v1(34.95,75.56)
  L3_IN1 w0.135: v6(65.65,87.48) 64.74,88.39 61.47,88.39 61.26,88.18 57.7,88.18 47.99,78.47 38.86,78.47 38.36,77.97 35.13,77.97 34.55,77.39 M45.E4 v1(34.95,75.56)
FBC_D29: length 39.2
  TOP w0.11: G1.G11 64.65,86.98 v6(64.6,86.93)
  TOP w0.165: M45.E2 v1(34.95,73.96)
  L3_IN1 w0.135: v1(34.95,73.96) 35.35,74.36 35.35,76.53 35.67,76.85 36.12,76.85 36.7,77.43 38.58,77.43 39.16,78.01 48.2,78.01 57.83,87.64 61.26,87.64 61.66,88.03 62.64,88.03 62.69,88.08 64.2,88.08 64.65,87.63 64.65,86.98 v6(64.6,86.93)
FBC_D30: length 33.7
  TOP w0.165: M45.F4 v1(35.75,76.36) ; G1.F11 v6(63.65,87.48)
  L3_IN1 w0.135: v1(35.75,76.36) 36.18,76.36 36.66,76.84 38.7,76.84 39.33,77.48 48.54,77.48 58.23,87.17 61.3,87.17 61.83,87.7 62.73,87.7 62.82,87.79 63.34,87.79 v6(63.65,87.48)
FBC_D31: length 34.2
  TOP w0.165: G1.E11 63.06,87.59 63,87.53 v6(63,87.38) ; M45.F2 v1(35.75,74.76)
  L3_IN1 w0.135: v1(35.75,74.76) 36.16,75.17 36.16,75.79 36.55,76.18 38.8,76.18 39.49,76.87 48.78,76.87 54.94,83.03 57.78,85.87 60.37,85.87 60.74,86.24 62.44,86.24 62.7,86.5 62.7,87.08 v6(63,87.38)
FBC_D32: length 23.4
  TOP w0.165: v1(44.55,100.96) M46.A4 ; G1.J29 v6(66.35,100.08)
  L8_IN3 w0.102: v6(66.35,100.08) 65.75,100.68 63.95,100.68 63.81,100.53 62.51,100.53
  L8_IN3 w0.135: v1(44.55,100.96) 52.24,100.96 52.35,100.85 60.31,100.85 60.78,100.38 62.35,100.38 62.51,100.53
FBC_D33: length 21.1
  TOP w0.165: v6(63.65,101.38) G1.F30 ; M46.A2 v1(44.55,102.56)
  L8_IN3 w0.102: 62.57,101.08 62.65,101 63.27,101 v6(63.65,101.38)
  L8_IN3 w0.135: v1(44.55,102.56) 44.83,102.84 52.15,102.84 53.14,101.85 60.76,101.85 61.53,101.08 62.57,101.08
FBC_D34: length 23
  TOP w0.165: v1(43.75,100.96) M46.B4 ; G1.H29 v6(65.05,100.08)
  L8_IN3 w0.102: 62.52,100.06 62.78,100.32 63.97,100.32 64.06,100.41 64.72,100.41 v6(65.05,100.08)
  L8_IN3 w0.135: 62.52,100.06 61.61,100.06 61.5,99.94 52.34,99.94 52.14,100.13 51.72,100.55 44.16,100.55 v1(43.75,100.96)
FBC_D35: length 23.2
  TOP w0.165: G1.G30 v6(64.95,101.38) ; v1(43.75,102.56) M46.B2
  L8_IN3 w0.102: 62.31,100.77 63.64,100.77 63.88,101.01 64.58,101.01 v6(64.95,101.38)
  L8_IN3 w0.135: 62.31,100.77 62.27,100.73 61.11,100.73 60.5,101.34 52.81,101.34 51.99,102.16 44.15,102.16 v1(43.75,102.56)
FBC_D36: length 26.3
  TOP w0.1: v1(55.95,102.43) 55.95,102.15 56.49,101.6 57.14,101.6 57.35,101.4 59.27,101.4 59.31,101.35 60.25,101.35 60.31,101.41 60.62,101.41 60.95,101.08 G1.B30
  TOP w0.165: M46.E4 v1(40.55,100.96)
  L8_IN3 w0.135: v1(40.55,100.96) 40.95,101.36 40.95,104.11 41.89,105.04 52.49,105.04 53.73,103.8 54.26,103.8 54.47,103.58 55.01,103.05 55.33,103.05 v1(55.95,102.43)
FBC_D37: length 22.1
  TOP w0.1: 55.11,102.03 55.3,102.03 56.18,101.15 56.88,101.15 56.95,101.08 G1.A30
  TOP w0.165: M46.E2 v1(41.35,102.56)
  TOP w0.17: 55.11,102.03 v1(54.81,102.33)
  L8_IN3 w0.135: v1(41.35,102.56) 41.75,102.96 41.75,103.71 42.32,104.27 51.86,104.27 53.8,102.33 v1(54.81,102.33)
FBC_D38: length 35
  TOP w0.165: G1.H30 v6(65.65,101.38) ; M46.F4 v1(39.75,100.96)
  L8_IN3 w0.102: 60.58,102.41 63.28,102.41 63.48,102.61 65.23,102.61 65.42,102.42 65.42,101.61 v6(65.65,101.38)
  L8_IN3 w0.135: 60.58,102.41 60.17,102.83 57.47,102.83 54.35,105.95 53.58,106.72 41.2,106.72 39.35,104.86 39.35,101.36 v1(39.75,100.96)
FBC_D39: length 27
  TOP w0.1: G1.C30 61.65,101.08 61.3,101.43 60.95,101.43 60.76,101.62 59.45,101.62 59.34,101.73 57.8,101.73 57.1,102.43 v6(57.1,102.44)
  TOP w0.165: v1(40.55,102.56) M46.F2
  L8_IN3 w0.135: v6(57.1,102.44) 57.1,102.63 56.85,102.87 56.22,102.87 53.55,105.55 40.87,105.55 40.15,104.83 40.15,102.96 v1(40.55,102.56)
FBC_D40: length 21
  TOP w0.165: M46.A11 v1(44.55,94.56) ; G1.D27 v6(62.25,99.28)
  L3_IN1 w0.135: v6(62.25,99.28) 62.13,99.17 60.78,99.17 60.34,98.73 60.34,98.17 60.11,97.94 60.1,97.94 60.09,97.93 49.74,97.93 46.67,94.86 44.86,94.86 v1(44.55,94.56)
FBC_D41: length 25.8
  TOP w0.165: v6(66.34,97.94) 66.34,97.99 G1.J26 ; M46.A13 v1(44.55,92.96)
  L3_IN1 w0.135: v6(66.34,97.94) 66.34,97.99 65.93,98.4 63.54,98.4 63.49,98.35 62.02,98.35 61.09,97.43 61.09,96.91 60.53,96.35 51.01,96.35 47.4,92.74 44.77,92.74 v1(44.55,92.96)
FBC_D42: length 23.9
  TOP w0.165: G1.F27 v6(64.25,99.28) ; M46.B11 v1(43.75,94.56)
  L3_IN1 w0.135: v6(64.25,99.28) 63.94,98.98 63.3,98.98 63.17,98.85 61.28,98.85 60.74,98.31 60.74,98.04 60.09,97.39 50.18,97.39 46.95,94.16 44.15,94.16 v1(43.75,94.56)
FBC_D43: length 24.8
  TOP w0.165: M46.B13 v1(43.75,92.96) ; v6(64.95,99.28) G1.G27
  L3_IN1 w0.135: v6(64.95,99.28) 64.34,98.67 63.38,98.67 63.31,98.6 61.76,98.6 60.02,96.86 50.57,96.86 47.07,93.36 44.15,93.36 v1(43.75,92.96)
FBC_D44: length 24.7
  TOP w0.102: G1.C27 61.7,98.98 61.35,99.33 60.95,99.33 60.67,99.61 58.92,99.61 v6(58.2,100.33)
  TOP w0.165: M46.E11 v1(41.35,94.56)
  L3_IN1 w0.135: v1(41.35,94.56) 41.75,94.96 41.75,95.98 43.39,97.62 46.9,97.62 48.88,99.61 55.09,99.61 55.16,99.55 57.41,99.55 57.61,99.74 v6(58.2,100.33)
FBC_D45: length 26.9
  TOP w0.102: G1.B27 60.95,98.98 60.6,99.33 58.18,99.33 57.6,99.91 v6(57.6,100.33)
  TOP w0.165: M46.E13 v1(40.55,92.96)
  L3_IN1 w0.135: v1(40.55,92.96) M46.E13 40.95,96.37 43.23,98.65 47.21,98.65 48.62,100.06 55.37,100.06 55.5,99.93 57.19,99.93 v6(57.6,100.33)
FBC_D46: length 25.3
  TOP w0.102: v1(56.03,100.36) 56.03,100.33 57.38,98.98 G1.A27
  TOP w0.165: M46.F11 v1(40.55,94.56)
  L3_IN1 w0.135: v1(56.03,100.36) 56.03,100.37 55.83,100.58 48.27,100.58 47.25,99.56 43.2,99.56 40.15,96.51 M46.F11 v1(40.55,94.56)
FBC_D47: length 30.9
  TOP w0.127: G1.G29 64.41,100.38 64.06,100.04 63.61,100.04 v6(63.51,99.94)
  TOP w0.165: M46.F13 v1(39.75,92.96)
  L3_IN1 w0.135: v1(39.75,92.96) 40.28,92.43 41.41,92.43 41.75,92.77 41.75,94.02 41.9,94.16 42.43,94.16 42.55,94.28 42.55,95.67 43.67,96.79 46.93,96.79 49.3,99.16 57.98,99.16 58.59,99.78 60.08,99.78 60.75,100.45 63,100.45 v6(63.51,99.94)
FBC_D48: length 46.1
  TOP w0.165: G1.H20 v6(65.65,93.78) ; M46.V11 v1(30.95,94.56)
  L3_IN1 w0.135: v1(30.95,94.56) 30.56,94.56 30.14,94.13 30.14,89.89 32.78,87.24 48.55,87.24 52.9,91.59 61,91.59 61.32,91.9 62.53,91.9 62.71,92.08 64.85,92.08 65.4,92.63 65.4,93.38 65.65,93.63 v6(65.65,93.78)
FBC_D49: length 37.1
  TOP w0.165: G1.D18 v6(62.25,92.98) ; v1(30.95,92.96) M46.V13
  L3_IN1 w0.135: v1(30.95,92.96) 31.35,92.56 31.35,90.91 31.82,90.44 33.98,88.28 48.1,88.28 52.53,92.71 61.98,92.71 v6(62.25,92.98)
FBC_D50: length 43.7
  TOP w0.165: v6(64.43,93.66) 64.43,93.86 G1.G20 ; M46.T11 v1(31.75,94.56)
  L3_IN1 w0.135: v6(64.43,93.66) 64.32,93.66 63.95,93.29 63.95,92.88 63.56,92.49 62.53,92.49 62.38,92.34 52.88,92.34 48.3,87.76 33.21,87.76 30.54,90.43 30.54,93.95 30.75,94.16 31.35,94.16 v1(31.75,94.56)
FBC_D51: length 37.9
  TOP w0.165: G1.E20 63.05,93.88 63.05,93.6 v6(63.12,93.53) ; v1(31.75,93.76) M46.T13
  L3_IN1 w0.135: v6(63.12,93.53) 62.98,93.67 61.55,93.67 61.35,93.47 52.64,93.47 48,88.84 34.55,88.84 32.15,91.23 M46.T13 v1(31.75,93.76)
FBC_D52: length 39.4
  TOP w0.165: G1.F23 v6(63.55,95.78) ; M46.N11 v1(34.15,94.56)
  L3_IN1 w0.135: v1(34.15,94.56) 33.75,94.16 33.75,90.61 35.04,89.33 47.6,89.33 52.43,94.16 63.27,94.16 63.98,94.87 63.98,95.35 v6(63.55,95.78)
FBC_D53: length 34.1
  TOP w0.165: v1(34.95,92.96) M46.N13 ; v6(62.95,95.08) G1.E21
  L3_IN1 w0.135: v1(34.95,92.96) 34.55,92.56 34.55,91.11 35.82,89.84 39.26,89.84 39.26,89.85 47.44,89.85 49.88,92.29 52.27,94.68 62.55,94.68 v6(62.95,95.08)
FBC_D54: length 34.4
  TOP w0.165: G1.D21 v6(62.25,95.08) ; M46.M11 v1(34.95,94.56)
  L3_IN1 w0.135: v1(34.95,94.56) 35.35,94.16 35.35,92.29 35.36,92.28 35.36,91.4 35.56,91.2 36.39,90.37 41.37,90.37 41.56,90.56 47.26,90.56 49.59,92.89 52,95.3 60.71,95.3 61.18,95.77 61.96,95.77 62.25,95.48 v6(62.25,95.08)
FBC_D55: length 31.2
  TOP w0.165: G1.E23 63,95.93 v6(63,95.78) ; M46.M13 v1(35.75,92.96)
  L3_IN1 w0.135: v6(63,95.78) 62.63,96.15 60.72,96.15 60.39,95.82 51.6,95.82 47.03,91.25 38.63,91.25 37.38,92.5 36.21,92.5 v1(35.75,92.96)
FBC_D56: length 39.9
  TOP w0.165: M46.V4 v1(31.75,100.96) ; G1.G24 v6(64.95,97.18)
  L8_IN3 w0.135: v1(31.75,100.96) 31.27,100.48 31.27,99.09 33.44,96.92 35.56,96.92 37.1,95.39 38.78,95.39 39.24,95.85 44.84,95.85 45.88,94.81 58.77,94.81 60.27,96.31 64.08,96.31 v6(64.95,97.18)
FBC_D57: length 40.3
  TOP w0.165: G1.H26 v6(65.65,97.98) ; M46.V2 v1(31.75,102.56)
  L8_IN3 w0.135: v6(65.65,97.98) 64.75,98.87 61.76,98.87 61.16,99.47 47.5,99.47 47.21,99.75 39.32,99.75 38.55,100.52 38.55,102.78 38.15,103.18 36.63,103.18 36.24,103.57 36.05,103.76 31.54,103.76 31.35,103.57 31.35,102.96 v1(31.75,102.56)
FBC_D58: length 37.1
  TOP w0.165: M46.T4 v1(31.75,100.16) ; G1.F24 v6(64.25,97.18)
  L8_IN3 w0.135: v1(31.75,100.16) 32.15,99.76 32.15,99.08 33.56,97.68 35.71,97.68 37.58,95.8 38.3,95.8 38.87,96.37 45.15,96.37 46.12,95.41 58.64,95.41 60,96.76 63.83,96.76 v6(64.25,97.18)
FBC_D59: length 36.3
  TOP w0.165: v6(64.35,97.98) G1.G26 ; M46.T2 v1(32.55,102.56)
  L8_IN3 w0.135: v1(32.55,102.56) 32.95,102.96 35.99,102.96 36.72,102.23 37.55,102.23 37.75,102.04 37.75,100.28 38.27,99.76 38.61,99.76 39.15,99.23 46.93,99.23 47.66,98.5 55.64,98.5 55.99,98.85 61.29,98.85 61.56,98.58 63.75,98.58 v6(64.35,97.98)
FBC_D60: length 34.5
  TOP w0.165: v6(63.65,97.98) G1.F26 ; v1(34.95,100.96) M46.N4
  L8_IN3 w0.135: v6(63.65,97.98) 63.38,98.25 61.82,98.25 60.87,97.31 59.83,97.31 58.51,95.98 46.43,95.98 45.39,97.03 37.11,97.03 35.64,98.49 35.14,98.49 34.46,99.17 34.46,100.47 v1(34.95,100.96)
FBC_D61: length 32.5
  TOP w0.102: G1.D26 62.2,98.63 60.25,98.63 60.16,98.72 59.79,98.72 v6(59.4,98.33)
  TOP w0.165: v1(34.95,101.76) M46.N2
  L8_IN3 w0.135: v1(34.95,101.76) 35.35,101.36 35.35,99.83 35.49,99.69 35.92,99.69 36.16,99.45 36.16,99.02 37.61,97.57 45.74,97.57 46.7,96.61 55.89,96.61 55.9,96.62 57.69,96.62 v6(59.4,98.33)
FBC_D62: length 28.7
  TOP w0.102: v6(58.65,98.33) 59.02,97.95 60.6,97.95 60.93,98.28 G1.B26
  TOP w0.165: M46.M4 v1(35.75,100.96)
  L8_IN3 w0.135: v1(35.75,100.96) 36.74,99.98 36.74,99.21 37.81,98.14 46.22,98.14 47.13,97.22 57.54,97.22 v6(58.65,98.33)
FBC_D63: length 30.9
  TOP w0.102: G1.C26 61.5,97.93 60.97,97.93 60.76,97.72 58.05,97.72 57.61,98.17 v6(57.45,98.33)
  TOP w0.165: v1(34.95,102.56) M46.M2
  L8_IN3 w0.135: v1(34.95,102.56) 35.35,102.16 36.04,102.16 36.95,101.24 36.95,100.41 37.28,100.09 37.28,99.68 37.89,99.07 38.51,99.07 38.95,98.63 46.63,98.63 47.38,97.88 55.89,97.88 56.04,97.73 56.85,97.73 v6(57.45,98.33)
FBC_DBI0: length 25.9
  TOP w0.165: G1.A5 v6(60.15,83.28) ; M45.P2 v1(42.15,73.96)
  L6_IN2 w0.14: v1(42.15,73.96) 42.55,73.56 42.55,72.86 43.39,72.02 45.11,72.02 54.47,81.38 59.8,81.38 60.03,81.61 60.3,81.88 60.3,83.13 v6(60.15,83.28)
FBC_DBI1: length 24.9
  TOP w0.165: M45.P13 v1(42.15,83.56) ; G1.C8 61.6,85.43 v6(61.6,85.31)
  L8_IN3 w0.135: v1(42.15,83.56) 42.55,83.16 43.14,83.16 43.35,82.95 43.35,80.93 43.65,80.63 45.71,80.63 50.24,85.16 57.6,85.16 57.9,85.46 61.07,85.46 61.21,85.31 v6(61.6,85.31)
FBC_DBI2: length 41.8
  TOP w0.165: M45.D13 v1(33.35,82.76) ; G1.J18 v6(66.35,92.98)
  L6_IN2 w0.14: v6(66.35,92.98) 65.81,92.44 50.48,92.44 46.08,88.04 34.93,88.04 32.05,85.16 32.05,84.03 32.15,83.93 32.15,83.36 32.36,83.15 32.96,83.15 v1(33.35,82.76)
FBC_DBI3: length 41.5
  TOP w0.165: G1.F12 v6(64.25,88.78) ; M45.D2 v1(34.15,74.76)
  L6_IN2 w0.14: v6(64.25,88.78) 63.86,88.39 48.97,88.39 46.95,86.37 38.5,86.37 37.82,85.69 37.82,84.82 36.22,83.22 36.22,80.4 33.67,77.85 33.67,75.96 33.75,75.88 33.75,75.16 v1(34.15,74.76)
FBC_DBI4: length 24.6
  TOP w0.1: 55.97,100.82 56.58,100.82 56.63,100.77 60.26,100.77 60.3,100.73 62.2,100.73 G1.D29
  TOP w0.165: v1(42.15,102.56) M46.D2
  TOP w0.17: 55.97,100.82 55.19,101.6 54.96,101.6 54.64,101.92 54.63,101.92 54.39,102.16 54.39,102.17 54.06,102.5 v1(54.06,103.23)
  L6_IN2 w0.14: v1(42.15,102.56) 42.55,102.96 42.55,103.81 43.35,104.61 52.83,104.61 54.06,103.38 v1(54.06,103.23)
FBC_DBI5: length 26.2
  TOP w0.165: M46.D13 v1(42.15,92.96) ; v6(62.95,99.28) G1.E27
  L3_IN1 w0.135: v1(42.15,92.96) 42.55,93.36 43.13,93.36 43.35,93.58 43.35,95.56 43.8,96.01 47.04,96.01 49.48,98.46 55.99,98.46 56.29,98.76 58.55,98.76 59.01,99.22 60.21,99.22 60.99,100 62.23,100 v6(62.95,99.28)
FBC_DBI6: length 39.3
  TOP w0.165: G1.F20 v6(63.65,93.78) ; M46.P13 v1(33.35,93.76)
  L6_IN2 w0.14: v6(63.65,93.78) 63.48,93.95 62.84,93.95 62.56,93.67 50.82,93.67 45.86,88.71 34.29,88.71 32.15,90.85 32.15,93.12 32.39,93.36 32.95,93.36 v1(33.35,93.76)
FBC_DBI7: length 39.9
  TOP w0.102: v6(62.11,97.82) 62.21,97.93 62.67,97.93 63.02,98.28 G1.E26
  TOP w0.165: M46.P2 v1(34.15,102.56)
  L6_IN2 w0.14: v1(34.15,102.56) 34.55,102.16 34.55,101.51 34.62,101.44 34.7,101.36 35.12,101.36 35.35,101.13 35.35,100.79 35.58,100.56 35.96,100.56 36.17,100.35 36.17,98.82 38.55,96.44 38.55,92.74 38.81,92.48 44.85,92.48 50.19,97.82 v6(62.11,97.82)
FBC_DEBUG0: length 5.2
  TOP w0.1: v6(58.48,86.47) 58.89,86.88 59.95,86.88 G1.A9
  BOTTOM w0.102: R913.2 58.45,86.44 v6(58.48,86.47) 58.47,86.59 v3(58.47,87.26)
FBC_DEBUG1: length 9.6
  TOP w0.1: 61.7,96.88 G1.C24
  TOP w0.102: R914.2 54.4,101.17 56.21,99.36 v3(56.21,99.14) 56.21,98.92 56.8,98.33 57.63,97.5 60.75,97.5 61.01,97.23 61.35,97.23 61.7,96.88
FBC_EDC0: length 27.5
  TOP w0.165: M45.R2 42.56,74.36 v1(42.96,74.76) ; G1.D5 v6(62.85,83.28)
  L6_IN2 w0.14: v1(42.96,74.76) 43.35,74.36 43.35,72.89 43.61,72.63 44.85,72.63 54.4,82.18 58.6,82.18 59.25,82.83 59.25,82.98 60.01,83.74 62.39,83.74 v6(62.85,83.28)
FBC_EDC1: length 35.1
  TOP w0.165: G1.D8 v6(62.85,85.38) ; M45.R13 v1(42.95,82.76)
  L6_IN2 w0.14: v1(42.95,82.76) 43.35,82.36 43.35,79.17 41.6,77.42 41.6,75.92 41.75,75.77 41.75,75.73 41.75,75.34 41.93,75.16 42.79,75.16 42.79,75.16 43.12,75.16 43.12,75.16 43.59,75.16 43.59,75.16 43.92,75.16 43.92,75.16 44.15,75.16 50.68,81.68 52.37,81.68 54.37,83.68 58.82,83.68 59.31,84.17 62.29,84.17 62.55,84.43 62.55,85.09 62.81,85.36 62.82,85.36 v6(62.85,85.38)
FBC_EDC2: length 35.6
  TOP w0.1: v6(62.95,91.68) G1.E17
  TOP w0.165: M45.C13 v1(32.55,83.56)
  L6_IN2 w0.14: v1(32.55,83.56) 33.1,84.1 33.1,85.37 35.25,87.53 46.59,87.53 49.27,90.22 54.28,90.22 55.87,91.8 62.82,91.8 v6(62.95,91.68)
FBC_EDC3: length 43
  TOP w0.165: M45.C2 v1(33.35,73.96) ; G1.E12 62.97,88.76 62.97,88.76 62.95,88.78 v6(62.95,88.78)
  L6_IN2 w0.14: v6(62.95,88.78) 62.95,88.78 62.97,88.76 62.97,88.76 62.28,89.45 49.34,89.45 46.86,86.97 37.57,86.97 35.35,84.75 35.35,84.13 35.12,83.9 34.73,83.9 34.59,83.76 34.59,83.01 34.55,82.97 34.55,80.88 34.15,80.48 34.15,79.43 32.95,78.23 M45.C2 v1(33.35,73.96)
FBC_EDC4: length 24.3
  TOP w0.165: v6(62.95,101.38) G1.E30 ; v1(42.95,101.76) M46.C2
  L6_IN2 w0.14: v6(62.95,101.38) 62.56,100.99 61.64,100.99 60.72,101.91 50.94,101.91 48.78,104.07 43.74,104.07 43.35,103.68 43.35,102.16 v1(42.95,101.76)
FBC_EDC5: length 23.5
  TOP w0.102: v6(59.4,100.38) 59.8,99.98 60.6,99.98 61,100.38 G1.B29
  TOP w0.165: M46.C13 v1(42.95,93.76)
  L6_IN2 w0.14: v6(59.4,100.38) 58.74,99.72 49.06,99.72 46.74,97.4 44.3,97.4 42.55,95.65 42.55,94.16 v1(42.95,93.76)
FBC_EDC6: length 37.9
  TOP w0.165: G1.G21 v6(64.95,95.08) ; M46.R13 v1(32.55,92.96)
  L6_IN2 w0.14: v6(64.95,95.08) 64.5,94.63 50.97,94.63 45.84,89.5 34.66,89.5 32.95,91.21 32.95,92.56 v1(32.55,92.96)
FBC_EDC7: length 40.2
  TOP w0.165: v6(62.95,97.23) 62.97,97.21 62.97,97.16 63.12,97.01 G1.E24 ; v1(33.35,101.76) M46.R2
  L6_IN2 w0.14: v1(33.35,101.76) 33.75,101.36 33.75,100.71 34.51,99.95 34.51,99.19 37.14,96.56 37.14,96.26 37.75,95.65 37.75,92.77 37.99,92.54 38.19,92.34 38.19,91.89 38.53,91.54 45.05,91.54 50.35,96.84 62.45,96.84 62.84,97.23 v6(62.95,97.23)
FBC_VREFC: length 10.7
  TOP w0.4: M45.J14 37.7,84.01 37.7,86.46 C973.2 R2717.1 R2714.2 R2719.1 37.29,88.34 v3(37.79,88.85) 37.97,89.03 C1040.2 37.97,91.79 37.75,92.01 M46.J14
FBC_WCK01_N: length 32.5
  TOP w0.127: v6(64.81,85.23) 64.65,85.4 G1.G8 ; v1(42.15,76.36) M45.P5
  L6_IN2 w0.094: v6(64.81,85.23) 64.75,85.3 64.62,85.42 64.62,85.8 64.36,86.07 61.19,86.07 60.96,85.84 57.55,85.84 57.35,85.63 57.35,85.35 57.25,85.26 57.07,85.26 56.97,85.35 56.97,85.63 56.77,85.84 56.42,85.84 56.21,85.63 56.21,85.35 56.12,85.26 55.93,85.26 55.84,85.35 55.84,85.63 55.63,85.84 55.29,85.84 55.08,85.63 55.08,85.35 54.99,85.26 54.8,85.26 54.71,85.35 54.71,85.63 54.5,85.84 54.15,85.84 53.95,85.63 53.95,85.35 53.86,85.26 53.67,85.26 53.57,85.35 53.57,85.63 53.37,85.84 53.02,85.84 52.82,85.63 52.82,85.35 52.72,85.26 52.53,85.26 52.44,85.35 52.44,85.63 52.23,85.84 51.36,85.84 42.35,76.83 42.35,76.56 v1(42.15,76.36)
FBC_WCK01_P: length 32.5
  TOP w0.127: M45.P4 41.76,75.96 v1(42.15,75.56) ; G1.F8 v6(64.24,85.38)
  L6_IN2 w0.094: v1(42.15,75.56) 42.54,76.22 42.54,76.75 51.44,85.65 52.16,85.65 52.25,85.55 52.25,85.27 52.46,85.07 52.8,85.07 53.01,85.27 53.01,85.55 53.1,85.65 53.29,85.65 53.38,85.55 53.38,85.27 53.59,85.07 53.93,85.07 54.14,85.27 54.14,85.55 54.23,85.65 54.42,85.65 54.52,85.55 54.52,85.27 54.72,85.07 55.07,85.07 55.27,85.27 55.27,85.55 55.37,85.65 55.55,85.65 55.65,85.55 55.65,85.27 55.85,85.07 56.2,85.07 56.41,85.27 56.41,85.55 56.5,85.65 56.69,85.65 56.78,85.55 56.78,85.27 56.99,85.07 57.33,85.07 57.54,85.27 57.54,85.55 57.63,85.65 61.04,85.65 61.27,85.88 64.28,85.88 64.43,85.73 64.43,85.57 v6(64.24,85.38)
FBC_WCK23_N: length 40.1
  TOP w0.127: G1.G12 v6(64.95,88.78) ; M45.D5 33.52,76.76 33.43,76.85 33.43,77.19 33.57,77.33 34,77.33 v1(34.15,77.18)
  L6_IN2 w0.094: v6(64.95,88.78) 65.17,88.55 65.17,88.24 64.98,88.04 62.53,88.04 62.32,87.83 49.72,87.83 47.02,85.12 38.9,85.12 38.67,84.89 36.75,82.97 36.75,79.97 34.36,77.58 34.36,77.39 v1(34.15,77.18)
FBC_WCK23_P: length 40
  TOP w0.127: v1(34.14,76.35) M45.D4 ; G1.H12 v6(65.65,88.78)
  L6_IN2 w0.094: v6(65.65,88.78) 65.36,88.5 65.36,88.16 65.06,87.85 62.61,87.85 62.39,87.64 49.8,87.64 47.1,84.93 38.98,84.93 38.81,84.76 36.94,82.89 36.94,79.89 35.63,78.57 34.55,77.5 34.55,76.76 v1(34.14,76.35)
FBC_WCK45_N: length 32.6
  TOP w0.127: v6(65.65,99.28) 65.7,99.23 65.7,98.75 65.61,98.65 65.41,98.65 65.3,98.76 65.3,98.94 G1.H27 ; M46.D5 41.96,99.76 42.07,99.87 42.07,100.02 41.91,100.18 41.38,100.18 v1(41.35,100.16)
  L6_IN2 w0.094: v6(65.65,99.28) 65.85,99.28 65.89,99.23 65.89,98.96 65.69,98.76 61.6,98.76 61.16,99.21 61.16,100.51 60.53,101.15 47.7,101.15 47.5,100.94 47.5,100.72 47.4,100.63 47.21,100.63 47.12,100.72 47.12,100.94 46.92,101.15 46.56,101.15 46.2,100.78 46.2,99.61 45.91,99.32 41.41,99.32 41.15,99.58 41.15,99.96 v1(41.35,100.16)
FBC_WCK45_P: length 32.6
  TOP w0.127: v1(41.35,100.96) 41.35,100.69 41.48,100.56 M46.D4 ; G1.J27 v6(66.35,99.28)
  L6_IN2 w0.094: v6(66.35,99.28) 66.09,99.02 66.09,98.88 65.77,98.57 61.52,98.57 60.97,99.13 60.97,100.43 60.45,100.96 47.78,100.96 47.69,100.86 47.69,100.64 47.48,100.43 47.14,100.43 46.93,100.64 46.93,100.86 46.84,100.96 46.64,100.96 46.39,100.7 46.39,99.53 45.99,99.13 41.33,99.13 40.96,99.5 40.96,100.32 41.35,100.71 v1(41.35,100.96)
FBC_WCK67_N: length 43.4
  TOP w0.127: M46.P5 33.43,99.76 33.35,99.68 v1(33.35,99.36) ; G1.H23 65.24,96.29 65.11,96.29 65,96.17 65,95.93 v6(65.05,95.88)
  L6_IN2 w0.094: v6(65.05,95.88) 64.88,95.88 64.24,96.52 62.87,96.52 62.35,96 50.42,96 44.62,90.2 38.09,90.2 37.38,90.91 37.38,92.33 36.42,93.29 36.42,96.61 35.98,97.05 34.71,97.05 33.15,98.61 33.15,99.16 v1(33.35,99.36)
FBC_WCK67_P: length 43.4
  TOP w0.127: G1.G23 v6(64.35,95.88) ; v1(33.35,100.16) M46.P4
  L6_IN2 w0.094: v6(64.35,95.88) 64.35,96.15 64.16,96.33 62.95,96.33 62.43,95.81 50.5,95.81 44.7,90.01 38.02,90.01 37.19,90.84 37.19,92.25 36.23,93.21 36.23,96.53 35.9,96.86 34.64,96.86 32.96,98.53 32.96,99.53 33.35,99.92 v1(33.35,100.16)
FBC_ZQ0: length 3.6
  TOP w0.125: v1(37.07,85.19) 37.31,84.95 37.31,83.6 M45.J13
  BOTTOM w0.102: R2718.1 v1(37.07,85.19)
FBC_ZQ2: length 3.7
  TOP w0.076: M46.J13 37.72,93.36 v1(37.33,92.97)
  BOTTOM w0.102: v1(37.33,92.97) 37.33,92.95 37.54,92.74 v3(37.54,91.14) 37.54,90.05 R2732.1
FBCAL_GND: length 12.2
  TOP w0.165: G1.P44 v6(69.25,110.58)
  BOTTOM w0.1: v3(68.26,120.48) 68.95,119.79 68.95,115.82 69.9,114.87 69.9,111.23 v6(69.25,110.58)
  BOTTOM w0.102: v3(68.26,120.48) 68.27,120.48 R2759.1
FBCAL_TERM: length 11.1
  TOP w0.11: G1.R45 v6(70.55,111.28)
  BOTTOM w0.1: v6(70.55,111.28) 70.14,111.68 70.14,115.1 69.62,115.62 v3(69.62,115.9) 69.16,116.36 69.16,119.97
  BOTTOM w0.102: R2760.1 69.16,119.97
FBCAL_VDDQ: length 1.6
  TOP w0.165: G1.R44 v6(70.55,110.58)
  BOTTOM w0.102: R2758.1 69.92,110.31 70.19,110.58 v6(70.55,110.58)
FBD_DEBUG0: length 6.8
  TOP w0.102: v3(77.24,78.03) 77.24,77.42 R920.2 76.17,77.73 76.17,81.89 76.46,82.18 G1.AD3
FBD_DEBUG1: length 6.7
  TOP w0.1: v3(66.5,76.91) 66.65,77.07 66.65,81 66.65,81 66.65,81.08 66.4,81.33 66.4,81.68 66.05,82.03 G1.J3
  TOP w0.102: R921.2 66.37,76.79 v3(66.5,76.91)
FBVDDQ_EN: length 21.6
  TOP w0.254: U84.3 6.93,105.49 7.42,105.97 C666.1 R869.1 7.19,107.75 D16.3 7.19,110.7 6.17,111.71 6.17,113.36 6.57,113.76 Q165.4 8.13,114.38 11,114.38 11.25,114.13 11.25,110.45 12.4,109.3 Q136.G
FBVDDQ_GND_SENSE: length 1.9
  TOP w0.203: R2755.2 4.24,109.27 3.38,108.41 R2751.2
FBVDDQ_MEM: length 460.4
  TOP w0.152: M42.L2 94.13,140.8 94.86,140.8 M42.L1
  TOP w0.17: M46.T3 v1(31.75,101.76)
  TOP w0.203: G1.M43 68.15,110.18 68.4,109.93 v6(68.4,109.83)
  TOP w0.3: G1.AR43 v6(83.95,109.88) ; M43.G1 M43.G2 ; v1(37.75,107.98) M43.J1 ; v1(48.41,142.03) 48.45,142.03 ; G1.AR42 84.25,109.38 v6(84,109.13) ; G1.K12 v6(67.05,88.78) ; G1.M10 v6(68.45,87.38) ; v1(35.78,91.55) v1(35.78,92.15)
  TOP w0.305: M46.R10 v1(33.35,95.36) M46.P11 ; M46.R10 v1(32.55,96.16) ; M46.R10 v1(33.35,96.16) ; M43.L4 v1(38.95,110.56) M43.K3 v1(38.15,110.56) ; M46.G11 39.35,94.96 v1(39.75,94.56) M46.F12 v1(40.55,93.76) ; M42.L14 84.5,140.83 84.58,140.75 85.1,140.75 85.21,140.75 M42.L13 ; v1(37.35,110.56) M43.H3 v1(36.55,110.56) 36.15,110.96 M43.G4 v1(35.75,110.56) 35.35,110.16 M43.F3 ; M42.L13 85.31,140.83 v1(85.69,141.21) 86.1,141.62 M42.M12 v1(85.7,142.03) ; M42.L13 M42.K12 ; v1(39.75,119.36) M43.L14 39.35,118.96 v1(39.75,118.56) ; M46.P11 v1(34.18,95.38) M46.N10 ; M46.P11 33.35,94.56 v1(33.35,94.56) M46.P12 ; v1(64.5,143.63) v1(65.1,143.63) 65.5,143.23 M41.D1 ; v1(50.7,141.23) M44.M12 ; M42.R10 v1(87.31,143.65) ; M42.R10 87.7,144.03 v1(88.1,144.43) ; M42.R10 87.7,144.03 v1(88.05,143.67) ; M46.K3 v1(36.55,100.96) 36.15,100.56 M46.L4 ; v1(65.1,145.23) 65.5,144.83 M41.B1 ; v1(35.78,119.31) 36.13,118.96 M43.G14 36.23,118.88 36.23,118.36 36.23,118.24 M43.G13 ; M44.L13 50.21,140.75 50.1,140.75 49.58,140.75 M44.L14 49.5,140.83 v1(49.1,141.23) ; M43.M12 v1(39.75,116.96) M43.L11 ; R914.1 51.89,102.62 v1(51.89,103.46) ; M43.E5 v1(34.95,111.36) ; M43.K12 v1(38.89,117.7) M43.L13 ; G1.K41 v6(67.05,108.48)
  TOP w0.381: v1(72.33,148.17) 72.45,148.29 C889.1 ; R921.1 65.18,74.93 v1(64.85,75.26) ; v1(55.05,147.7) 55.5,148.16 C967.1 ; v1(59.53,141.21) 59.53,141.19 M44.L1 v1(60.3,141.23) ; v1(59.53,141.21) 59.53,141.27 M44.M1 59.9,141.63 ; v1(59.53,141.21) 59.47,141.21 M44.L2 59.07,140.83 v1(58.7,141.2) 58.3,141.61 M44.M3 ; v1(42.15,94.56) 41.75,94.96 M46.D11 v1(41.35,95.36) M46.E10 ; v1(74.99,77.53) 75.48,77.04 R920.1 ; M42.C10 87.3,134.03 v1(87.31,134.03) ; R2712.1 34.87,122.25 34.49,121.87 34.49,120.98 34.95,120.52 v1(34.95,119.96) v1(34.95,119.36) M43.F14 ; C1009.1 83.2,135.41 v1(83.38,135.23) ; M42.G11 v1(86.5,137.23) M42.F12 ; M42.F12 v1(85.7,137.23) M42.G13 85.3,137.63 v1(85.7,138.03) ; M42.F12 v1(85.7,136.43) ; v1(50.7,136.43) 50.7,136.44 51.08,136.83 M44.F12 ; M41.H12 74.3,140.03 M41.G13 75.3,140.63 ; M42.F1 95.29,136.43 v1(95.33,136.43) ; M45.B1 v1(31.75,73.16) 31.74,73.15 31.74,72.65 31.74,72.64 v1(31.74,72.55) 32.35,71.94 C1033.1 ; C924.1 61.65,142.93 v1(60.95,143.63) ; M42.F3 M42.G2 94.13,137.63 v1(94.5,137.26) 94.86,137.63 M42.G1 94.9,137.62 95.26,137.26 95.28,137.26 v1(95.3,137.24) ; v1(65.08,134.83) 65.08,134.83 65.49,135.23 M41.P1 ; M45.H12 M45.G13 v1(35.75,82.76) ; M42.L1 95.3,141.23 v1(95.49,141.23) 96.03,141.23 96.07,141.19 v1(96.09,141.19) ; v1(30.15,111.36) 29.94,111.15 29.15,111.15 ; v1(57.9,138.03) M44.G4 ; v1(48.41,142.03) 47.94,142.5 C928.2 ; M44.T14 49.5,144.83 v1(49.1,145.23) v1(48.45,145.23) 47.93,145.75 47.93,147.26 C965.1 ; v1(51.5,134.83) M44.D11 51.9,135.23 v1(52.3,135.63) M44.E10 ; v1(92.1,136.43) 91.7,136.03 M42.E5 ; M44.F12 M44.G13 50.3,137.63 v1(50.7,138.03) M44.H12 ; M44.F12 v1(51.5,137.23) M44.G11 ; C927.1 47.25,135.34 v1(48.83,135.34) ; 62.68,147.28 63.56,148.16 C892.1 ; 62.68,147.28 61.8,148.16 C968.1 ; 62.68,147.28 v1(62.68,146.76) ; M45.D11 v1(33.35,81.96) M45.D12 ; 95.97,142.05 v1(95.95,142.03) ; M41.G4 M41.H3 67.1,140.01 67.48,139.63 v1(67.5,139.63) ; M42.B14 83.96,133.63 v1(83.91,133.58) v1(83.35,133.58) 83.3,133.63 C427.1 ; v1(48.45,143.63) 47.61,144.46 C966.1 ; v1(32.55,75.56) 32.15,75.16 M45.B3 ; C926.1 48.52,133.25 v1(48.9,133.63) 48.9,133.63 M44.B14 ; C984.2 63.77,145.95 v1(64.5,145.23) ; v1(42.15,91.96) M46.D14 ; v1(39.75,81.96) 39.35,81.56 M45.L11 ; M46.C10 v1(42.95,95.36) ; v1(65.9,141.23) M41.G2 ; v1(65.9,141.23) M41.F1 65.5,141.63 v1(65.1,142.03) v1(64.5,142.03) 64.41,142.12 C887.1 ; v1(65.9,141.23) M41.G1 65.5,140.83 v1(65.1,141.23) ; M42.L4 v1(92.9,141.23) M42.M3 93.3,141.6 93.67,141.23 v1(93.7,141.23) M42.L2 ; M41.D11 v1(73.9,143.63) M41.D12 ; M45.G11 v1(35.75,81.16) ; 34.15,120.56 33.81,120.91 C952.2 ; v1(53.1,142.03) M44.N10 v1(52.28,142.85) M44.P11 v1(51.5,143.63) M44.P12 ; M42.P12 v1(86.5,143.63) M42.P11 ; v1(92.1,134.03) 92.08,134.03 91.7,134.42 M42.C5 ; M46.G13 38.98,93.73 v1(38.98,93.74) 38.56,94.16 M46.H12 ; M41.F12 74.3,141.63 ; v1(67.48,138.81) 67.48,138.81 67.1,138.43 M41.K3 ; M42.H3 v1(92.87,138) 92.5,137.63 M42.G4 ; v1(54.35,147.83) 54.01,148.16 C964.1 ; M42.P11 87.31,143.65 v1(87.31,143.65) ; M42.P11 v1(87.3,142.83) M42.N10 v1(88.1,142.03) ; M46.L13 M46.K12 v1(37.35,94.56) ; M43.M12 v1(39.75,117.76) ; M46.N10 34.55,95.77 34.95,96.17 v1(34.95,96.16) ; M46.B12 v1(43.75,93.76) ; M44.B3 58.29,133.63 v1(57.93,134) ; v1(42.15,81.96) 41.75,81.56 M45.P11 41.75,81.55 v1(41.33,81.12) 40.96,80.76 M45.N10 ; M41.G11 v1(73.1,141.23) ; v1(60.3,137.23) M44.G1 v1(59.5,137.23) M44.G2 v1(58.7,137.23) ; M43.M14 v1(40.55,119.36) ; M41.M3 v1(66.7,137.23) M41.L2 ; M44.R10 53.13,143.6 v1(53.15,143.6) ; M44.L4 M44.K3 v1(57.9,139.63) ; v1(50.7,142.03) M44.M12 ; C888.1 63.25,141.31 v1(64.47,141.31) ; v1(76.3,137.23) M41.L14 ; M41.M12 v1(73.9,137.23) M41.L11 ; M41.N10 72.7,136.03 ; M45.K12 v1(38.95,82.76) M45.L13 39.35,83.16 v1(39.75,83.56) ; 29.92,109.19 v1(30.15,108.96) ; v1(39.75,73.96) M45.L1 v1(39.75,73.16) ; v1(60.95,141.23) 62.23,141.23 C925.1 ; v1(69.97,148.3) 69.83,148.16 C891.2 ; M41.B14 v1(76.3,144.43) ; v1(65.9,137.23) 65.9,137.25 65.51,137.63 M41.L1 65.5,137.63 v1(65.1,137.23) ; M45.D1 v1(33.35,73.16) ; M45.T1 v1(43.75,73.16) ; M45.J1 v1(37.75,72.98) ; v1(95.3,142.03) M42.M1 ; M41.J1 v1(64.9,139.23) ; v1(84.1,143.63) M42.P14 ; M44.K12 M44.L13
  TOP w0.4: v1(51.5,139.63) 51.28,139.85 M44.K12 ; M46.B1 v1(43.75,103.36) ; M43.M1 v1(40.55,108.16) ; v1(73.1,136.43) M41.N10 v1(73.1,135.63) M41.P11 v1(73.9,134.83) M41.P12 ; M43.T1 v1(43.75,108.16) ; v1(40.55,74.76) M45.M3 v1(39.75,74.76) M45.L2 v1(39.75,73.96) ; v1(48.45,143.63) v1(49.1,143.63) 49.31,143.42 M44.P14 ; M41.K12 v1(74.7,138.03) 74.7,138.03 M41.L13 v1(74.7,137.23) M41.M12 ; v1(29.67,93.93) 29.54,93.93 29.05,93.44 C1048.1 ; M46.M1 v1(34.95,103.36) v1(34.95,104.16) ; M41.M14 v1(76.3,136.43) ; v1(76.3,141.23) M41.G14 75.7,140.63 75.3,140.63 ; 35.74,75.55 M45.G4 36.55,75.56 ; 35.74,75.55 v1(35.76,75.55) ; 35.74,75.55 M45.F3 35.14,74.95 v1(34.95,74.76) ; M43.T14 v1(43.75,119.36) 43.81,119.42 C921.1 ; 38.98,100.93 M46.H3 v1(38.15,100.96) ; 38.98,100.93 M46.G4 ; 38.98,100.93 v1(38.98,100.93) ; 74.3,141.63 74.72,141.21 v1(74.72,141.19) ; 74.3,141.63 v1(74.7,142.03) ; 74.3,141.63 M41.F12 74.3,141.63 ; v1(40.55,91.98) 40.17,92.54 M46.F14 ; v1(76.91,144.43) 76.91,144.41 76.89,144.43 v1(76.3,144.43) ; v1(85.7,133.23) M42.B12 ; v1(33.35,107.56) v1(33.35,108.16) M43.D1 ; M44.T12 51.45,144.48 v1(51.5,144.43) ; M46.F12 v1(39.75,93.76) M46.G13 ; M43.B3 v1(32.55,110.56) ; v1(50.7,133.23) M44.B12 ; M43.C10 v1(32.55,115.36) ; v1(31.75,92.16) M46.T14 ; v1(60.95,145.23) v1(60.3,145.23) M44.T1 ; v1(30.61,99.9) 30.4,99.7 C1077.2 ; v1(39.75,118.56) M43.L13 v1(39.75,117.76) ; M43.P3 v1(41.35,110.56) ; C958.1 29.92,109.19 ; M41.B12 v1(74.7,144.43) ; C1051.1 30.02,96.61 v1(30.15,96.48) ; M41.G4 v1(67.5,141.23) M41.F3 ; R2714.1 35.25,87.46 34.23,86.43 v1(34.23,85.08) 34.23,84.44 v1(34.15,84.36) M45.D14 ; v1(74.69,133.23) 74.69,133.23 M41.T12 ; M46.T12 v1(32.55,94.56) ; v1(68.3,136.43) 68.3,136.43 M41.N5 ; 59.9,141.63 v1(60.3,142.03) v1(60.95,142.03) ; v1(57.9,138.83) M44.H3 v1(57.9,138.03) ; v1(40.55,73.16) M45.M1 ; v1(83.45,142.03) v1(84.1,142.03) 84.3,141.83 84.3,141.83 M42.M14 ; C1075.1 34.44,90.98 34.93,91.46 34.93,91.48 v1(34.95,91.51) v1(34.95,92.16) M46.M14 ; M45.R10 v1(42.95,81.16) ; M45.L13 M45.M12 v1(39.75,81.96) ; M45.P1 v1(42.15,73.16) ; M44.P3 v1(57.9,143.63) ; v1(85.7,134.83) M42.D12 v1(86.5,134.83) M42.D11 87.3,135.64 ; C919.1 34.57,107.18 v1(34.95,107.56) v1(34.95,108.16) M43.F1 ; C1041.1 31.77,104.18 v1(31.75,104.16) v1(31.75,103.36) M46.T1 ; M45.C10 v1(32.55,80.36) ; M45.T14 v1(43.75,84.36) 44.19,84.8 C1038.1 ; C920.1 35.69,107.49 v1(35.75,107.56) v1(35.75,108.16) M43.G1 ; C1046.1 35.69,104.22 v1(35.75,104.16) ; M45.F14 v1(34.95,84.36) 35.02,84.43 35.02,85.11 v1(35.11,85.19) ; 29.15,111.15 28.94,111.15 C953.1 ; v1(48.9,137.63) 49.5,137.63 M44.G14 ; M44.N5 v1(57.1,142.03) ; M43.N5 v1(40.55,111.36) ; M41.P3 v1(67.5,135.63) ; M42.L4 v1(92.9,140.43) M42.K3 v1(92.9,139.63) ; v1(87.3,135.61) 87.3,135.64 ; 87.3,135.64 M42.E10 ; M43.D3 v1(33.35,110.56) ; v1(60.3,133.23) M44.B1 ; M41.F14 75.9,141.68 v1(76.27,142.05) 76.79,142.05 76.85,141.99 76.86,141.99 v1(76.91,141.94) ; v1(35.75,95.36) M46.L11 ; M46.P1 v1(33.35,103.36) v1(33.35,104.16) 33.68,104.49 C1064.2 ; M41.B3 v1(66.7,144.43) ; v1(33.35,91.55) v1(33.35,92.16) M46.P14 ; v1(30.15,77.48) 28.95,77.48 C1039.1 ; C1070.1 41.91,91.72 v1(42.15,91.96) ; M44.E5 56.9,136.23 v1(57.1,136.43) ; M46.C5 v1(42.95,100.16) ; M42.G14 v1(83.9,137.63) ; M45.E10 v1(34.55,80.21) ; M44.D3 v1(58.7,135.63) ; M41.K3 v1(67.51,138.02) M41.L4 ; v1(43.75,74.76) M45.T3 ; M41.D14 75.9,143.23 76.24,142.89 v1(76.26,142.89) 76.81,142.89 v1(76.86,142.94) ; C1019.2 35.75,71.26 v1(35.75,72.56) v1(35.75,73.16) M45.G1 35.75,73.96 v1(35.75,73.96) M45.G2 ; v1(43.75,109.76) M43.T3 ; v1(92.9,143.63) M42.P3 ; M41.P14 v1(76.3,134.83) ; v1(35.76,116.95) M43.F12 v1(35.75,117.76) M43.G13 M43.H12 v1(37.35,116.96) ; v1(50.7,134.83) M44.D12 51.31,135.02 v1(51.5,134.83) ; M42.L11 v1(87.27,141.2) ; M44.L11 v1(52.3,141.23) ; M41.T3 v1(66.7,134.03) ; M44.D14 49.48,135.22 48.96,135.22 v1(48.83,135.34) ; v1(95.95,142.03) v1(95.3,142.03) ; v1(37.35,75.56) M45.H3 36.55,75.56 ; M46.D12 v1(42.15,94.56) ; M42.D3 v1(93.7,135.63) ; M41.C10 v1(72.3,144.43) ; M42.D1 94.92,135.23 95.3,134.85 v1(95.3,134.83) ; v1(95.95,143.63) v1(95.34,143.63) 95.3,143.63 M42.P1 ; M46.M3 v1(35.75,101.76) M46.L2 v1(35.75,102.56) M46.L1 v1(35.75,103.36) ; v1(60.95,143.63) v1(60.3,143.63) M44.P1 ; v1(42.15,81.96) M45.P12 ; v1(34.55,115.21) M43.E10 v1(34.15,116.16) M43.D11 v1(33.35,116.96) M43.D12 ; M45.G13 36.35,83.36 36.35,83.76 M45.G14 v1(35.75,84.36) 35.73,84.38 35.73,86.52 C1017.2 ; M42.T1 v1(95.3,145.23) v1(95.95,145.23) ; M43.R5 v1(42.95,111.36) ; v1(39.75,83.56) M45.L14 v1(39.75,84.36) ; M45.F1 v1(34.95,73.16) v1(34.95,72.56) 34.88,72.49 34.88,71.26 C976.1 ; M41.M1 65.06,136.4 v1(65.06,136.38) ; v1(35.75,82.76) M45.F12 v1(35.75,81.96) ; M45.B12 32.53,82.73 v1(32.55,82.73) ; v1(30.15,116.96) 29.83,116.63 28.92,116.63 C946.1 ; C1078.1 29.48,101.92 v1(30.15,101.24) ; 36.55,75.56 v1(36.59,75.56) ; M42.F14 v1(83.9,136.83) ; v1(31.75,107.56) v1(31.75,108.16) M43.B1 ; v1(34.95,93.76) M46.M12 v1(35.75,93.76) M46.L13 36.3,93.21 36.3,92.71 M46.L14 36.15,92.52 v1(35.78,92.15) ; M45.P3 v1(41.35,75.56) ; v1(30.15,74.54) 30.05,74.64 C975.1 ; M41.R10 v1(73.1,134.03) ; M45.C5 v1(32.55,77.16) ; M45.N5 v1(40.55,76.36) ; v1(40.55,84.36) M45.M14 ; v1(39.75,108.16) M43.L1 v1(39.75,108.96) M43.L2 v1(39.75,109.76) M43.M3 v1(40.55,109.76) ; v1(33.35,75.56) 33.36,75.56 33.75,75.16 M45.D3 ; M46.F3 v1(39.75,101.76) M46.G2 v1(39.75,102.56) M46.G1 v1(39.75,103.36) ; C1076.2 30.48,97.79 v1(30.56,97.87) ; v1(32.55,84.36) 32.54,84.36 32.15,83.97 M45.B14 ; M42.B3 v1(92.9,134.03) ; M43.P14 v1(42.15,119.36) 42.15,120.05 41.91,120.3 C995.2 ; M46.R5 v1(32.55,99.36) ; M46.E5 v1(40.55,100.16) ; v1(83.45,145.23) v1(84.1,145.23) M42.T14 ; v1(92.9,138.83) M42.H3 ; M42.T3 v1(93.7,145.23) ; v1(69.1,144.43) 69.09,144.44 68.7,144.04 M41.C5 ; v1(83.45,143.63) v1(84.1,143.63) ; M46.B14 v1(43.75,91.96) 43.81,91.9 C1068.2 ; v1(53.1,144.43) M44.R10 v1(52.29,143.62) ; M43.R10 v1(42.95,116.16) ; v1(68.3,134.03) M41.R5 ; v1(40.55,103.36) M46.F1 ; M45.P14 v1(42.15,84.36) 42.29,84.5 C1037.1 ; M43.T12 v1(43.75,117.76) ; M44.F3 v1(58.7,137.23) ; M43.B14 v1(32.55,119.36) v1(32.55,119.96) ; v1(76.3,133.23) M41.T14 ; M43.P12 v1(42.15,116.96) M43.P11 v1(41.35,116.16) M43.N10 ; M43.B12 v1(31.75,116.96) ; v1(65.1,141.23) 65.01,141.31 v1(64.47,141.31) ; M42.T12 v1(86.5,144.43) ; v1(37.35,100.96) M46.K3 ; M44.R5 v1(56.3,144.43) ; M43.D14 33.95,119.15 v1(34.15,119.36) v1(34.15,119.96) 34.15,120.56 ; v1(37.35,81.96) M45.H12 ; M41.E10 v1(72.15,142.43) ; M45.R5 v1(42.95,76.36) ; M44.C5 v1(57.1,134.03) ; v1(66.7,136.43) M41.M3 ; v1(83.94,135.23) M42.D14 ; v1(35.78,91.55) 35.78,91.03 35.43,90.68 C1074.2 ; v1(39.75,91.98) 39.37,92.54 M46.G14 ; M44.L13 v1(50.7,141.23) ; v1(34.95,100.16) M46.N5 ; v1(85.7,138.03) M42.H12 ; M44.C10 v1(52.3,134.03) ; v1(38.15,75.56) M45.K3 38.81,75.42 v1(38.95,75.56) M45.L4 ; M42.L14 v1(84.1,141.23) v1(83.45,141.23) 82.94,141.74 C1010.1 ; M44.M14 49.5,141.63 v1(49.1,142.03) 48.45,142.03 ; M43.C5 v1(32.55,112.16) ; v1(60.95,141.23) v1(60.3,141.23) ; M46.D1 v1(42.15,103.36) ; M41.E5 v1(69.1,142.03) ; M42.N5 v1(92.1,142.03) ; v1(65.1,133.23) M41.T1 ; M44.T3 v1(57.9,145.23) ; M41.D3 v1(67.5,143.63) ; M41.L2 v1(65.9,137.23) ; M45.E5 v1(34.95,77.16) ; M43.P1 v1(42.15,108.16) ; M46.B3 v1(42.95,100.96) ; v1(33.35,100.96) M46.P3 ; v1(34.95,112.16) M43.E5 ; M46.D3 v1(41.35,101.76) ; v1(35.75,116.16) M43.G11 ; v1(60.3,136.43) M44.F1 ; v1(95.32,133.21) M42.B1 ; M42.R5 v1(91.3,144.43) ; M44.D1 v1(60.3,134.83) ; M44.F14 v1(48.9,136.83) ; M45.T12 v1(43.75,82.76)
  TOP w0.508: C430.1 96.03,142.12 95.97,142.05 ; C988.1 86.31,148.29 v1(86.81,147.79) ; v1(96.09,141.19) 96.46,141.19 97.15,140.49 C429.1 ; v1(47.19,73.31) 47.19,73.32 46.86,73.65 C1035.1 ; R2692.1 79.32,141.18 79.02,141.48 C1006.1 77.75,141.48 77.37,141.48 v1(76.91,141.94) ; C910.1 83.37,143.7 v1(83.45,143.63) ; C1028.1 32.54,85.02 v1(32.51,84.99) ; v1(90.24,147.28) 89.88,147.64 C900.1 ; C1005.1 77.04,144.3 v1(76.91,144.43) ; v1(29.92,81.11) 29.68,81.34 C1029.1 ; v1(23.82,100.28) 14.68,100.28 13.14,98.74 R1934.2 ; v1(93.03,147.28) 93.66,147.91 C903.1 ; v1(95.95,143.63) 96.51,143.63 96.77,143.89 C433.1 ; C1034.1 v1(29.91,79.98)
  L3_IN1 w0.381: v1(48.41,142.03) v1(49.1,142.03)
  L3_IN1 w0.4: v1(84.1,145.23) v1(83.45,145.23) ; 67.5,138.01 67.5,138.02 67.5,138.03 ; v1(49.1,143.63) v1(48.45,143.63) ; v1(86.5,137.23) v1(85.7,137.23) v1(85.7,136.43) ; v1(40.55,74.76) v1(39.75,74.76) v1(39.75,73.96) ; v1(51.5,134.83) v1(50.7,134.83) ; 67.5,138.03 67.5,138.8 v1(67.48,138.81) 67.5,138.83 v1(67.5,139.63) 67.5,140.43 ; 67.5,138.03 v1(67.51,138.02) ; v1(39.75,108.16) v1(39.75,108.96) v1(39.75,109.76) ; v1(37.35,110.56) v1(38.15,110.56) ; v1(36.59,75.56) v1(37.35,75.56) v1(38.15,75.56) v1(38.95,75.56) ; v1(34.95,92.16) v1(34.95,91.51) ; v1(84.1,143.63) v1(83.45,143.63) ; v1(49.1,145.23) v1(48.45,145.23)
  L8_IN3 w0.4: v1(58.7,137.23) v1(59.5,137.23) v1(60.3,137.23) ; v1(32.55,82.73) 32.56,82.75 v1(33.35,81.96) ; v1(57.9,138.83) v1(57.9,139.63) ; v1(73.9,137.23) v1(74.7,137.23) v1(74.7,138.03) ; v1(39.75,84.36) v1(39.75,83.56) ; v1(39.75,101.76) v1(39.75,102.56) v1(39.75,103.36) ; v1(94.5,137.26) 95.28,137.26 v1(95.3,137.24) ; v1(34.15,119.36) v1(34.15,119.96) ; v1(74.7,144.43) v1(73.9,143.63) ; v1(34.95,119.96) v1(34.95,119.36) ; v1(32.55,119.96) v1(32.55,119.36) ; v1(39.75,81.96) 39.75,82.76 v1(38.95,82.76) ; v1(36.55,100.96) v1(35.75,101.76)
  BOTTOM w0.3: v1(64.5,143.63) 64.47,143.65
  BOTTOM w0.305: v6(84,109.13) 84.15,108.98 C1396.1
  BOTTOM w0.381: v1(65.1,133.23) 64.97,133.1 C893.2 ; v1(73.1,134.03) 72.99,134.14 C886.1 ; C932.2 48.64,133.38 v1(48.9,133.63) ; v1(67.5,139.63) 67.57,139.7 C972.1 ; v1(42.95,111.36) 42.8,111.51 C911.1 ; v1(32.55,119.96) 32.98,120.39 C923.1 ; v1(40.55,108.16) 40.26,107.86 C913.1 ; v1(43.75,108.16) 44.35,107.56 C912.1 ; C916.1 29.92,109.19 v1(30.15,108.96) ; v1(56.3,144.43) 56.27,144.4 C935.1 ; v1(30.15,77.48) 30.14,77.47 29.3,77.47 C1018.1 ; v1(48.83,135.34) 48.78,135.28 C931.2 ; C1011.1 40.54,111.37 v1(40.55,111.36) ; C951.1 96.08,145.1 v1(95.95,145.23) ; C999.2 52.31,134.01 v1(52.3,134.03) ; C933.1 60.65,136.78 v1(60.3,136.43) ; v1(76.3,134.83) 76.37,134.9 C985.2 ; C1013.1 32.41,112.3 v1(32.55,112.16) ; v1(60.95,145.23) 60.95,145.23 61.86,145.23 C963.2 ; v1(40.55,103.36) 40.77,103.57 40.77,104.53 C1045.1 ; v1(90.24,147.28) 89.88,147.64 C900.1 ; C1012.1 37.26,110.65 v1(37.35,110.56) ; v1(30.15,116.96) 29.84,116.65 C922.1 ; v1(83.94,135.23) v1(83.38,135.23) ; v1(30.15,74.54) 29.29,74.54 C1023.1 ; C1007.1 68.39,136.53 v1(68.3,136.43) ; v1(34.15,119.96) 34.16,119.97 C991.1 ; C1004.2 48.95,141.38 v1(49.1,141.23) ; C1016.1 56.22,142.9 v1(57.1,142.03) ; v1(76.3,133.23) 76.4,133.12 C890.2 ; v1(65.1,145.23) v1(64.5,145.23) 64.47,145.23
  BOTTOM w0.4: C1031.1 42.8,76.51 v1(42.95,76.36) ; v1(43.75,73.16) 43.71,73.12 C980.2 ; v1(76.26,142.89) 76.8,142.89 76.83,142.85 76.83,142.92 v1(76.86,142.94) ; v1(31.75,103.36) v1(31.75,104.16) ; C1032.2 37.36,75.57 v1(37.35,75.56) ; v1(35.75,107.56) v1(35.75,108.16) ; v1(33.35,103.36) v1(33.35,104.16) ; R915.1 37.87,72.86 v1(37.75,72.98) ; v1(60.95,145.23) v1(60.3,145.23) ; v1(40.55,73.16) 40.77,72.94 C1025.1 ; v1(40.55,76.36) 40.66,76.47 C1022.1 ; v1(34.15,119.36) v1(34.15,119.96) ; v1(83.45,143.63) v1(84.1,143.63) ; v1(34.95,107.56) v1(34.95,108.16) ; v1(76.3,144.43) 76.89,144.43 76.91,144.41 v1(76.91,144.43) ; v1(35.75,103.36) v1(35.75,104.16) ; v1(60.95,143.63) v1(60.3,143.63) ; v1(32.55,119.36) v1(32.55,119.96) ; v1(33.35,107.56) v1(33.35,108.16) ; v1(34.95,119.36) v1(34.95,119.96)
  vias: v1(29.79,106.38) v1(29.79,105.11) v1(55.31,147.15) v3(46.86,149.08) v3(63.83,125.45) v5(23.95,91.14) v5(24.59,87.33) v5(24.59,86.31) v5(24.59,85.3) v5(24.94,91.14) v5(25.6,87.33) v5(25.6,86.31) v5(25.6,85.3) v5(25.86,91.14) v5(26.62,87.33) v5(26.62,86.31) v5(26.62,85.3) v5(26.87,91.14) v5(26.97,92.15) v5(27.63,87.33) v5(27.63,86.31) v5(27.76,85.3) v5(27.89,92.15) v5(27.89,91.14) v5(28.27,72.34) v5(28.78,89.11) v5(28.83,88.12) v5(28.9,87.2) v5(28.9,71.2) v5(29.92,71.2) v6(67.05,107.68) v6(67.05,106.38) v6(67.05,105.58) v6(67.05,104.28) v6(67.05,103.48) v6(67.05,102.18) v6(67.05,101.38) v6(67.05,100.08) v6(67.05,99.28) v6(67.05,97.98) v6(67.05,97.18) v6(67.05,95.88) v6(67.05,95.08) v6(67.05,93.78) v6(67.05,92.98) v6(67.05,91.68) v6(67.05,90.88) v6(67.05,89.58) v6(67.11,102.82) v6(67.8,107.63) v6(67.8,105.53) v6(67.8,103.43) v6(67.8,99.23) v6(67.8,95.93) v6(67.8,92.93) v6(67.86,98.18) v6(67.9,89.53) v6(69.24,109.88) v6(69.25,87.38) v6(69.3,109.13) v6(69.3,88.13) v6(70.55,109.88) v6(70.5,109.13) v6(70.5,88.13) v6(70.55,87.38) v6(71.35,109.88) v6(71.35,87.38) v6(71.4,88.13) v6(72.65,109.88) v6(72.6,109.13) v6(72.65,87.38) v6(73.45,109.88) v6(73.45,87.38) v6(73.5,109.13) v6(73.5,88.13) v6(74.75,109.88) v6(74.7,109.13) v6(74.7,88.13) v6(74.75,87.38) v6(75.55,109.88) v6(75.55,87.38) v6(75.6,109.13) v6(75.6,88.13) v6(76.85,109.88) v6(76.8,109.13) v6(76.8,88.13) v6(76.85,87.38) v6(77.65,109.88) v6(77.65,87.38) v6(78.95,109.88) v6(78.9,109.13) v6(78.9,88.13) v6(78.95,87.38) v6(79.75,109.88) v6(79.75,87.38) v6(79.8,109.13) v6(79.8,88.13) v6(81.05,109.88) v6(81,109.13) v6(81,88.13) v6(81.05,87.38) v6(81.85,109.88) v6(81.9,109.13) v6(83.15,109.88)
