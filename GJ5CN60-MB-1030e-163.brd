# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1440_CFL_H62_5_MA_KOZ
  round 0.406 smd: A3(12.06,-20.314) A37(-12.739,-20.314) B2(12.654,-19.654) B38(-13.314,-19.761) BR1(13.314,19.748) BR38(-13.314,19.722) BT2(12.743,20.314) BT37(-12.722,20.314) C1(13.314,-19.047)
  round 0.381 smd: A4(11.343,-20.314) A34(-11.146,-20.314) A36(-11.958,-20.314) AA13(5.502,-5.766) AA14(4.851,-5.766) AA29(-7.411,-5.899) AA30(-8.061,-5.899) AB29(-7.411,-5.111) AB30(-8.061,-5.111) AC13(5.502,-4.852) AC14(4.851,-4.852) AC29(-7.411,-4.324) AC30(-8.061,-4.324) AD13(5.502,-3.937) AD14(4.851,-3.937) AD29(-7.411,-3.537) AD30(-8.061,-3.537) AE13(5.502,-3.023) AE14(4.851,-3.023) AE29(-7.411,-2.749) AE30(-8.061,-2.749) AF13(5.502,-2.108) AF14(4.851,-2.108) AF29(-7.411,-1.962) AF30(-8.061,-1.962) AG13(5.502,-1.194) AG14(4.851,-1.194) AG29(-7.411,-1.174) AG30(-8.061,-1.174) AH13(5.502,-0.28) AH14(4.851,-0.28) AH29(-7.411,-0.387) AH30(-8.061,-0.387) AJ13(5.502,0.635) AJ14(4.851,0.635) AJ29(-7.411,0.4) AJ30(-8.061,0.4) AK29(-7.411,1.188) AK30(-8.061,1.188) AL13(5.502,1.549) AL14(4.851,1.549) AL29(-7.411,1.975) AL30(-8.061,1.975) AM13(5.502,2.464) AM14(4.851,2.464) AM29(-7.411,2.763) AM30(-8.061,2.763) AN13(5.502,3.378) AN14(4.851,3.378) AN29(-7.411,3.55) AN30(-8.061,3.55) AP13(5.502,4.292) AP14(4.851,4.292) AP29(-7.411,4.337) AP30(-8.061,4.337) AR13(5.502,5.207) AR14(4.851,5.207) AR29(-7.411,5.125) AR30(-8.061,5.125) AT13(5.502,6.121) AT14(4.851,6.121) AT29(-7.411,5.912) AT30(-8.061,5.912) AU13(5.502,7.036) AU14(4.851,7.036) AU29(-7.411,6.7) AU30(-8.061,6.7) AV29(-7.411,7.487) AV30(-8.061,7.487) AW13(5.502,7.95) AW14(4.851,7.95) AW29(-7.411,8.274) AW30(-8.061,8.274) AY13(5.502,8.864) AY14(4.851,8.864) AY29(-7.411,9.062) AY30(-8.061,9.062) B3(11.933,-19.616) B37(-12.595,-19.612) BA13(5.502,9.779) BA14(4.851,9.779) BA29(-7.411,9.849) BA30(-8.061,9.849) BB13(5.502,10.693) BB14(4.851,10.693) BB29(-7.411,10.637) BB30(-8.061,10.637) BC13(5.502,11.608) BC14(4.851,11.608) BC29(-7.411,11.424) BC30(-8.061,11.424) BD13(5.502,12.522) BD14(4.851,12.522) BD29(-7.411,12.211) BD30(-8.061,12.211) BE29(-7.411,12.999) BE30(-8.061,12.999) BF13(5.502,13.436) BF14(4.851,13.436) BF29(-7.411,13.786) BF30(-8.061,13.786) BG13(5.502,14.351) BG14(4.851,14.351) BG29(-7.411,14.574) BG30(-8.061,14.574) BH13(5.502,15.265) BH14(4.851,15.227) BH29(-7.411,15.234) BH30(-8.061,15.361) BJ13(5.144,15.812) BJ14(4.463,15.762) BJ15(3.713,15.762) BJ16(2.926,15.762) BJ17(2.139,15.762) BJ18(1.351,15.762) BJ19(0.564,15.762) BJ20(-0.224,15.762) BJ21(-1.011,15.762) BJ22(-1.798,15.762) BJ23(-2.586,15.762) BJ24(-3.373,15.762) BJ25(-4.161,15.762) BJ26(-4.948,15.762) BJ27(-5.735,15.762) BJ28(-6.523,15.762) BJ29(-7.183,15.844) BJ30(-8.039,16.015) BK29(-7.518,16.421) BN1(13.314,18.3) BN38(-13.314,18.285) BP1(13.314,19.024) BP38(-13.314,18.996) BR2(12.596,19.619) BR37(-12.59,19.613) BT3(12.019,20.314) BT4(11.295,20.314) BT35(-11.184,20.314) BT36(-11.996,20.314) C2(12.616,-18.953) C38(-13.314,-18.98) D1(13.314,-18.323) D38(-13.314,-18.218) H13(5.059,-15.712) H14(4.272,-15.712) H15(3.484,-15.712) H16(2.697,-15.712) H17(1.91,-15.712) H18(1.122,-15.712) H19(0.335,-15.712) H20(-0.453,-15.712) H21(-1.24,-15.712) H22(-2.027,-15.712) H23(-2.815,-15.712) H24(-3.602,-15.712) H25(-4.39,-15.712) H26(-5.177,-15.712) H27(-5.964,-15.712) H28(-6.752,-15.712) H29(-7.539,-15.762) J14(4.272,-15.061) J15(3.484,-15.061) J16(2.697,-15.061) J17(1.91,-15.061) J18(1.122,-15.061) J19(0.335,-15.061) J20(-0.453,-15.061) J21(-1.24,-15.061) J22(-2.027,-15.061) J23(-2.815,-15.061) J24(-3.602,-15.061) J25(-4.39,-15.061) J26(-5.177,-15.061) J27(-5.964,-15.061) J28(-6.752,-15.061) J30(-7.747,-15.146) K13(5.436,-15.138) K14(4.851,-14.656) K29(-7.411,-14.56) K30(-8.061,-14.56) L13(5.502,-13.996) L14(4.851,-13.996) L29(-7.411,-13.773) L30(-8.061,-13.773) M13(5.502,-13.081) M14(4.851,-13.081) M29(-7.411,-12.985) M30(-8.061,-12.985) N13(5.502,-12.167) N14(4.851,-12.167) N29(-7.411,-12.198) N30(-8.061,-12.198) P13(5.502,-11.252) P14(4.851,-11.252) P29(-7.411,-11.411) P30(-8.061,-11.411) R13(5.502,-10.338) R14(4.851,-10.338) R29(-7.411,-10.623) R30(-8.061,-10.623) T13(5.502,-9.424) T14(4.851,-9.424) T29(-7.411,-9.836) T30(-8.061,-9.836) U29(-7.411,-9.048) U30(-8.061,-9.048) V13(5.502,-8.509) V14(4.851,-8.509) V29(-7.411,-8.261) V30(-8.061,-8.261) W13(5.502,-7.595) W14(4.851,-7.595) W29(-7.411,-7.474) W30(-8.061,-7.474) Y13(5.502,-6.68) Y14(4.851,-6.68) Y29(-7.411,-6.686) Y30(-8.061,-6.686)
  round 0.356 smd: A5(10.543,-20.314) A33(-10.345,-20.314) B4(11.283,-19.344) B36(-11.884,-19.613) BM1(13.314,17.5) BM38(-13.314,17.573) BP2(12.486,18.965) BP37(-12.374,18.943) BR3(11.927,19.664) BR36(-11.879,19.657) BT5(10.495,20.314) BT34(-10.384,20.314) C37(-12.594,-18.912) D3(12.081,-18.492) E1(13.314,-17.536) E38(-13.314,-17.418)
  round 0.33 smd: A6(9.768,-20.314) A32(-9.558,-20.314) AA11(6.802,-5.766) AA12(6.152,-5.766) AC11(6.802,-4.852) AC12(6.152,-4.852) AD11(6.802,-3.937) AD12(6.152,-3.937) AE11(6.802,-3.023) AE12(6.152,-3.023) AF11(6.802,-2.108) AF12(6.152,-2.108) AG11(6.802,-1.194) AG12(6.152,-1.194) AH11(6.802,-0.28) AH12(6.152,-0.28) AJ11(6.802,0.635) AJ12(6.152,0.635) AL11(6.802,1.549) AL12(6.152,1.549) AM11(6.802,2.464) AM12(6.152,2.464) AN11(6.802,3.378) AN12(6.152,3.378) AP11(6.802,4.292) AP12(6.152,4.292) AR11(6.802,5.207) AR12(6.152,5.207) AT11(6.802,6.121) AT12(6.152,6.121) AU11(6.802,7.036) AU12(6.152,7.036) AW11(6.802,7.95) AW12(6.152,7.95) AY11(6.802,8.864) AY12(6.152,8.864) B5(10.571,-19.664) B34(-11.129,-19.645) BA11(6.802,9.779) BA12(6.152,9.779) BB11(6.802,10.693) BB12(6.152,10.693) BC11(6.802,11.608) BC12(6.152,11.608) BD11(6.802,12.522) BD12(6.152,12.522) BF11(6.802,13.436) BF12(6.152,13.436) BG11(6.802,14.351) BG12(6.152,14.351) BH11(6.802,15.265) BH12(6.152,15.265) BJ11(6.802,16.18) BJ12(6.032,16.091) BK1(13.314,16.722) BK13(5.415,16.413) BK14(4.501,16.413) BK15(3.713,16.413) BK16(2.926,16.413) BK17(2.139,16.413) BK18(1.351,16.413) BK19(0.564,16.413) BK20(-0.224,16.413) BK21(-1.011,16.413) BK22(-1.798,16.413) BK23(-2.586,16.413) BK24(-3.373,16.413) BK25(-4.161,16.413) BK26(-4.948,16.413) BK27(-5.735,16.413) BK28(-6.523,16.413) BL38(-13.314,16.862) BN2(12.664,18.328) BN37(-12.651,18.35) BR5(11.148,19.67) BR35(-11.222,19.664) BT6(9.721,20.314) BT32(-9.609,20.314) D37(-12.289,-18.329) E2(12.664,-17.84) G1(13.314,-16.733) G38(-13.314,-16.643) K11(6.802,-14.834) K12(6.152,-14.834) L11(6.802,-13.996) L12(6.152,-13.996) M11(6.802,-13.081) M12(6.152,-13.081) N11(6.802,-12.167) N12(6.152,-12.167) P11(6.802,-11.252) P12(6.152,-11.252) R11(6.802,-10.338) R12(6.152,-10.338) T11(6.802,-9.424) T12(6.152,-9.424) V11(6.802,-8.509) V12(6.152,-8.509) W11(6.802,-7.595) W12(6.152,-7.595) Y11(6.802,-6.68) Y12(6.152,-6.68)
  round 0.305 smd: A8(8.996,-20.314) A9(8.209,-20.314) A10(7.421,-20.314) A11(6.634,-20.314) A12(5.847,-20.314) A13(5.059,-20.314) A14(4.272,-20.314) A15(3.484,-20.314) A16(2.697,-20.314) A17(1.91,-20.314) A18(1.122,-20.314) A19(0.335,-20.314) A20(-0.453,-20.314) A21(-1.24,-20.314) A22(-2.027,-20.314) A23(-2.815,-20.314) A24(-3.602,-20.314) A25(-4.39,-20.314) A26(-5.177,-20.314) A27(-5.964,-20.314) A28(-6.752,-20.314) A29(-7.539,-20.314) A30(-8.53,-20.314) AA1(13.314,-6.295) AA2(12.664,-6.295) AA3(12.014,-6.295) AA4(11.363,-6.295) AA5(10.713,-6.295) AA6(10.063,-6.346) AA7(9.403,-5.766) AA8(8.753,-5.766) AA9(8.103,-5.766) AA10(7.452,-5.766) AA31(-8.762,-5.899) AA32(-9.413,-5.899) AA33(-10.063,-5.899) AA34(-10.713,-5.899) AA35(-11.363,-5.899) AA36(-12.014,-5.899) AA37(-12.664,-5.899) AA38(-13.314,-5.899) AB1(13.314,-5.559) AB2(12.664,-5.559) AB3(12.014,-5.559) AB4(11.363,-5.559) AB5(10.713,-5.559) AB6(10.063,-5.508) AB31(-8.762,-5.111) AB32(-9.413,-5.111) AB33(-10.063,-5.111) AB34(-10.713,-5.111) AB35(-11.363,-5.111) AB36(-12.014,-5.111) AB37(-12.664,-5.111) AB38(-13.314,-5.111) AC1(13.314,-4.67) AC2(12.664,-4.67) AC3(12.014,-4.67) AC4(11.363,-4.67) AC5(10.713,-4.67) AC6(10.063,-4.67) AC7(9.403,-4.852) AC8(8.753,-4.852) AC9(8.103,-4.852) AC10(7.452,-4.852) AC31(-8.762,-4.324) AC32(-9.413,-4.324) AC33(-10.063,-4.324) AC34(-10.713,-4.324) AC35(-11.363,-4.324) AC36(-12.014,-4.324) AC37(-12.664,-4.324) AC38(-13.314,-4.324) AD1(13.314,-3.781) AD2(12.664,-3.781) AD3(12.014,-3.781) AD4(11.363,-3.781) AD5(10.713,-3.781) AD6(10.063,-3.831) AD7(9.403,-3.937) AD8(8.753,-3.937) AD9(8.103,-3.937) AD10(7.452,-3.937) AD31(-8.762,-3.537) AD32(-9.413,-3.537) AD33(-10.063,-3.537) AD34(-10.713,-3.537) AD35(-11.363,-3.537) AD36(-12.014,-3.537) AD37(-12.664,-3.537) AD38(-13.314,-3.537) AE1(13.314,-3.044) AE2(12.664,-3.044) AE3(12.014,-3.044) AE4(11.363,-3.044) AE5(10.713,-3.044) AE6(10.063,-2.993) AE7(9.403,-3.023) AE8(8.753,-3.023) AE9(8.103,-3.023) AE10(7.452,-3.023) AE31(-8.762,-2.749) AE32(-9.413,-2.749) AE33(-10.063,-2.749) AE34(-10.713,-2.749) AE35(-11.363,-2.749) AE36(-12.014,-2.749) AE37(-12.664,-2.749) AE38(-13.314,-2.749) AF1(13.314,-2.155) AF2(12.664,-2.155) AF3(12.014,-2.155) AF4(11.363,-2.155) AF5(10.713,-2.155) AF6(10.063,-2.155) AF7(9.403,-2.108) AF8(8.753,-2.108) AF9(8.103,-2.108) AF10(7.452,-2.108) AF31(-8.762,-1.962) AF32(-9.413,-1.962) AF33(-10.063,-1.962) AF34(-10.713,-1.962) AF35(-11.363,-1.962) AF36(-12.014,-1.962) AF37(-12.664,-1.962) AF38(-13.314,-1.962) AG1(13.314,-1.266) AG2(12.664,-1.266) AG3(12.014,-1.266) AG4(11.363,-1.266) AG5(10.713,-1.266) AG6(10.063,-1.317) AG7(9.403,-1.194) AG8(8.753,-1.194) AG9(8.103,-1.194) AG10(7.452,-1.194) AG31(-8.762,-1.174) AG32(-9.413,-1.174) AG33(-10.063,-1.174) AG34(-10.713,-1.174) AG35(-11.363,-1.174) AG36(-12.014,-1.174) AG37(-12.664,-1.174) AG38(-13.314,-1.174) AH1(13.314,-0.529) AH2(12.664,-0.529) AH3(12.014,-0.529) AH4(11.363,-0.529) AH5(10.713,-0.529) AH6(10.063,-0.479) AH7(9.403,-0.28) AH8(8.753,-0.28) AH9(8.103,-0.28) AH10(7.452,-0.28) AH31(-8.762,-0.387) AH32(-9.413,-0.387) AH33(-10.063,-0.387) AH34(-10.713,-0.387) AH35(-11.363,-0.387) AH36(-12.014,-0.387) AH37(-12.664,-0.387) AH38(-13.314,-0.387) AJ1(13.314,0.36) AJ2(12.664,0.36) AJ3(12.014,0.36) AJ4(11.363,0.36) AJ5(10.713,0.36) AJ6(10.063,0.36) AJ7(9.403,0.635) AJ8(8.753,0.635) AJ9(8.103,0.635) AJ10(7.452,0.635) AJ31(-8.762,0.4) AJ32(-9.413,0.4) AJ33(-10.063,0.4) AJ34(-10.713,0.4) AJ35(-11.363,0.4) AJ36(-12.014,0.4) AJ37(-12.664,0.4) AJ38(-13.314,0.4) AK1(13.314,1.249) AK2(12.664,1.249) AK3(12.014,1.249) AK4(11.363,1.249) AK5(10.713,1.249) AK6(10.063,1.198) AK31(-8.762,1.188) AK32(-9.413,1.188) AK33(-10.063,1.188) AK34(-10.713,1.188) AK35(-11.363,1.188) AK36(-12.014,1.188) AK37(-12.664,1.188) AK38(-13.314,1.188) AL1(13.314,1.985) AL2(12.664,1.985) AL3(12.014,1.985) AL4(11.363,1.985) AL5(10.713,1.985) AL6(10.063,2.036) AL7(9.403,1.549) AL8(8.753,1.549) AL9(8.103,1.549) AL10(7.452,1.549) AL31(-8.762,1.975) AL32(-9.413,1.975) AL33(-10.063,1.975) AL34(-10.713,1.975) AL35(-11.363,1.975) AL36(-12.014,1.975) AL37(-12.664,1.975) AL38(-13.314,1.975) AM1(13.314,2.874) AM2(12.664,2.874) AM3(12.014,2.874) AM4(11.363,2.874) AM5(10.713,2.874) AM6(10.063,2.874) AM7(9.403,2.464) AM8(8.753,2.464) AM9(8.103,2.464) AM10(7.452,2.464) AM31(-8.762,2.763) AM32(-9.413,2.763) AM33(-10.063,2.763) AM34(-10.713,2.763) AM35(-11.363,2.763) AM36(-12.014,2.763) AM37(-12.664,2.763) AM38(-13.314,2.763) AN1(13.314,3.763) AN2(12.664,3.763) AN3(12.014,3.763) AN4(11.363,3.763) AN5(10.713,3.763) AN6(10.063,3.712) AN7(9.403,3.378) AN8(8.753,3.378) AN9(8.103,3.378) AN10(7.452,3.378) AN31(-8.762,3.55) AN32(-9.413,3.55) AN33(-10.063,3.55) AN34(-10.713,3.55) AN35(-11.363,3.55) AN36(-12.014,3.55) AN37(-12.664,3.55) AN38(-13.314,3.55) AP1(13.314,4.5) AP2(12.664,4.5) AP3(12.014,4.5) AP4(11.363,4.5) AP5(10.713,4.5) AP6(10.063,4.551) AP7(9.403,4.292) AP8(8.753,4.292) AP9(8.103,4.292) AP10(7.452,4.292) AP31(-8.762,4.337) AP32(-9.413,4.337) AP33(-10.063,4.337) AP34(-10.713,4.337) AP35(-11.363,4.337) AP36(-12.014,4.337) AP37(-12.664,4.337) AP38(-13.314,4.337) AR1(13.314,5.389) AR2(12.664,5.389) AR3(12.014,5.389) AR4(11.363,5.389) AR5(10.713,5.389) AR6(10.063,5.389) AR7(9.403,5.207) AR8(8.753,5.207) AR9(8.103,5.207) AR10(7.452,5.207) AR31(-8.762,5.125) AR32(-9.413,5.125) AR33(-10.063,5.125) AR34(-10.713,5.125) AR35(-11.363,5.125) AR36(-12.014,5.125) AR37(-12.664,5.125) AR38(-13.314,5.125) AT1(13.314,6.278) AT2(12.664,6.278) AT3(12.014,6.278) AT4(11.363,6.278) AT5(10.713,6.278) AT6(10.063,6.227) AT7(9.403,6.121) AT8(8.753,6.121) AT9(8.103,6.121) AT10(7.452,6.121) AT31(-8.762,5.912) AT32(-9.413,5.912) AT33(-10.063,5.912) AT34(-10.713,5.912) AT35(-11.363,5.912) AT36(-12.014,5.912) AT37(-12.664,5.912) AT38(-13.314,5.912) AU1(13.314,7.014) AU2(12.664,7.014) AU3(12.014,7.014) AU4(11.363,7.014) AU5(10.713,7.014) AU6(10.063,7.065) AU7(9.403,7.036) AU8(8.753,7.036) AU9(8.103,7.036) AU10(7.452,7.036) AU31(-8.762,6.7) AU32(-9.413,6.7) AU33(-10.063,6.7) AU34(-10.713,6.7) AU35(-11.363,6.7) AU36(-12.014,6.7) AU37(-12.664,6.7) AU38(-13.314,6.7) AV31(-8.762,7.487) AV32(-9.413,7.487) AV33(-10.063,7.487) AV34(-10.713,7.487) AV35(-11.363,7.487) AV36(-12.014,7.487) AV37(-12.664,7.487) AV38(-13.314,7.487) AW1(13.314,7.903) AW2(12.664,7.903) AW3(12.014,7.903) AW4(11.363,7.903) AW5(10.713,7.903) AW6(10.063,7.903) AW7(9.403,7.95) AW8(8.753,7.95) AW9(8.103,7.95) AW10(7.452,7.95) AW31(-8.762,8.274) AW32(-9.413,8.274) AW33(-10.063,8.274) AW34(-10.713,8.274) AW35(-11.363,8.274) AW36(-12.014,8.274) AW37(-12.664,8.274) AW38(-13.314,8.274) AY1(13.314,8.792) AY2(12.664,8.792) AY3(12.014,8.792) AY4(11.363,8.792) AY5(10.713,8.792) AY6(10.063,8.742) AY7(9.403,8.864) AY8(8.753,8.864) AY9(8.103,8.864) AY10(7.452,8.864) AY31(-8.762,9.062) AY32(-9.413,9.062) AY33(-10.063,9.062) AY34(-10.713,9.062) AY35(-11.363,9.062) AY36(-12.014,9.062) AY37(-12.664,9.062) AY38(-13.314,9.062) B6(9.784,-19.664) B8(8.996,-19.664) B9(8.209,-19.664) B10(7.421,-19.664) B11(6.634,-19.664) B12(5.847,-19.664) B13(5.059,-19.664) B14(4.272,-19.664) B15(3.484,-19.664) B16(2.697,-19.664) B17(1.91,-19.664) B18(1.122,-19.664) B19(0.335,-19.664) B20(-0.453,-19.664) B21(-1.24,-19.664) B22(-2.027,-19.664) B23(-2.815,-19.664) B24(-3.602,-19.664) B25(-4.39,-19.664) B26(-5.177,-19.664) B27(-5.964,-19.664) B28(-6.752,-19.664) B29(-7.539,-19.664) B30(-8.327,-19.664) B31(-9.114,-19.664) B33(-9.901,-19.664) BA1(13.314,9.529) BA2(12.664,9.529) BA3(12.014,9.529) BA4(11.363,9.529) BA5(10.713,9.529) BA6(10.063,9.58) BA7(9.403,9.779) BA8(8.753,9.779) BA9(8.103,9.779) BA10(7.452,9.779) BA31(-8.762,9.849) BA32(-9.413,9.849) BA33(-10.063,9.849) BA34(-10.713,9.849) BA35(-11.363,9.849) BA36(-12.014,9.849) BA37(-12.664,9.849) BA38(-13.314,9.849) BB1(13.314,10.418) BB2(12.664,10.418) BB3(12.014,10.418) BB4(11.363,10.418) BB5(10.713,10.418) BB6(10.063,10.418) BB7(9.403,10.693) BB8(8.753,10.693) BB9(8.103,10.693) BB10(7.452,10.693) BB31(-8.762,10.637) BB32(-9.413,10.637) BB33(-10.063,10.637) BB34(-10.713,10.637) BB35(-11.363,10.637) BB36(-12.014,10.637) BB37(-12.664,10.637) BB38(-13.314,10.637) BC1(13.314,11.307) BC2(12.664,11.307) BC3(12.014,11.307) BC4(11.363,11.307) BC5(10.713,11.307) BC6(10.063,11.256) BC7(9.403,11.608) BC8(8.753,11.608) BC9(8.103,11.608) BC10(7.452,11.608) BC31(-8.762,11.424) BC32(-9.413,11.424) BC33(-10.063,11.424) BC34(-10.713,11.424) BC35(-11.363,11.424) BC36(-12.014,11.424) BC37(-12.664,11.424) BC38(-13.314,11.424) BD1(13.314,12.044) BD2(12.664,12.044) BD3(12.014,12.044) BD4(11.363,12.044) BD5(10.713,12.044) BD6(10.063,12.094) BD7(9.403,12.522) BD8(8.753,12.522) BD9(8.103,12.522) BD10(7.452,12.522) BD31(-8.762,12.211) BD32(-9.413,12.211) BD33(-10.063,12.211) BD34(-10.713,12.211) BD35(-11.363,12.211) BD36(-12.014,12.211) BD37(-12.664,12.211) BD38(-13.314,12.211) BE1(13.314,12.933) BE2(12.664,12.933) BE3(12.014,12.933) BE4(11.363,12.933) BE5(10.713,12.933) BE6(10.063,12.933) BE31(-8.762,12.999) BE32(-9.413,12.999) BE33(-10.063,12.999) BE34(-10.713,12.999) BE35(-11.363,12.999) BE36(-12.014,12.999) BE37(-12.664,12.999) BE38(-13.314,12.999) BF1(13.314,13.822) BF2(12.664,13.822) BF3(12.014,13.822) BF4(11.363,13.822) BF5(10.713,13.822) BF6(10.063,13.771) BF7(9.403,13.436) BF8(8.753,13.436) BF9(8.103,13.436) BF10(7.452,13.436) BF31(-8.762,13.786) BF32(-9.413,13.786) BF33(-10.063,13.786) BF34(-10.713,13.786) BF35(-11.363,13.786) BF36(-12.014,13.786) BF37(-12.664,13.786) BF38(-13.314,13.786) BG1(13.314,14.558) BG2(12.664,14.558) BG3(12.014,14.558) BG4(11.363,14.558) BG5(10.713,14.558) BG6(10.063,14.609) BG7(9.403,14.351) BG8(8.753,14.351) BG9(8.103,14.351) BG10(7.452,14.351) BG31(-8.762,14.574) BG32(-9.413,14.574) BG33(-10.063,14.574) BG34(-10.713,14.574) BG35(-11.363,14.574) BG36(-12.014,14.574) BG37(-12.664,14.574) BG38(-13.314,14.574) BH1(13.314,15.701) BH2(12.664,15.447) BH3(12.014,15.447) BH4(11.363,15.447) BH5(10.713,15.447) BH6(10.063,15.447) BH7(9.403,15.265) BH8(8.753,15.265) BH9(8.103,15.265) BH10(7.452,15.265) BH31(-8.762,15.361) BH32(-9.413,15.361) BH33(-10.063,15.361) BH34(-10.713,15.361) BH35(-11.363,15.361) BH36(-12.014,15.361) BH37(-12.664,15.361) BH38(-13.314,15.361) BJ7(9.403,16.18) BJ8(8.753,16.18) BJ9(8.103,16.18) BJ10(7.452,16.18) BJ31(-8.762,16.148) BJ32(-9.413,16.148) BJ33(-10.063,16.148) BJ34(-10.713,16.148) BJ35(-11.363,16.148) BJ36(-12.014,16.148) BJ37(-12.664,16.148) BJ38(-13.314,16.098) BK2(12.664,16.285) BK3(12.014,16.285) BK4(11.363,16.285) BK5(10.713,16.285) BK6(10.063,16.285) BL2(12.664,17.124) BL3(12.014,17.073) BL4(11.363,17.073) BL5(10.713,17.073) BL6(10.063,17.124) BL7(9.327,17.069) BL8(8.438,17.063) BL9(7.65,17.063) BL11(6.863,17.063) BL12(6.076,17.063) BL13(5.288,17.063) BL14(4.501,17.063) BL15(3.713,17.063) BL16(2.926,17.063) BL17(2.139,17.063) BL18(1.351,17.063) BL19(0.564,17.063) BL20(-0.224,17.063) BL21(-1.011,17.063) BL22(-1.798,17.063) BL23(-2.586,17.063) BL24(-3.373,17.063) BL25(-4.161,17.063) BL26(-4.948,17.063) BL27(-5.735,17.063) BL28(-6.523,17.063) BL29(-7.31,17.063) BL30(-8.112,16.936) BL31(-8.762,16.936) BL32(-9.413,16.936) BL33(-10.063,16.936) BL34(-10.713,16.936) BL35(-11.363,16.936) BL36(-12.014,16.936) BL37(-12.664,16.936) BM2(12.352,17.738) BM3(11.701,17.815) BM5(10.789,17.815) BM6(10.145,17.916) BM7(9.225,17.713) BM8(8.438,17.713) BM9(7.65,17.713) BM11(6.863,17.713) BM12(6.076,17.713) BM13(5.288,17.713) BM14(4.501,17.713) BM15(3.713,17.713) BM16(2.926,17.713) BM17(2.139,17.713) BM18(1.351,17.713) BM19(0.564,17.713) BM20(-0.224,17.713) BM21(-1.011,17.713) BM22(-1.798,17.713) BM23(-2.586,17.713) BM24(-3.373,17.713) BM25(-4.161,17.713) BM26(-4.948,17.713) BM27(-5.735,17.713) BM28(-6.523,17.713) BM29(-7.31,17.713) BM30(-8.098,17.713) BM31(-8.885,17.713) BM33(-9.672,17.713) BM34(-10.46,17.713) BM35(-11.247,17.713) BM36(-12.014,17.672) BM37(-12.664,17.672) BN3(12.014,18.387) BN4(11.209,18.315) BN5(10.566,18.479) BN7(9.225,18.363) BN8(8.438,18.363) BN9(7.65,18.363) BN11(6.863,18.363) BN12(6.076,18.363) BN13(5.288,18.363) BN14(4.501,18.363) BN15(3.713,18.363) BN16(2.926,18.363) BN17(2.139,18.363) BN18(1.351,18.363) BN19(0.564,18.363) BN20(-0.224,18.363) BN21(-1.011,18.363) BN22(-1.798,18.363) BN23(-2.586,18.363) BN24(-3.373,18.363) BN25(-4.161,18.363) BN26(-4.948,18.363) BN27(-5.735,18.363) BN28(-6.523,18.363) BN29(-7.31,18.363) BN30(-8.098,18.363) BN31(-8.885,18.363) BN33(-9.672,18.363) BN34(-10.46,18.363) BN35(-11.248,18.363) BN36(-11.999,18.324) BP3(11.831,19.02) BP5(10.94,19.037) BP6(10.02,18.974) BP7(9.225,19.014) BP8(8.438,19.014) BP9(7.65,19.014) BP11(6.863,19.014) BP12(6.076,19.014) BP13(5.288,19.014) BP14(4.501,19.014) BP15(3.713,19.014) BP16(2.926,19.014) BP17(2.139,19.014) BP18(1.351,19.014) BP19(0.564,19.014) BP20(-0.224,19.014) BP21(-1.011,19.014) BP22(-1.798,19.014) BP23(-2.586,19.014) BP24(-3.373,19.014) BP25(-4.161,19.014) BP26(-4.948,19.014) BP27(-5.735,19.014) BP28(-6.523,19.014) BP29(-7.31,19.014) BP30(-8.098,19.014) BP31(-8.885,19.014) BP33(-9.672,19.014) BP34(-10.46,19.014) BP35(-11.247,19.014) BR6(10.122,19.647) BR7(9.225,19.664) BR8(8.438,19.664) BR9(7.65,19.664) BR11(6.863,19.664) BR12(6.076,19.664) BR13(5.288,19.664) BR14(4.501,19.664) BR15(3.713,19.664) BR16(2.926,19.664) BR17(2.139,19.664) BR18(1.351,19.664) BR19(0.564,19.664) BR20(-0.224,19.664) BR21(-1.011,19.664) BR22(-1.798,19.664) BR23(-2.586,19.664) BR24(-3.373,19.664) BR25(-4.161,19.664) BR26(-4.948,19.664) BR27(-5.735,19.664) BR28(-6.523,19.664) BR29(-7.31,19.664) BR30(-8.098,19.664) BR31(-8.885,19.664) BR33(-9.672,19.664) BR34(-10.46,19.664) BT8(8.666,20.314) BT9(7.65,20.314) BT11(6.863,20.314) BT12(6.076,20.314) BT13(5.288,20.314) BT14(4.501,20.314) BT15(3.713,20.314) BT16(2.926,20.314) BT17(2.139,20.314) BT18(1.351,20.314) BT19(0.564,20.314) BT20(-0.224,20.314) BT21(-1.011,20.314) BT22(-1.798,20.314) BT23(-2.586,20.314) BT24(-3.373,20.314) BT25(-4.161,20.314) BT26(-4.948,20.314) BT27(-5.735,20.314) BT28(-6.523,20.314) BT29(-7.31,20.314) BT30(-8.098,20.314) BT31(-8.86,20.314) C5(10.571,-19.014) C6(9.784,-19.014) C8(8.996,-19.014) C9(8.209,-19.014) C10(7.421,-19.014) C11(6.634,-19.014) C12(5.847,-19.014) C13(5.059,-19.014) C14(4.272,-19.014) C15(3.484,-19.014) C16(2.697,-19.014) C17(1.91,-19.014) C18(1.122,-19.014) C19(0.335,-19.014) C20(-0.453,-19.014) C21(-1.24,-19.014) C22(-2.027,-19.014) C23(-2.815,-19.014) C24(-3.602,-19.014) C25(-4.39,-19.014) C26(-5.177,-19.014) C27(-5.964,-19.014) C28(-6.752,-19.014) C29(-7.539,-19.014) C30(-8.327,-19.014) C31(-9.114,-19.014) C33(-9.901,-19.014) C34(-10.697,-19.025) C36(-11.831,-18.926) D4(11.42,-18.66) D5(10.571,-18.363) D6(9.784,-18.363) D8(8.996,-18.363) D9(8.209,-18.363) D10(7.421,-18.363) D11(6.634,-18.363) D12(5.847,-18.363) D13(5.059,-18.363) D14(4.272,-18.363) D15(3.484,-18.363) D16(2.697,-18.363) D17(1.91,-18.363) D18(1.122,-18.363) D19(0.335,-18.363) D20(-0.453,-18.363) D21(-1.24,-18.363) D22(-2.027,-18.363) D23(-2.815,-18.363) D24(-3.602,-18.363) D25(-4.39,-18.363) D26(-5.177,-18.363) D27(-5.964,-18.363) D28(-6.752,-18.363) D29(-7.539,-18.363) D30(-8.327,-18.363) D31(-9.114,-18.363) D33(-9.901,-18.363) D34(-10.689,-18.363) D35(-11.341,-18.453) E3(12.014,-17.84) E4(11.363,-17.739) E5(10.571,-17.713) E6(9.784,-17.713) E8(8.996,-17.713) E9(8.209,-17.713) E10(7.421,-17.713) E11(6.634,-17.713) E12(5.847,-17.713) E13(5.059,-17.713) E14(4.272,-17.713) E15(3.484,-17.713) E16(2.697,-17.713) E17(1.91,-17.713) E18(1.122,-17.713) E19(0.335,-17.713) E20(-0.453,-17.713) E21(-1.24,-17.713) E22(-2.027,-17.713) E23(-2.815,-17.713) E24(-3.602,-17.713) E25(-4.39,-17.713) E26(-5.177,-17.713) E27(-5.964,-17.713) E28(-6.752,-17.713) E29(-7.539,-17.713) E30(-8.327,-17.713) E31(-9.114,-17.713) E33(-9.901,-17.713) E34(-10.689,-17.713) E35(-11.363,-17.71) E36(-12.014,-17.71) E37(-12.664,-17.71) F2(12.664,-17.155) F3(12.014,-17.155) F4(11.363,-17.053) F5(10.571,-17.041) F6(9.784,-17.041) F8(8.996,-17.063) F9(8.209,-17.063) F10(7.421,-17.063) F11(6.634,-17.063) F12(5.847,-17.063) F13(5.059,-17.063) F14(4.272,-17.063) F15(3.484,-17.063) F16(2.697,-17.063) F17(1.91,-17.063) F18(1.122,-17.063) F19(0.335,-17.063) F20(-0.453,-17.063) F21(-1.24,-17.063) F22(-2.027,-17.063) F23(-2.815,-17.063) F24(-3.602,-17.063) F25(-4.39,-17.063) F26(-5.177,-17.063) F27(-5.964,-17.063) F28(-6.752,-17.063) F29(-7.539,-17.063) F30(-8.327,-17.063) F31(-9.114,-17.063) F33(-9.901,-17.063) F34(-10.713,-16.922) F35(-11.363,-16.922) F36(-12.014,-16.922) F37(-12.664,-16.922) G2(12.664,-16.367) G3(12.014,-16.367) G4(11.363,-16.367) G5(10.713,-16.367) G6(10.063,-16.367) G8(8.996,-16.413) G9(8.209,-16.413) G10(7.421,-16.413) G11(6.634,-16.413) G12(5.847,-16.413) G13(5.059,-16.413) G14(4.272,-16.413) G15(3.484,-16.413) G16(2.697,-16.413) G17(1.91,-16.413) G18(1.122,-16.413) G19(0.335,-16.413) G20(-0.453,-16.413) G21(-1.24,-16.413) G22(-2.027,-16.413) G23(-2.815,-16.413) G24(-3.602,-16.413) G25(-4.39,-16.413) G26(-5.177,-16.413) G27(-5.964,-16.413) G28(-6.752,-16.413) G29(-7.539,-16.413) G30(-8.327,-16.413) H1(13.314,-15.871) H11(6.634,-15.762) H12(5.847,-15.762) H30(-8.289,-15.762) H32(-9.413,-16.135) H33(-10.063,-16.135) H34(-10.713,-16.135) H35(-11.363,-16.135) H36(-12.014,-16.135) H37(-12.664,-16.135) J2(12.664,-15.566) J3(12.014,-15.566) J4(11.363,-15.566) J5(10.713,-15.566) J6(10.063,-15.566) J7(9.421,-15.695) J8(8.773,-15.598) J9(8.103,-15.621) J10(7.421,-15.686) J31(-8.762,-15.31) J32(-9.413,-15.348) J33(-10.063,-15.348) J34(-10.713,-15.348) J35(-11.363,-15.348) J36(-12.014,-15.348) J37(-12.664,-15.348) J38(-13.314,-15.602) K1(13.314,-14.728) K2(12.664,-14.728) K3(12.014,-14.728) K4(11.363,-14.728) K5(10.713,-14.728) K6(10.063,-14.728) K7(9.403,-14.758) K8(8.753,-14.834) K9(8.103,-14.834) K10(7.452,-14.834) K31(-8.762,-14.56) K32(-9.413,-14.56) K33(-10.063,-14.56) K34(-10.713,-14.56) K35(-11.363,-14.56) K36(-12.014,-14.56) K37(-12.664,-14.56) K38(-13.314,-14.56) L1(13.314,-13.839) L2(12.664,-13.839) L3(12.014,-13.839) L4(11.363,-13.839) L5(10.713,-13.839) L6(10.063,-13.89) L7(9.403,-13.919) L8(8.753,-13.97) L9(8.103,-13.996) L10(7.452,-13.996) L31(-8.762,-13.773) L32(-9.413,-13.773) L33(-10.063,-13.773) L34(-10.713,-13.773) L35(-11.363,-13.773) L36(-12.014,-13.773) L37(-12.664,-13.773) L38(-13.314,-13.773) M1(13.314,-13.102) M2(12.664,-13.102) M3(12.014,-13.102) M4(11.363,-13.102) M5(10.713,-13.102) M6(10.063,-13.052) M7(9.403,-13.081) M8(8.753,-13.081) M9(8.103,-13.081) M10(7.452,-13.081) M31(-8.762,-12.985) M32(-9.413,-12.985) M33(-10.063,-12.985) M34(-10.713,-12.985) M35(-11.363,-12.985) M36(-12.014,-12.985) M37(-12.664,-12.985) M38(-13.314,-12.985) N1(13.314,-12.213) N2(12.664,-12.213) N3(12.014,-12.213) N4(11.363,-12.213) N5(10.713,-12.213) N6(10.063,-12.213) N7(9.403,-12.167) N8(8.753,-12.167) N9(8.103,-12.167) N10(7.452,-12.167) N31(-8.762,-12.198) N32(-9.413,-12.198) N33(-10.063,-12.198) N34(-10.713,-12.198) N35(-11.363,-12.198) N36(-12.014,-12.198) N37(-12.664,-12.198) N38(-13.314,-12.198) P1(13.314,-11.324) P2(12.664,-11.324) P3(12.014,-11.324) P4(11.363,-11.324) P5(10.713,-11.324) P6(10.063,-11.375) P7(9.403,-11.252) P8(8.753,-11.252) P9(8.103,-11.252) P10(7.452,-11.252) P31(-8.762,-11.411) P32(-9.413,-11.411) P33(-10.063,-11.411) P34(-10.713,-11.411) P35(-11.363,-11.411) P36(-12.014,-11.411) P37(-12.664,-11.411) P38(-13.314,-11.411) R1(13.314,-10.588) R2(12.664,-10.588) R3(12.014,-10.588) R4(11.363,-10.588) R5(10.713,-10.588) R6(10.063,-10.537) R7(9.403,-10.338) R8(8.753,-10.338) R9(8.103,-10.338) R10(7.452,-10.338) R31(-8.762,-10.623) R32(-9.413,-10.623) R33(-10.063,-10.623) R34(-10.713,-10.623) R35(-11.363,-10.623) R36(-12.014,-10.623) R37(-12.664,-10.623) R38(-13.314,-10.623) T1(13.314,-9.699) T2(12.664,-9.699) T3(12.014,-9.699) T4(11.363,-9.699) T5(10.713,-9.699) T6(10.063,-9.699) T7(9.403,-9.424) T8(8.753,-9.424) T9(8.103,-9.424) T10(7.452,-9.424) T31(-8.762,-9.836) T32(-9.413,-9.836) T33(-10.063,-9.836) T34(-10.713,-9.836) T35(-11.363,-9.836) T36(-12.014,-9.836) T37(-12.664,-9.836) T38(-13.314,-9.836) U1(13.314,-8.81) U2(12.664,-8.81) U3(12.014,-8.81) U4(11.363,-8.81) U5(10.713,-8.81) U6(10.063,-8.861) U31(-8.762,-9.048) U32(-9.413,-9.048) U33(-10.063,-9.048) U34(-10.713,-9.048) U35(-11.363,-9.048) U36(-12.014,-9.048) U37(-12.664,-9.048) U38(-13.314,-9.048) V1(13.314,-8.073) V2(12.664,-8.073) V3(12.014,-8.073) V4(11.363,-8.073) V5(10.713,-8.073) V6(10.063,-8.022) V7(9.403,-8.509) V8(8.753,-8.509) V9(8.103,-8.509) V10(7.452,-8.509) V31(-8.762,-8.261) V32(-9.413,-8.261) V33(-10.063,-8.261) V34(-10.713,-8.261) V35(-11.363,-8.261) V36(-12.014,-8.261) V37(-12.664,-8.261) V38(-13.314,-8.261) W1(13.314,-7.184) W2(12.664,-7.184) W3(12.014,-7.184) W4(11.363,-7.184) W5(10.713,-7.184) W6(10.063,-7.184) W7(9.403,-7.595) W8(8.753,-7.595) W9(8.103,-7.595) W10(7.452,-7.595) W31(-8.762,-7.474) W32(-9.413,-7.474) W33(-10.063,-7.474) W34(-10.713,-7.474) W35(-11.363,-7.474) W36(-12.014,-7.474) W37(-12.664,-7.474) W38(-13.314,-7.474) Y7(9.403,-6.68) Y8(8.753,-6.68) Y9(8.103,-6.68) Y10(7.452,-6.68) Y31(-8.762,-6.686) Y32(-9.413,-6.686) Y33(-10.063,-6.686) Y34(-10.713,-6.686) Y35(-11.363,-6.686) Y36(-12.014,-6.686) Y37(-12.664,-6.686) Y38(-13.314,-6.686)
BGA_0170_P080_140X120
  round 0.37 smd: A1(-5.2,6.4) A2(-4.4,6.4) A3(-3.6,6.4) A4(-2.8,6.4) A5(-2,6.4) A10(2,6.4) A11(2.8,6.4) A12(3.6,6.4) A13(4.4,6.4) A14(5.2,6.4) B1(-5.2,5.6) B2(-4.4,5.6) B3(-3.6,5.6) B4(-2.8,5.6) B5(-2,5.6) B10(2,5.6) B11(2.8,5.6) B12(3.6,5.6) B13(4.4,5.6) B14(5.2,5.6) C1(-5.2,4.8) C2(-4.4,4.8) C3(-3.6,4.8) C4(-2.8,4.8) C5(-2,4.8) C10(2,4.8) C11(2.8,4.8) C12(3.6,4.8) C13(4.4,4.8) C14(5.2,4.8) D1(-5.2,4) D2(-4.4,4) D3(-3.6,4) D4(-2.8,4) D5(-2,4) D10(2,4) D11(2.8,4) D12(3.6,4) D13(4.4,4) D14(5.2,4) E1(-5.2,3.2) E2(-4.4,3.2) E3(-3.6,3.2) E4(-2.8,3.2) E5(-2,3.2) E10(2,3.2) E11(2.8,3.2) E12(3.6,3.2) E13(4.4,3.2) E14(5.2,3.2) F1(-5.2,2.4) F2(-4.4,2.4) F3(-3.6,2.4) F4(-2.8,2.4) F5(-2,2.4) F10(2,2.4) F11(2.8,2.4) F12(3.6,2.4) F13(4.4,2.4) F14(5.2,2.4) G1(-5.2,1.6) G2(-4.4,1.6) G3(-3.6,1.6) G4(-2.8,1.6) G5(-2,1.6) G10(2,1.6) G11(2.8,1.6) G12(3.6,1.6) G13(4.4,1.6) G14(5.2,1.6) H1(-5.2,0.8) H2(-4.4,0.8) H3(-3.6,0.8) H4(-2.8,0.8) H5(-2,0.8) H10(2,0.8) H11(2.8,0.8) H12(3.6,0.8) H13(4.4,0.8) H14(5.2,0.8) J1(-5.2,0) J2(-4.4,0) J3(-3.6,0) J4(-2.8,0) J5(-2,0) J10(2,0) J11(2.8,0) J12(3.6,0) J13(4.4,0) J14(5.2,0) K1(-5.2,-0.8) K2(-4.4,-0.8) K3(-3.6,-0.8) K4(-2.8,-0.8) K5(-2,-0.8) K10(2,-0.8) K11(2.8,-0.8) K12(3.6,-0.8) K13(4.4,-0.8) K14(5.2,-0.8) L1(-5.2,-1.6) L2(-4.4,-1.6) L3(-3.6,-1.6) L4(-2.8,-1.6) L5(-2,-1.6) L10(2,-1.6) L11(2.8,-1.6) L12(3.6,-1.6) L13(4.4,-1.6) L14(5.2,-1.6) M1(-5.2,-2.4) M2(-4.4,-2.4) M3(-3.6,-2.4) M4(-2.8,-2.4) M5(-2,-2.4) M10(2,-2.4) M11(2.8,-2.4) M12(3.6,-2.4) M13(4.4,-2.4) M14(5.2,-2.4) N1(-5.2,-3.2) N2(-4.4,-3.2) N3(-3.6,-3.2) N4(-2.8,-3.2) N5(-2,-3.2) N10(2,-3.2) N11(2.8,-3.2) N12(3.6,-3.2) N13(4.4,-3.2) N14(5.2,-3.2) P1(-5.2,-4) P2(-4.4,-4) P3(-3.6,-4) P4(-2.8,-4) P5(-2,-4) P10(2,-4) P11(2.8,-4) P12(3.6,-4) P13(4.4,-4) P14(5.2,-4) R1(-5.2,-4.8) R2(-4.4,-4.8) R3(-3.6,-4.8) R4(-2.8,-4.8) R5(-2,-4.8) R10(2,-4.8) R11(2.8,-4.8) R12(3.6,-4.8) R13(4.4,-4.8) R14(5.2,-4.8) T1(-5.2,-5.6) T2(-4.4,-5.6) T3(-3.6,-5.6) T4(-2.8,-5.6) T5(-2,-5.6) T10(2,-5.6) T11(2.8,-5.6) T12(3.6,-5.6) T13(4.4,-5.6) T14(5.2,-5.6) V1(-5.2,-6.4) V2(-4.4,-6.4) V3(-3.6,-6.4) V4(-2.8,-6.4) V5(-2,-6.4) V10(2,-6.4) V11(2.8,-6.4) V12(3.6,-6.4) V13(4.4,-6.4) V14(5.2,-6.4)
BGA_2152_P070_375X375
  round 0.3 smd: A2(-17.15,17.85) A3(-16.45,17.85) A4(-15.75,17.85) A5(-15.05,17.85) A6(-14.35,17.85) A8(-12.95,17.85) A9(-12.25,17.85) A11(-10.85,17.85) A12(-10.15,17.85) A14(-8.75,17.85) A15(-8.05,17.85) A17(-6.65,17.85) A18(-5.95,17.85) A20(-4.55,17.85) A21(-3.85,17.85) A23(-2.45,17.85) A24(-1.75,17.85) A26(-0.35,17.85) A27(0.35,17.85) A29(1.75,17.85) A30(2.45,17.85) A32(3.85,17.85) A33(4.55,17.85) A35(5.95,17.85) A36(6.65,17.85) A38(8.05,17.85) A39(8.75,17.85) A41(10.15,17.85) A42(10.85,17.85) A44(12.25,17.85) A45(12.95,17.85) A47(14.35,17.85) A48(15.05,17.85) A49(15.75,17.85) A50(16.45,17.85) A51(17.15,17.85) AA1(-17.85,3.85) AA2(-17.15,3.85) AA3(-16.45,3.85) AA4(-15.75,3.85) AA5(-15.05,3.85) AA6(-14.35,3.85) AA7(-13.65,3.85) AA8(-12.95,3.85) AA9(-12.25,3.85) AA10(-11.55,3.85) AA11(-10.85,3.85) AA14(-8.75,3.85) AA15(-8.05,3.85) AA16(-7.35,3.85) AA17(-6.65,3.85) AA18(-5.95,3.85) AA19(-5.25,3.85) AA20(-4.55,3.85) AA21(-3.85,3.85) AA22(-3.15,3.85) AA23(-2.45,3.85) AA24(-1.75,3.85) AA25(-1.05,3.85) AA26(-0.35,3.85) AA27(0.35,3.85) AA28(1.05,3.85) AA29(1.75,3.85) AA30(2.45,3.85) AA31(3.15,3.85) AA32(3.85,3.85) AA33(4.55,3.85) AA34(5.25,3.85) AA35(5.95,3.85) AA36(6.65,3.85) AA37(7.35,3.85) AA38(8.05,3.85) AA39(8.75,3.85) AA42(10.85,3.85) AA43(11.55,3.85) AA44(12.25,3.85) AA45(12.95,3.85) AA46(13.65,3.85) AA47(14.35,3.85) AA48(15.05,3.85) AA49(15.75,3.85) AA50(16.45,3.85) AA51(17.15,3.85) AA52(17.85,3.85) AB2(-17.15,3.15) AB4(-15.75,3.15) AB6(-14.35,3.15) AB8(-12.95,3.15) AB10(-11.55,3.15) AB13(-9.45,3.15) AB14(-8.75,3.15) AB15(-8.05,3.15) AB16(-7.35,3.15) AB17(-6.65,3.15) AB18(-5.95,3.15) AB19(-5.25,3.15) AB20(-4.55,3.15) AB21(-3.85,3.15) AB22(-3.15,3.15) AB23(-2.45,3.15) AB24(-1.75,3.15) AB25(-1.05,3.15) AB26(-0.35,3.15) AB27(0.35,3.15) AB28(1.05,3.15) AB29(1.75,3.15) AB30(2.45,3.15) AB31(3.15,3.15) AB32(3.85,3.15) AB33(4.55,3.15) AB34(5.25,3.15) AB35(5.95,3.15) AB36(6.65,3.15) AB37(7.35,3.15) AB38(8.05,3.15) AB39(8.75,3.15) AB40(9.45,3.15) AB43(11.55,3.15) AB45(12.95,3.15) AB47(14.35,3.15) AB49(15.75,3.15) AB51(17.15,3.15) AC1(-17.85,2.45) AC2(-17.15,2.45) AC3(-16.45,2.45) AC4(-15.75,2.45) AC5(-15.05,2.45) AC6(-14.35,2.45) AC7(-13.65,2.45) AC8(-12.95,2.45) AC9(-12.25,2.45) AC10(-11.55,2.45) AC11(-10.85,2.45) AC14(-8.75,2.45) AC15(-8.05,2.45) AC16(-7.35,2.45) AC17(-6.65,2.45) AC18(-5.95,2.45) AC19(-5.25,2.45) AC20(-4.55,2.45) AC21(-3.85,2.45) AC22(-3.15,2.45) AC23(-2.45,2.45) AC24(-1.75,2.45) AC25(-1.05,2.45) AC26(-0.35,2.45) AC27(0.35,2.45) AC28(1.05,2.45) AC29(1.75,2.45) AC30(2.45,2.45) AC31(3.15,2.45) AC32(3.85,2.45) AC33(4.55,2.45) AC34(5.25,2.45) AC35(5.95,2.45) AC36(6.65,2.45) AC37(7.35,2.45) AC38(8.05,2.45) AC39(8.75,2.45) AC42(10.85,2.45) AC43(11.55,2.45) AC44(12.25,2.45) AC45(12.95,2.45) AC46(13.65,2.45) AC47(14.35,2.45) AC48(15.05,2.45) AC49(15.75,2.45) AC50(16.45,2.45) AC51(17.15,2.45) AC52(17.85,2.45) AD1(-17.85,1.75) AD2(-17.15,1.75) AD3(-16.45,1.75) AD4(-15.75,1.75) AD5(-15.05,1.75) AD6(-14.35,1.75) AD7(-13.65,1.75) AD8(-12.95,1.75) AD9(-12.25,1.75) AD10(-11.55,1.75) AD11(-10.85,1.75) AD14(-8.75,1.75) AD15(-8.05,1.75) AD16(-7.35,1.75) AD17(-6.65,1.75) AD18(-5.95,1.75) AD19(-5.25,1.75) AD20(-4.55,1.75) AD21(-3.85,1.75) AD22(-3.15,1.75) AD23(-2.45,1.75) AD24(-1.75,1.75) AD25(-1.05,1.75) AD26(-0.35,1.75) AD27(0.35,1.75) AD28(1.05,1.75) AD29(1.75,1.75) AD30(2.45,1.75) AD31(3.15,1.75) AD32(3.85,1.75) AD33(4.55,1.75) AD34(5.25,1.75) AD35(5.95,1.75) AD36(6.65,1.75) AD37(7.35,1.75) AD38(8.05,1.75) AD39(8.75,1.75) AD42(10.85,1.75) AD43(11.55,1.75) AD44(12.25,1.75) AD45(12.95,1.75) AD46(13.65,1.75) AD47(14.35,1.75) AD48(15.05,1.75) AD49(15.75,1.75) AD50(16.45,1.75) AD51(17.15,1.75) AD52(17.85,1.75) AE2(-17.15,1.05) AE4(-15.75,1.05) AE6(-14.35,1.05) AE8(-12.95,1.05) AE10(-11.55,1.05) AE14(-8.75,1.05) AE15(-8.05,1.05) AE16(-7.35,1.05) AE17(-6.65,1.05) AE18(-5.95,1.05) AE19(-5.25,1.05) AE20(-4.55,1.05) AE21(-3.85,1.05) AE22(-3.15,1.05) AE23(-2.45,1.05) AE24(-1.75,1.05) AE25(-1.05,1.05) AE26(-0.35,1.05) AE27(0.35,1.05) AE28(1.05,1.05) AE29(1.75,1.05) AE30(2.45,1.05) AE31(3.15,1.05) AE32(3.85,1.05) AE33(4.55,1.05) AE34(5.25,1.05) AE35(5.95,1.05) AE36(6.65,1.05) AE37(7.35,1.05) AE38(8.05,1.05) AE39(8.75,1.05) AE43(11.55,1.05) AE45(12.95,1.05) AE47(14.35,1.05) AE49(15.75,1.05) AE51(17.15,1.05) AF1(-17.85,0.35) AF2(-17.15,0.35) AF3(-16.45,0.35) AF4(-15.75,0.35) AF5(-15.05,0.35) AF6(-14.35,0.35) AF7(-13.65,0.35) AF8(-12.95,0.35) AF9(-12.25,0.35) AF10(-11.55,0.35) AF11(-10.85,0.35) AF13(-9.45,0.35) AF14(-8.75,0.35) AF15(-8.05,0.35) AF16(-7.35,0.35) AF17(-6.65,0.35) AF18(-5.95,0.35) AF19(-5.25,0.35) AF20(-4.55,0.35) AF21(-3.85,0.35) AF22(-3.15,0.35) AF23(-2.45,0.35) AF24(-1.75,0.35) AF25(-1.05,0.35) AF26(-0.35,0.35) AF27(0.35,0.35) AF28(1.05,0.35) AF29(1.75,0.35) AF30(2.45,0.35) AF31(3.15,0.35) AF32(3.85,0.35) AF33(4.55,0.35) AF34(5.25,0.35) AF35(5.95,0.35) AF36(6.65,0.35) AF37(7.35,0.35) AF38(8.05,0.35) AF39(8.75,0.35) AF40(9.45,0.35) AF42(10.85,0.35) AF43(11.55,0.35) AF44(12.25,0.35) AF45(12.95,0.35) AF46(13.65,0.35) AF47(14.35,0.35) AF48(15.05,0.35) AF49(15.75,0.35) AF50(16.45,0.35) AF51(17.15,0.35) AF52(17.85,0.35) AG1(-17.85,-0.35) AG2(-17.15,-0.35) AG3(-16.45,-0.35) AG4(-15.75,-0.35) AG5(-15.05,-0.35) AG6(-14.35,-0.35) AG7(-13.65,-0.35) AG8(-12.95,-0.35) AG9(-12.25,-0.35) AG10(-11.55,-0.35) AG11(-10.85,-0.35) AG13(-9.45,-0.35) AG14(-8.75,-0.35) AG15(-8.05,-0.35) AG16(-7.35,-0.35) AG17(-6.65,-0.35) AG18(-5.95,-0.35) AG19(-5.25,-0.35) AG20(-4.55,-0.35) AG21(-3.85,-0.35) AG22(-3.15,-0.35) AG23(-2.45,-0.35) AG24(-1.75,-0.35) AG25(-1.05,-0.35) AG26(-0.35,-0.35) AG27(0.35,-0.35) AG28(1.05,-0.35) AG29(1.75,-0.35) AG30(2.45,-0.35) AG31(3.15,-0.35) AG32(3.85,-0.35) AG33(4.55,-0.35) AG34(5.25,-0.35) AG35(5.95,-0.35) AG36(6.65,-0.35) AG37(7.35,-0.35) AG38(8.05,-0.35) AG39(8.75,-0.35) AG40(9.45,-0.35) AG42(10.85,-0.35) AG43(11.55,-0.35) AG44(12.25,-0.35) AG45(12.95,-0.35) AG46(13.65,-0.35) AG47(14.35,-0.35) AG48(15.05,-0.35) AG49(15.75,-0.35) AG50(16.45,-0.35) AG51(17.15,-0.35) AG52(17.85,-0.35) AH2(-17.15,-1.05) AH4(-15.75,-1.05) AH6(-14.35,-1.05) AH8(-12.95,-1.05) AH10(-11.55,-1.05) AH14(-8.75,-1.05) AH15(-8.05,-1.05) AH16(-7.35,-1.05) AH17(-6.65,-1.05) AH18(-5.95,-1.05) AH19(-5.25,-1.05) AH20(-4.55,-1.05) AH21(-3.85,-1.05) AH22(-3.15,-1.05) AH23(-2.45,-1.05) AH24(-1.75,-1.05) AH25(-1.05,-1.05) AH26(-0.35,-1.05) AH27(0.35,-1.05) AH28(1.05,-1.05) AH29(1.75,-1.05) AH30(2.45,-1.05) AH31(3.15,-1.05) AH32(3.85,-1.05) AH33(4.55,-1.05) AH34(5.25,-1.05) AH35(5.95,-1.05) AH36(6.65,-1.05) AH37(7.35,-1.05) AH38(8.05,-1.05) AH39(8.75,-1.05) AH43(11.55,-1.05) AH45(12.95,-1.05) AH47(14.35,-1.05) AH49(15.75,-1.05) AH51(17.15,-1.05) AJ1(-17.85,-1.75) AJ2(-17.15,-1.75) AJ3(-16.45,-1.75) AJ4(-15.75,-1.75) AJ5(-15.05,-1.75) AJ6(-14.35,-1.75) AJ7(-13.65,-1.75) AJ8(-12.95,-1.75) AJ9(-12.25,-1.75) AJ10(-11.55,-1.75) AJ11(-10.85,-1.75) AJ14(-8.75,-1.75) AJ15(-8.05,-1.75) AJ16(-7.35,-1.75) AJ17(-6.65,-1.75) AJ18(-5.95,-1.75) AJ19(-5.25,-1.75) AJ20(-4.55,-1.75) AJ21(-3.85,-1.75) AJ22(-3.15,-1.75) AJ23(-2.45,-1.75) AJ24(-1.75,-1.75) AJ25(-1.05,-1.75) AJ26(-0.35,-1.75) AJ27(0.35,-1.75) AJ28(1.05,-1.75) AJ29(1.75,-1.75) AJ30(2.45,-1.75) AJ31(3.15,-1.75) AJ32(3.85,-1.75) AJ33(4.55,-1.75) AJ34(5.25,-1.75) AJ35(5.95,-1.75) AJ36(6.65,-1.75) AJ37(7.35,-1.75) AJ38(8.05,-1.75) AJ39(8.75,-1.75) AJ42(10.85,-1.75) AJ43(11.55,-1.75) AJ44(12.25,-1.75) AJ45(12.95,-1.75) AJ46(13.65,-1.75) AJ47(14.35,-1.75) AJ48(15.05,-1.75) AJ49(15.75,-1.75) AJ50(16.45,-1.75) AJ51(17.15,-1.75) AJ52(17.85,-1.75) AK1(-17.85,-2.45) AK2(-17.15,-2.45) AK3(-16.45,-2.45) AK4(-15.75,-2.45) AK5(-15.05,-2.45) AK6(-14.35,-2.45) AK7(-13.65,-2.45) AK8(-12.95,-2.45) AK9(-12.25,-2.45) AK10(-11.55,-2.45) AK11(-10.85,-2.45) AK14(-8.75,-2.45) AK15(-8.05,-2.45) AK16(-7.35,-2.45) AK17(-6.65,-2.45) AK18(-5.95,-2.45) AK19(-5.25,-2.45) AK20(-4.55,-2.45) AK21(-3.85,-2.45) AK22(-3.15,-2.45) AK23(-2.45,-2.45) AK24(-1.75,-2.45) AK25(-1.05,-2.45) AK26(-0.35,-2.45) AK27(0.35,-2.45) AK28(1.05,-2.45) AK29(1.75,-2.45) AK30(2.45,-2.45) AK31(3.15,-2.45) AK32(3.85,-2.45) AK33(4.55,-2.45) AK34(5.25,-2.45) AK35(5.95,-2.45) AK36(6.65,-2.45) AK37(7.35,-2.45) AK38(8.05,-2.45) AK39(8.75,-2.45) AK42(10.85,-2.45) AK43(11.55,-2.45) AK44(12.25,-2.45) AK45(12.95,-2.45) AK46(13.65,-2.45) AK47(14.35,-2.45) AK48(15.05,-2.45) AK49(15.75,-2.45) AK50(16.45,-2.45) AK51(17.15,-2.45) AK52(17.85,-2.45) AL2(-17.15,-3.15) AL4(-15.75,-3.15) AL6(-14.35,-3.15) AL8(-12.95,-3.15) AL10(-11.55,-3.15) AL13(-9.45,-3.15) AL14(-8.75,-3.15) AL15(-8.05,-3.15) AL16(-7.35,-3.15) AL17(-6.65,-3.15) AL18(-5.95,-3.15) AL19(-5.25,-3.15) AL20(-4.55,-3.15) AL21(-3.85,-3.15) AL22(-3.15,-3.15) AL23(-2.45,-3.15) AL24(-1.75,-3.15) AL25(-1.05,-3.15) AL26(-0.35,-3.15) AL27(0.35,-3.15) AL28(1.05,-3.15) AL29(1.75,-3.15) AL30(2.45,-3.15) AL31(3.15,-3.15) AL32(3.85,-3.15) AL33(4.55,-3.15) AL34(5.25,-3.15) AL35(5.95,-3.15) AL36(6.65,-3.15) AL37(7.35,-3.15) AL38(8.05,-3.15) AL39(8.75,-3.15) AL40(9.45,-3.15) AL43(11.55,-3.15) AL45(12.95,-3.15) AL47(14.35,-3.15) AL49(15.75,-3.15) AL51(17.15,-3.15) AM1(-17.85,-3.85) AM2(-17.15,-3.85) AM3(-16.45,-3.85) AM4(-15.75,-3.85) AM5(-15.05,-3.85) AM6(-14.35,-3.85) AM7(-13.65,-3.85) AM8(-12.95,-3.85) AM9(-12.25,-3.85) AM10(-11.55,-3.85) AM11(-10.85,-3.85) AM14(-8.75,-3.85) AM15(-8.05,-3.85) AM16(-7.35,-3.85) AM17(-6.65,-3.85) AM18(-5.95,-3.85) AM19(-5.25,-3.85) AM20(-4.55,-3.85) AM21(-3.85,-3.85) AM22(-3.15,-3.85) AM23(-2.45,-3.85) AM24(-1.75,-3.85) AM25(-1.05,-3.85) AM26(-0.35,-3.85) AM27(0.35,-3.85) AM28(1.05,-3.85) AM29(1.75,-3.85) AM30(2.45,-3.85) AM31(3.15,-3.85) AM32(3.85,-3.85) AM33(4.55,-3.85) AM34(5.25,-3.85) AM35(5.95,-3.85) AM36(6.65,-3.85) AM37(7.35,-3.85) AM38(8.05,-3.85) AM39(8.75,-3.85) AM42(10.85,-3.85) AM43(11.55,-3.85) AM44(12.25,-3.85) AM45(12.95,-3.85) AM46(13.65,-3.85) AM47(14.35,-3.85) AM48(15.05,-3.85) AM49(15.75,-3.85) AM50(16.45,-3.85) AM51(17.15,-3.85) AM52(17.85,-3.85) AN1(-17.85,-4.55) AN2(-17.15,-4.55) AN3(-16.45,-4.55) AN4(-15.75,-4.55) AN5(-15.05,-4.55) AN6(-14.35,-4.55) AN7(-13.65,-4.55) AN8(-12.95,-4.55) AN9(-12.25,-4.55) AN10(-11.55,-4.55) AN11(-10.85,-4.55) AN14(-8.75,-4.55) AN15(-8.05,-4.55) AN16(-7.35,-4.55) AN17(-6.65,-4.55) AN18(-5.95,-4.55) AN19(-5.25,-4.55) AN20(-4.55,-4.55) AN21(-3.85,-4.55) AN22(-3.15,-4.55) AN23(-2.45,-4.55) AN24(-1.75,-4.55) AN25(-1.05,-4.55) AN26(-0.35,-4.55) AN27(0.35,-4.55) AN28(1.05,-4.55) AN29(1.75,-4.55) AN30(2.45,-4.55) AN31(3.15,-4.55) AN32(3.85,-4.55) AN33(4.55,-4.55) AN34(5.25,-4.55) AN35(5.95,-4.55) AN36(6.65,-4.55) AN37(7.35,-4.55) AN38(8.05,-4.55) AN39(8.75,-4.55) AN42(10.85,-4.55) AN43(11.55,-4.55) AN44(12.25,-4.55) AN45(12.95,-4.55) AN46(13.65,-4.55) AN47(14.35,-4.55) AN48(15.05,-4.55) AN49(15.75,-4.55) AN50(16.45,-4.55) AN51(17.15,-4.55) AN52(17.85,-4.55) AP2(-17.15,-5.25) AP4(-15.75,-5.25) AP6(-14.35,-5.25) AP8(-12.95,-5.25) AP10(-11.55,-5.25) AP14(-8.75,-5.25) AP15(-8.05,-5.25) AP16(-7.35,-5.25) AP17(-6.65,-5.25) AP18(-5.95,-5.25) AP19(-5.25,-5.25) AP20(-4.55,-5.25) AP21(-3.85,-5.25) AP22(-3.15,-5.25) AP23(-2.45,-5.25) AP24(-1.75,-5.25) AP25(-1.05,-5.25) AP26(-0.35,-5.25) AP27(0.35,-5.25) AP28(1.05,-5.25) AP29(1.75,-5.25) AP30(2.45,-5.25) AP31(3.15,-5.25) AP32(3.85,-5.25) AP33(4.55,-5.25) AP34(5.25,-5.25) AP35(5.95,-5.25) AP36(6.65,-5.25) AP37(7.35,-5.25) AP38(8.05,-5.25) AP39(8.75,-5.25) AP43(11.55,-5.25) AP45(12.95,-5.25) AP47(14.35,-5.25) AP49(15.75,-5.25) AP51(17.15,-5.25) AR1(-17.85,-5.95) AR2(-17.15,-5.95) AR3(-16.45,-5.95) AR4(-15.75,-5.95) AR5(-15.05,-5.95) AR6(-14.35,-5.95) AR7(-13.65,-5.95) AR8(-12.95,-5.95) AR9(-12.25,-5.95) AR10(-11.55,-5.95) AR11(-10.85,-5.95) AR13(-9.45,-5.95) AR14(-8.75,-5.95) AR15(-8.05,-5.95) AR16(-7.35,-5.95) AR17(-6.65,-5.95) AR18(-5.95,-5.95) AR19(-5.25,-5.95) AR20(-4.55,-5.95) AR21(-3.85,-5.95) AR22(-3.15,-5.95) AR23(-2.45,-5.95) AR24(-1.75,-5.95) AR25(-1.05,-5.95) AR26(-0.35,-5.95) AR27(0.35,-5.95) AR28(1.05,-5.95) AR29(1.75,-5.95) AR30(2.45,-5.95) AR31(3.15,-5.95) AR32(3.85,-5.95) AR33(4.55,-5.95) AR34(5.25,-5.95) AR35(5.95,-5.95) AR36(6.65,-5.95) AR37(7.35,-5.95) AR38(8.05,-5.95) AR39(8.75,-5.95) AR40(9.45,-5.95) AR42(10.85,-5.95) AR43(11.55,-5.95) AR44(12.25,-5.95) AR45(12.95,-5.95) AR46(13.65,-5.95) AR47(14.35,-5.95) AR48(15.05,-5.95) AR49(15.75,-5.95) AR50(16.45,-5.95) AR51(17.15,-5.95) AR52(17.85,-5.95) AT1(-17.85,-6.65) AT2(-17.15,-6.65) AT3(-16.45,-6.65) AT4(-15.75,-6.65) AT5(-15.05,-6.65) AT6(-14.35,-6.65) AT7(-13.65,-6.65) AT8(-12.95,-6.65) AT9(-12.25,-6.65) AT10(-11.55,-6.65) AT11(-10.85,-6.65) AT14(-8.75,-6.65) AT15(-8.05,-6.65) AT16(-7.35,-6.65) AT17(-6.65,-6.65) AT18(-5.95,-6.65) AT19(-5.25,-6.65) AT20(-4.55,-6.65) AT21(-3.85,-6.65) AT22(-3.15,-6.65) AT23(-2.45,-6.65) AT24(-1.75,-6.65) AT25(-1.05,-6.65) AT26(-0.35,-6.65) AT27(0.35,-6.65) AT28(1.05,-6.65) AT29(1.75,-6.65) AT30(2.45,-6.65) AT31(3.15,-6.65) AT32(3.85,-6.65) AT33(4.55,-6.65) AT34(5.25,-6.65) AT35(5.95,-6.65) AT36(6.65,-6.65) AT37(7.35,-6.65) AT38(8.05,-6.65) AT39(8.75,-6.65) AT42(10.85,-6.65) AT43(11.55,-6.65) AT44(12.25,-6.65) AT45(12.95,-6.65) AT46(13.65,-6.65) AT47(14.35,-6.65) AT48(15.05,-6.65) AT49(15.75,-6.65) AT50(16.45,-6.65) AT51(17.15,-6.65) AT52(17.85,-6.65) AU2(-17.15,-7.35) AU4(-15.75,-7.35) AU6(-14.35,-7.35) AU8(-12.95,-7.35) AU10(-11.55,-7.35) AU14(-8.75,-7.35) AU15(-8.05,-7.35) AU16(-7.35,-7.35) AU17(-6.65,-7.35) AU18(-5.95,-7.35) AU19(-5.25,-7.35) AU20(-4.55,-7.35) AU21(-3.85,-7.35) AU22(-3.15,-7.35) AU23(-2.45,-7.35) AU24(-1.75,-7.35) AU25(-1.05,-7.35) AU26(-0.35,-7.35) AU27(0.35,-7.35) AU28(1.05,-7.35) AU29(1.75,-7.35) AU30(2.45,-7.35) AU31(3.15,-7.35) AU32(3.85,-7.35) AU33(4.55,-7.35) AU34(5.25,-7.35) AU35(5.95,-7.35) AU36(6.65,-7.35) AU37(7.35,-7.35) AU38(8.05,-7.35) AU39(8.75,-7.35) AU43(11.55,-7.35) AU45(12.95,-7.35) AU47(14.35,-7.35) AU49(15.75,-7.35) AU51(17.15,-7.35) AV1(-17.85,-8.05) AV2(-17.15,-8.05) AV3(-16.45,-8.05) AV4(-15.75,-8.05) AV5(-15.05,-8.05) AV6(-14.35,-8.05) AV7(-13.65,-8.05) AV8(-12.95,-8.05) AV9(-12.25,-8.05) AV10(-11.55,-8.05) AV11(-10.85,-8.05) AV14(-8.75,-8.05) AV15(-8.05,-8.05) AV16(-7.35,-8.05) AV17(-6.65,-8.05) AV18(-5.95,-8.05) AV19(-5.25,-8.05) AV20(-4.55,-8.05) AV21(-3.85,-8.05) AV22(-3.15,-8.05) AV23(-2.45,-8.05) AV24(-1.75,-8.05) AV25(-1.05,-8.05) AV26(-0.35,-8.05) AV27(0.35,-8.05) AV28(1.05,-8.05) AV29(1.75,-8.05) AV30(2.45,-8.05) AV31(3.15,-8.05) AV32(3.85,-8.05) AV33(4.55,-8.05) AV34(5.25,-8.05) AV35(5.95,-8.05) AV36(6.65,-8.05) AV37(7.35,-8.05) AV38(8.05,-8.05) AV39(8.75,-8.05) AV42(10.85,-8.05) AV43(11.55,-8.05) AV44(12.25,-8.05) AV45(12.95,-8.05) AV46(13.65,-8.05) AV47(14.35,-8.05) AV48(15.05,-8.05) AV49(15.75,-8.05) AV50(16.45,-8.05) AV51(17.15,-8.05) AV52(17.85,-8.05) AW1(-17.85,-8.75) AW2(-17.15,-8.75) AW3(-16.45,-8.75) AW4(-15.75,-8.75) AW5(-15.05,-8.75) AW6(-14.35,-8.75) AW7(-13.65,-8.75) AW8(-12.95,-8.75) AW9(-12.25,-8.75) AW10(-11.55,-8.75) AW11(-10.85,-8.75) AW13(-9.45,-8.75) AW14(-8.75,-8.75) AW15(-8.05,-8.75) AW16(-7.35,-8.75) AW17(-6.65,-8.75) AW18(-5.95,-8.75) AW19(-5.25,-8.75) AW20(-4.55,-8.75) AW21(-3.85,-8.75) AW22(-3.15,-8.75) AW23(-2.45,-8.75) AW24(-1.75,-8.75) AW25(-1.05,-8.75) AW26(-0.35,-8.75) AW27(0.35,-8.75) AW28(1.05,-8.75) AW29(1.75,-8.75) AW30(2.45,-8.75) AW31(3.15,-8.75) AW32(3.85,-8.75) AW33(4.55,-8.75) AW34(5.25,-8.75) AW35(5.95,-8.75) AW36(6.65,-8.75) AW37(7.35,-8.75) AW38(8.05,-8.75) AW39(8.75,-8.75) AW40(9.45,-8.75) AW42(10.85,-8.75) AW43(11.55,-8.75) AW44(12.25,-8.75) AW45(12.95,-8.75) AW46(13.65,-8.75) AW47(14.35,-8.75) AW48(15.05,-8.75) AW49(15.75,-8.75) AW50(16.45,-8.75) AW51(17.15,-8.75) AW52(17.85,-8.75) AY2(-17.15,-9.45) AY4(-15.75,-9.45) AY6(-14.35,-9.45) AY8(-12.95,-9.45) AY10(-11.55,-9.45) AY14(-8.75,-9.45) AY18(-5.95,-9.45) AY22(-3.15,-9.45) AY26(-0.35,-9.45) AY27(0.35,-9.45) AY31(3.15,-9.45) AY35(5.95,-9.45) AY39(8.75,-9.45) AY43(11.55,-9.45) AY45(12.95,-9.45) AY47(14.35,-9.45) AY49(15.75,-9.45) AY51(17.15,-9.45) B1(-17.85,17.15) B2(-17.15,17.15) B3(-16.45,17.15) B4(-15.75,17.15) B5(-15.05,17.15) B6(-14.35,17.15) B7(-13.65,17.15) B8(-12.95,17.15) B9(-12.25,17.15) B10(-11.55,17.15) B11(-10.85,17.15) B12(-10.15,17.15) B13(-9.45,17.15) B14(-8.75,17.15) B15(-8.05,17.15) B16(-7.35,17.15) B17(-6.65,17.15) B18(-5.95,17.15) B19(-5.25,17.15) B20(-4.55,17.15) B21(-3.85,17.15) B22(-3.15,17.15) B23(-2.45,17.15) B24(-1.75,17.15) B25(-1.05,17.15) B26(-0.35,17.15) B27(0.35,17.15) B28(1.05,17.15) B29(1.75,17.15) B30(2.45,17.15) B31(3.15,17.15) B32(3.85,17.15) B33(4.55,17.15) B34(5.25,17.15) B35(5.95,17.15) B36(6.65,17.15) B37(7.35,17.15) B38(8.05,17.15) B39(8.75,17.15) B40(9.45,17.15) B41(10.15,17.15) B42(10.85,17.15) B43(11.55,17.15) B44(12.25,17.15) B45(12.95,17.15) B46(13.65,17.15) B47(14.35,17.15) B48(15.05,17.15) B49(15.75,17.15) B50(16.45,17.15) B51(17.15,17.15) B52(17.85,17.15) BA1(-17.85,-10.15) BA2(-17.15,-10.15) BA3(-16.45,-10.15) BA4(-15.75,-10.15) BA5(-15.05,-10.15) BA6(-14.35,-10.15) BA7(-13.65,-10.15) BA8(-12.95,-10.15) BA9(-12.25,-10.15) BA10(-11.55,-10.15) BA43(11.55,-10.15) BA44(12.25,-10.15) BA45(12.95,-10.15) BA46(13.65,-10.15) BA47(14.35,-10.15) BA48(15.05,-10.15) BA49(15.75,-10.15) BA50(16.45,-10.15) BA51(17.15,-10.15) BA52(17.85,-10.15) BB1(-17.85,-10.85) BB2(-17.15,-10.85) BB3(-16.45,-10.85) BB4(-15.75,-10.85) BB5(-15.05,-10.85) BB6(-14.35,-10.85) BB7(-13.65,-10.85) BB8(-12.95,-10.85) BB14(-8.75,-10.85) BB15(-8.05,-10.85) BB17(-6.65,-10.85) BB18(-5.95,-10.85) BB20(-4.55,-10.85) BB21(-3.85,-10.85) BB23(-2.45,-10.85) BB24(-1.75,-10.85) BB26(-0.35,-10.85) BB27(0.35,-10.85) BB29(1.75,-10.85) BB30(2.45,-10.85) BB32(3.85,-10.85) BB33(4.55,-10.85) BB35(5.95,-10.85) BB36(6.65,-10.85) BB38(8.05,-10.85) BB39(8.75,-10.85) BB45(12.95,-10.85) BB46(13.65,-10.85) BB47(14.35,-10.85) BB48(15.05,-10.85) BB49(15.75,-10.85) BB50(16.45,-10.85) BB51(17.15,-10.85) BB52(17.85,-10.85) BC2(-17.15,-11.55) BC4(-15.75,-11.55) BC6(-14.35,-11.55) BC8(-12.95,-11.55) BC12(-10.15,-11.55) BC13(-9.45,-11.55) BC14(-8.75,-11.55) BC15(-8.05,-11.55) BC16(-7.35,-11.55) BC17(-6.65,-11.55) BC18(-5.95,-11.55) BC19(-5.25,-11.55) BC20(-4.55,-11.55) BC21(-3.85,-11.55) BC22(-3.15,-11.55) BC23(-2.45,-11.55) BC24(-1.75,-11.55) BC25(-1.05,-11.55) BC26(-0.35,-11.55) BC27(0.35,-11.55) BC28(1.05,-11.55) BC29(1.75,-11.55) BC30(2.45,-11.55) BC31(3.15,-11.55) BC32(3.85,-11.55) BC33(4.55,-11.55) BC34(5.25,-11.55) BC35(5.95,-11.55) BC36(6.65,-11.55) BC37(7.35,-11.55) BC38(8.05,-11.55) BC39(8.75,-11.55) BC40(9.45,-11.55) BC41(10.15,-11.55) BC45(12.95,-11.55) BC47(14.35,-11.55) BC49(15.75,-11.55) BC51(17.15,-11.55) BD1(-17.85,-12.25) BD2(-17.15,-12.25) BD3(-16.45,-12.25) BD4(-15.75,-12.25) BD5(-15.05,-12.25) BD6(-14.35,-12.25) BD7(-13.65,-12.25) BD12(-10.15,-12.25) BD14(-8.75,-12.25) BD15(-8.05,-12.25) BD17(-6.65,-12.25) BD18(-5.95,-12.25) BD20(-4.55,-12.25) BD21(-3.85,-12.25) BD23(-2.45,-12.25) BD24(-1.75,-12.25) BD26(-0.35,-12.25) BD27(0.35,-12.25) BD29(1.75,-12.25) BD30(2.45,-12.25) BD32(3.85,-12.25) BD33(4.55,-12.25) BD35(5.95,-12.25) BD36(6.65,-12.25) BD38(8.05,-12.25) BD39(8.75,-12.25) BD41(10.15,-12.25) BD46(13.65,-12.25) BD47(14.35,-12.25) BD48(15.05,-12.25) BD49(15.75,-12.25) BD50(16.45,-12.25) BD51(17.15,-12.25) BD52(17.85,-12.25) BE1(-17.85,-12.95) BE2(-17.15,-12.95) BE3(-16.45,-12.95) BE4(-15.75,-12.95) BE5(-15.05,-12.95) BE6(-14.35,-12.95) BE7(-13.65,-12.95) BE10(-11.55,-12.95) BE11(-10.85,-12.95) BE12(-10.15,-12.95) BE13(-9.45,-12.95) BE14(-8.75,-12.95) BE15(-8.05,-12.95) BE16(-7.35,-12.95) BE17(-6.65,-12.95) BE18(-5.95,-12.95) BE19(-5.25,-12.95) BE20(-4.55,-12.95) BE21(-3.85,-12.95) BE22(-3.15,-12.95) BE23(-2.45,-12.95) BE24(-1.75,-12.95) BE25(-1.05,-12.95) BE26(-0.35,-12.95) BE27(0.35,-12.95) BE28(1.05,-12.95) BE29(1.75,-12.95) BE30(2.45,-12.95) BE31(3.15,-12.95) BE32(3.85,-12.95) BE33(4.55,-12.95) BE34(5.25,-12.95) BE35(5.95,-12.95) BE36(6.65,-12.95) BE37(7.35,-12.95) BE38(8.05,-12.95) BE39(8.75,-12.95) BE40(9.45,-12.95) BE41(10.15,-12.95) BE42(10.85,-12.95) BE43(11.55,-12.95) BE46(13.65,-12.95) BE47(14.35,-12.95) BE48(15.05,-12.95) BE49(15.75,-12.95) BE50(16.45,-12.95) BE51(17.15,-12.95) BE52(17.85,-12.95) BF2(-17.15,-13.65) BF4(-15.75,-13.65) BF6(-14.35,-13.65) BF8(-12.95,-13.65) BF9(-12.25,-13.65) BF11(-10.85,-13.65) BF12(-10.15,-13.65) BF14(-8.75,-13.65) BF15(-8.05,-13.65) BF17(-6.65,-13.65) BF18(-5.95,-13.65) BF20(-4.55,-13.65) BF21(-3.85,-13.65) BF23(-2.45,-13.65) BF24(-1.75,-13.65) BF26(-0.35,-13.65) BF27(0.35,-13.65) BF29(1.75,-13.65) BF30(2.45,-13.65) BF32(3.85,-13.65) BF33(4.55,-13.65) BF35(5.95,-13.65) BF36(6.65,-13.65) BF38(8.05,-13.65) BF39(8.75,-13.65) BF41(10.15,-13.65) BF42(10.85,-13.65) BF44(12.25,-13.65) BF45(12.95,-13.65) BF47(14.35,-13.65) BF49(15.75,-13.65) BF51(17.15,-13.65) BG1(-17.85,-14.35) BG2(-17.15,-14.35) BG3(-16.45,-14.35) BG4(-15.75,-14.35) BG5(-15.05,-14.35) BG6(-14.35,-14.35) BG7(-13.65,-14.35) BG8(-12.95,-14.35) BG9(-12.25,-14.35) BG10(-11.55,-14.35) BG11(-10.85,-14.35) BG12(-10.15,-14.35) BG13(-9.45,-14.35) BG14(-8.75,-14.35) BG15(-8.05,-14.35) BG16(-7.35,-14.35) BG17(-6.65,-14.35) BG18(-5.95,-14.35) BG19(-5.25,-14.35) BG20(-4.55,-14.35) BG21(-3.85,-14.35) BG22(-3.15,-14.35) BG23(-2.45,-14.35) BG24(-1.75,-14.35) BG25(-1.05,-14.35) BG26(-0.35,-14.35) BG27(0.35,-14.35) BG28(1.05,-14.35) BG29(1.75,-14.35) BG30(2.45,-14.35) BG31(3.15,-14.35) BG32(3.85,-14.35) BG33(4.55,-14.35) BG34(5.25,-14.35) BG35(5.95,-14.35) BG36(6.65,-14.35) BG37(7.35,-14.35) BG38(8.05,-14.35) BG39(8.75,-14.35) BG40(9.45,-14.35) BG41(10.15,-14.35) BG42(10.85,-14.35) BG43(11.55,-14.35) BG44(12.25,-14.35) BG45(12.95,-14.35) BG46(13.65,-14.35) BG47(14.35,-14.35) BG48(15.05,-14.35) BG49(15.75,-14.35) BG50(16.45,-14.35) BG51(17.15,-14.35) BG52(17.85,-14.35) BH1(-17.85,-15.05) BH2(-17.15,-15.05) BH3(-16.45,-15.05) BH4(-15.75,-15.05) BH5(-15.05,-15.05) BH6(-14.35,-15.05) BH8(-12.95,-15.05) BH9(-12.25,-15.05) BH11(-10.85,-15.05) BH12(-10.15,-15.05) BH14(-8.75,-15.05) BH15(-8.05,-15.05) BH17(-6.65,-15.05) BH18(-5.95,-15.05) BH20(-4.55,-15.05) BH21(-3.85,-15.05) BH23(-2.45,-15.05) BH24(-1.75,-15.05) BH26(-0.35,-15.05) BH27(0.35,-15.05) BH29(1.75,-15.05) BH30(2.45,-15.05) BH32(3.85,-15.05) BH33(4.55,-15.05) BH35(5.95,-15.05) BH36(6.65,-15.05) BH38(8.05,-15.05) BH39(8.75,-15.05) BH41(10.15,-15.05) BH42(10.85,-15.05) BH44(12.25,-15.05) BH45(12.95,-15.05) BH47(14.35,-15.05) BH48(15.05,-15.05) BH49(15.75,-15.05) BH50(16.45,-15.05) BH51(17.15,-15.05) BH52(17.85,-15.05) BJ1(-17.85,-15.75) BJ2(-17.15,-15.75) BJ3(-16.45,-15.75) BJ4(-15.75,-15.75) BJ5(-15.05,-15.75) BJ6(-14.35,-15.75) BJ7(-13.65,-15.75) BJ8(-12.95,-15.75) BJ9(-12.25,-15.75) BJ10(-11.55,-15.75) BJ11(-10.85,-15.75) BJ12(-10.15,-15.75) BJ13(-9.45,-15.75) BJ14(-8.75,-15.75) BJ15(-8.05,-15.75) BJ16(-7.35,-15.75) BJ17(-6.65,-15.75) BJ18(-5.95,-15.75) BJ19(-5.25,-15.75) BJ20(-4.55,-15.75) BJ21(-3.85,-15.75) BJ22(-3.15,-15.75) BJ23(-2.45,-15.75) BJ24(-1.75,-15.75) BJ25(-1.05,-15.75) BJ26(-0.35,-15.75) BJ27(0.35,-15.75) BJ28(1.05,-15.75) BJ29(1.75,-15.75) BJ30(2.45,-15.75) BJ31(3.15,-15.75) BJ32(3.85,-15.75) BJ33(4.55,-15.75) BJ34(5.25,-15.75) BJ35(5.95,-15.75) BJ36(6.65,-15.75) BJ37(7.35,-15.75) BJ38(8.05,-15.75) BJ39(8.75,-15.75) BJ40(9.45,-15.75) BJ41(10.15,-15.75) BJ42(10.85,-15.75) BJ43(11.55,-15.75) BJ44(12.25,-15.75) BJ45(12.95,-15.75) BJ46(13.65,-15.75) BJ47(14.35,-15.75) BJ48(15.05,-15.75) BJ49(15.75,-15.75) BJ50(16.45,-15.75) BJ51(17.15,-15.75) BJ52(17.85,-15.75) BK1(-17.85,-16.45) BK2(-17.15,-16.45) BK3(-16.45,-16.45) BK4(-15.75,-16.45) BK5(-15.05,-16.45) BK6(-14.35,-16.45) BK8(-12.95,-16.45) BK9(-12.25,-16.45) BK11(-10.85,-16.45) BK12(-10.15,-16.45) BK14(-8.75,-16.45) BK15(-8.05,-16.45) BK17(-6.65,-16.45) BK18(-5.95,-16.45) BK20(-4.55,-16.45) BK21(-3.85,-16.45) BK23(-2.45,-16.45) BK24(-1.75,-16.45) BK26(-0.35,-16.45) BK27(0.35,-16.45) BK29(1.75,-16.45) BK30(2.45,-16.45) BK32(3.85,-16.45) BK33(4.55,-16.45) BK35(5.95,-16.45) BK36(6.65,-16.45) BK38(8.05,-16.45) BK39(8.75,-16.45) BK41(10.15,-16.45) BK42(10.85,-16.45) BK44(12.25,-16.45) BK45(12.95,-16.45) BK47(14.35,-16.45) BK48(15.05,-16.45) BK49(15.75,-16.45) BK50(16.45,-16.45) BK51(17.15,-16.45) BK52(17.85,-16.45) BL1(-17.85,-17.15) BL2(-17.15,-17.15) BL3(-16.45,-17.15) BL4(-15.75,-17.15) BL5(-15.05,-17.15) BL6(-14.35,-17.15) BL7(-13.65,-17.15) BL8(-12.95,-17.15) BL9(-12.25,-17.15) BL10(-11.55,-17.15) BL11(-10.85,-17.15) BL12(-10.15,-17.15) BL13(-9.45,-17.15) BL14(-8.75,-17.15) BL15(-8.05,-17.15) BL16(-7.35,-17.15) BL17(-6.65,-17.15) BL18(-5.95,-17.15) BL19(-5.25,-17.15) BL20(-4.55,-17.15) BL21(-3.85,-17.15) BL22(-3.15,-17.15) BL23(-2.45,-17.15) BL24(-1.75,-17.15) BL25(-1.05,-17.15) BL26(-0.35,-17.15) BL27(0.35,-17.15) BL28(1.05,-17.15) BL29(1.75,-17.15) BL30(2.45,-17.15) BL31(3.15,-17.15) BL32(3.85,-17.15) BL33(4.55,-17.15) BL34(5.25,-17.15) BL35(5.95,-17.15) BL36(6.65,-17.15) BL37(7.35,-17.15) BL38(8.05,-17.15) BL39(8.75,-17.15) BL40(9.45,-17.15) BL41(10.15,-17.15) BL42(10.85,-17.15) BL43(11.55,-17.15) BL44(12.25,-17.15) BL45(12.95,-17.15) BL46(13.65,-17.15) BL47(14.35,-17.15) BL48(15.05,-17.15) BL49(15.75,-17.15) BL50(16.45,-17.15) BL51(17.15,-17.15) BL52(17.85,-17.15) BM2(-17.15,-17.85) BM3(-16.45,-17.85) BM4(-15.75,-17.85) BM5(-15.05,-17.85) BM6(-14.35,-17.85) BM8(-12.95,-17.85) BM9(-12.25,-17.85) BM11(-10.85,-17.85) BM12(-10.15,-17.85) BM14(-8.75,-17.85) BM15(-8.05,-17.85) BM17(-6.65,-17.85) BM18(-5.95,-17.85) BM20(-4.55,-17.85) BM21(-3.85,-17.85) BM23(-2.45,-17.85) BM24(-1.75,-17.85) BM26(-0.35,-17.85) BM27(0.35,-17.85) BM29(1.75,-17.85) BM30(2.45,-17.85) BM32(3.85,-17.85) BM33(4.55,-17.85) BM35(5.95,-17.85) BM36(6.65,-17.85) BM38(8.05,-17.85) BM39(8.75,-17.85) BM41(10.15,-17.85) BM42(10.85,-17.85) BM44(12.25,-17.85) BM45(12.95,-17.85) BM47(14.35,-17.85) BM48(15.05,-17.85) BM49(15.75,-17.85) BM50(16.45,-17.85) BM51(17.15,-17.85) C1(-17.85,16.45) C2(-17.15,16.45) C3(-16.45,16.45) C4(-15.75,16.45) C5(-15.05,16.45) C6(-14.35,16.45) C8(-12.95,16.45) C9(-12.25,16.45) C11(-10.85,16.45) C12(-10.15,16.45) C14(-8.75,16.45) C15(-8.05,16.45) C17(-6.65,16.45) C18(-5.95,16.45) C20(-4.55,16.45) C21(-3.85,16.45) C23(-2.45,16.45) C24(-1.75,16.45) C26(-0.35,16.45) C27(0.35,16.45) C29(1.75,16.45) C30(2.45,16.45) C32(3.85,16.45) C33(4.55,16.45) C35(5.95,16.45) C36(6.65,16.45) C38(8.05,16.45) C39(8.75,16.45) C41(10.15,16.45) C42(10.85,16.45) C44(12.25,16.45) C45(12.95,16.45) C47(14.35,16.45) C48(15.05,16.45) C49(15.75,16.45) C50(16.45,16.45) C51(17.15,16.45) C52(17.85,16.45) D1(-17.85,15.75) D2(-17.15,15.75) D3(-16.45,15.75) D4(-15.75,15.75) D5(-15.05,15.75) D6(-14.35,15.75) D7(-13.65,15.75) D8(-12.95,15.75) D9(-12.25,15.75) D10(-11.55,15.75) D11(-10.85,15.75) D12(-10.15,15.75) D13(-9.45,15.75) D14(-8.75,15.75) D15(-8.05,15.75) D16(-7.35,15.75) D17(-6.65,15.75) D18(-5.95,15.75) D19(-5.25,15.75) D20(-4.55,15.75) D21(-3.85,15.75) D22(-3.15,15.75) D23(-2.45,15.75) D24(-1.75,15.75) D25(-1.05,15.75) D26(-0.35,15.75) D27(0.35,15.75) D28(1.05,15.75) D29(1.75,15.75) D30(2.45,15.75) D31(3.15,15.75) D32(3.85,15.75) D33(4.55,15.75) D34(5.25,15.75) D35(5.95,15.75) D36(6.65,15.75) D37(7.35,15.75) D38(8.05,15.75) D39(8.75,15.75) D40(9.45,15.75) D41(10.15,15.75) D42(10.85,15.75) D43(11.55,15.75) D44(12.25,15.75) D45(12.95,15.75) D46(13.65,15.75) D47(14.35,15.75) D48(15.05,15.75) D49(15.75,15.75) D50(16.45,15.75) D51(17.15,15.75) D52(17.85,15.75) E1(-17.85,15.05) E2(-17.15,15.05) E3(-16.45,15.05) E4(-15.75,15.05) E5(-15.05,15.05) E6(-14.35,15.05) E8(-12.95,15.05) E9(-12.25,15.05) E11(-10.85,15.05) E12(-10.15,15.05) E14(-8.75,15.05) E15(-8.05,15.05) E17(-6.65,15.05) E18(-5.95,15.05) E20(-4.55,15.05) E21(-3.85,15.05) E23(-2.45,15.05) E24(-1.75,15.05) E26(-0.35,15.05) E27(0.35,15.05) E29(1.75,15.05) E30(2.45,15.05) E32(3.85,15.05) E33(4.55,15.05) E35(5.95,15.05) E36(6.65,15.05) E38(8.05,15.05) E39(8.75,15.05) E41(10.15,15.05) E42(10.85,15.05) E44(12.25,15.05) E45(12.95,15.05) E47(14.35,15.05) E48(15.05,15.05) E49(15.75,15.05) E50(16.45,15.05) E51(17.15,15.05) E52(17.85,15.05) F1(-17.85,14.35) F2(-17.15,14.35) F3(-16.45,14.35) F4(-15.75,14.35) F5(-15.05,14.35) F6(-14.35,14.35) F7(-13.65,14.35) F8(-12.95,14.35) F9(-12.25,14.35) F10(-11.55,14.35) F11(-10.85,14.35) F12(-10.15,14.35) F13(-9.45,14.35) F14(-8.75,14.35) F15(-8.05,14.35) F16(-7.35,14.35) F17(-6.65,14.35) F18(-5.95,14.35) F19(-5.25,14.35) F20(-4.55,14.35) F21(-3.85,14.35) F22(-3.15,14.35) F23(-2.45,14.35) F24(-1.75,14.35) F25(-1.05,14.35) F26(-0.35,14.35) F27(0.35,14.35) F28(1.05,14.35) F29(1.75,14.35) F30(2.45,14.35) F31(3.15,14.35) F32(3.85,14.35) F33(4.55,14.35) F34(5.25,14.35) F35(5.95,14.35) F36(6.65,14.35) F37(7.35,14.35) F38(8.05,14.35) F39(8.75,14.35) F40(9.45,14.35) F41(10.15,14.35) F42(10.85,14.35) F43(11.55,14.35) F44(12.25,14.35) F45(12.95,14.35) F46(13.65,14.35) F47(14.35,14.35) F48(15.05,14.35) F49(15.75,14.35) F50(16.45,14.35) F51(17.15,14.35) F52(17.85,14.35) G2(-17.15,13.65) G4(-15.75,13.65) G6(-14.35,13.65) G8(-12.95,13.65) G9(-12.25,13.65) G11(-10.85,13.65) G12(-10.15,13.65) G14(-8.75,13.65) G15(-8.05,13.65) G17(-6.65,13.65) G18(-5.95,13.65) G20(-4.55,13.65) G21(-3.85,13.65) G23(-2.45,13.65) G24(-1.75,13.65) G26(-0.35,13.65) G27(0.35,13.65) G29(1.75,13.65) G30(2.45,13.65) G32(3.85,13.65) G33(4.55,13.65) G35(5.95,13.65) G36(6.65,13.65) G38(8.05,13.65) G39(8.75,13.65) G41(10.15,13.65) G42(10.85,13.65) G44(12.25,13.65) G45(12.95,13.65) G47(14.35,13.65) G49(15.75,13.65) G51(17.15,13.65) H1(-17.85,12.95) H2(-17.15,12.95) H3(-16.45,12.95) H4(-15.75,12.95) H5(-15.05,12.95) H6(-14.35,12.95) H7(-13.65,12.95) H10(-11.55,12.95) H11(-10.85,12.95) H12(-10.15,12.95) H13(-9.45,12.95) H14(-8.75,12.95) H15(-8.05,12.95) H16(-7.35,12.95) H17(-6.65,12.95) H18(-5.95,12.95) H19(-5.25,12.95) H20(-4.55,12.95) H21(-3.85,12.95) H22(-3.15,12.95) H23(-2.45,12.95) H24(-1.75,12.95) H25(-1.05,12.95) H26(-0.35,12.95) H27(0.35,12.95) H28(1.05,12.95) H29(1.75,12.95) H30(2.45,12.95) H31(3.15,12.95) H32(3.85,12.95) H33(4.55,12.95) H34(5.25,12.95) H35(5.95,12.95) H36(6.65,12.95) H37(7.35,12.95) H38(8.05,12.95) H39(8.75,12.95) H40(9.45,12.95) H41(10.15,12.95) H42(10.85,12.95) H43(11.55,12.95) H46(13.65,12.95) H47(14.35,12.95) H48(15.05,12.95) H49(15.75,12.95) H50(16.45,12.95) H51(17.15,12.95) H52(17.85,12.95) J1(-17.85,12.25) J2(-17.15,12.25) J3(-16.45,12.25) J4(-15.75,12.25) J5(-15.05,12.25) J6(-14.35,12.25) J7(-13.65,12.25) J12(-10.15,12.25) J14(-8.75,12.25) J15(-8.05,12.25) J17(-6.65,12.25) J18(-5.95,12.25) J20(-4.55,12.25) J21(-3.85,12.25) J23(-2.45,12.25) J24(-1.75,12.25) J26(-0.35,12.25) J27(0.35,12.25) J29(1.75,12.25) J30(2.45,12.25) J32(3.85,12.25) J33(4.55,12.25) J35(5.95,12.25) J36(6.65,12.25) J38(8.05,12.25) J39(8.75,12.25) J41(10.15,12.25) J46(13.65,12.25) J47(14.35,12.25) J48(15.05,12.25) J49(15.75,12.25) J50(16.45,12.25) J51(17.15,12.25) J52(17.85,12.25) K2(-17.15,11.55) K4(-15.75,11.55) K6(-14.35,11.55) K8(-12.95,11.55) K12(-10.15,11.55) K13(-9.45,11.55) K14(-8.75,11.55) K15(-8.05,11.55) K16(-7.35,11.55) K17(-6.65,11.55) K18(-5.95,11.55) K19(-5.25,11.55) K20(-4.55,11.55) K21(-3.85,11.55) K22(-3.15,11.55) K23(-2.45,11.55) K24(-1.75,11.55) K25(-1.05,11.55) K26(-0.35,11.55) K27(0.35,11.55) K28(1.05,11.55) K29(1.75,11.55) K30(2.45,11.55) K31(3.15,11.55) K32(3.85,11.55) K33(4.55,11.55) K34(5.25,11.55) K35(5.95,11.55) K36(6.65,11.55) K37(7.35,11.55) K38(8.05,11.55) K39(8.75,11.55) K40(9.45,11.55) K41(10.15,11.55) K45(12.95,11.55) K47(14.35,11.55) K49(15.75,11.55) K51(17.15,11.55) L1(-17.85,10.85) L2(-17.15,10.85) L3(-16.45,10.85) L4(-15.75,10.85) L5(-15.05,10.85) L6(-14.35,10.85) L7(-13.65,10.85) L8(-12.95,10.85) L14(-8.75,10.85) L15(-8.05,10.85) L17(-6.65,10.85) L18(-5.95,10.85) L20(-4.55,10.85) L21(-3.85,10.85) L23(-2.45,10.85) L24(-1.75,10.85) L26(-0.35,10.85) L27(0.35,10.85) L29(1.75,10.85) L30(2.45,10.85) L32(3.85,10.85) L33(4.55,10.85) L35(5.95,10.85) L36(6.65,10.85) L38(8.05,10.85) L39(8.75,10.85) L45(12.95,10.85) L46(13.65,10.85) L47(14.35,10.85) L48(15.05,10.85) L49(15.75,10.85) L50(16.45,10.85) L51(17.15,10.85) L52(17.85,10.85) M1(-17.85,10.15) M2(-17.15,10.15) M3(-16.45,10.15) M4(-15.75,10.15) M5(-15.05,10.15) M6(-14.35,10.15) M7(-13.65,10.15) M8(-12.95,10.15) M9(-12.25,10.15) M10(-11.55,10.15) M43(11.55,10.15) M44(12.25,10.15) M45(12.95,10.15) M46(13.65,10.15) M47(14.35,10.15) M48(15.05,10.15) M49(15.75,10.15) M50(16.45,10.15) M51(17.15,10.15) M52(17.85,10.15) N2(-17.15,9.45) N4(-15.75,9.45) N6(-14.35,9.45) N8(-12.95,9.45) N10(-11.55,9.45) N14(-8.75,9.45) N18(-5.95,9.45) N22(-3.15,9.45) N26(-0.35,9.45) N27(0.35,9.45) N31(3.15,9.45) N35(5.95,9.45) N39(8.75,9.45) N43(11.55,9.45) N45(12.95,9.45) N47(14.35,9.45) N49(15.75,9.45) N51(17.15,9.45) P1(-17.85,8.75) P2(-17.15,8.75) P3(-16.45,8.75) P4(-15.75,8.75) P5(-15.05,8.75) P6(-14.35,8.75) P7(-13.65,8.75) P8(-12.95,8.75) P9(-12.25,8.75) P10(-11.55,8.75) P11(-10.85,8.75) P13(-9.45,8.75) P14(-8.75,8.75) P15(-8.05,8.75) P16(-7.35,8.75) P17(-6.65,8.75) P18(-5.95,8.75) P19(-5.25,8.75) P20(-4.55,8.75) P21(-3.85,8.75) P22(-3.15,8.75) P23(-2.45,8.75) P24(-1.75,8.75) P25(-1.05,8.75) P26(-0.35,8.75) P27(0.35,8.75) P28(1.05,8.75) P29(1.75,8.75) P30(2.45,8.75) P31(3.15,8.75) P32(3.85,8.75) P33(4.55,8.75) P34(5.25,8.75) P35(5.95,8.75) P36(6.65,8.75) P37(7.35,8.75) P38(8.05,8.75) P39(8.75,8.75) P40(9.45,8.75) P42(10.85,8.75) P43(11.55,8.75) P44(12.25,8.75) P45(12.95,8.75) P46(13.65,8.75) P47(14.35,8.75) P48(15.05,8.75) P49(15.75,8.75) P50(16.45,8.75) P51(17.15,8.75) P52(17.85,8.75) R1(-17.85,8.05) R2(-17.15,8.05) R3(-16.45,8.05) R4(-15.75,8.05) R5(-15.05,8.05) R6(-14.35,8.05) R7(-13.65,8.05) R8(-12.95,8.05) R9(-12.25,8.05) R10(-11.55,8.05) R11(-10.85,8.05) R14(-8.75,8.05) R15(-8.05,8.05) R16(-7.35,8.05) R17(-6.65,8.05) R18(-5.95,8.05) R19(-5.25,8.05) R20(-4.55,8.05) R21(-3.85,8.05) R22(-3.15,8.05) R23(-2.45,8.05) R24(-1.75,8.05) R25(-1.05,8.05) R26(-0.35,8.05) R27(0.35,8.05) R28(1.05,8.05) R29(1.75,8.05) R30(2.45,8.05) R31(3.15,8.05) R32(3.85,8.05) R33(4.55,8.05) R34(5.25,8.05) R35(5.95,8.05) R36(6.65,8.05) R37(7.35,8.05) R38(8.05,8.05) R39(8.75,8.05) R42(10.85,8.05) R43(11.55,8.05) R44(12.25,8.05) R45(12.95,8.05) R46(13.65,8.05) R47(14.35,8.05) R48(15.05,8.05) R49(15.75,8.05) R50(16.45,8.05) R51(17.15,8.05) R52(17.85,8.05) T2(-17.15,7.35) T4(-15.75,7.35) T6(-14.35,7.35) T8(-12.95,7.35) T10(-11.55,7.35) T14(-8.75,7.35) T15(-8.05,7.35) T16(-7.35,7.35) T17(-6.65,7.35) T18(-5.95,7.35) T19(-5.25,7.35) T20(-4.55,7.35) T21(-3.85,7.35) T22(-3.15,7.35) T23(-2.45,7.35) T24(-1.75,7.35) T25(-1.05,7.35) T26(-0.35,7.35) T27(0.35,7.35) T28(1.05,7.35) T29(1.75,7.35) T30(2.45,7.35) T31(3.15,7.35) T32(3.85,7.35) T33(4.55,7.35) T34(5.25,7.35) T35(5.95,7.35) T36(6.65,7.35) T37(7.35,7.35) T38(8.05,7.35) T39(8.75,7.35) T43(11.55,7.35) T45(12.95,7.35) T47(14.35,7.35) T49(15.75,7.35) T51(17.15,7.35) U1(-17.85,6.65) U2(-17.15,6.65) U3(-16.45,6.65) U4(-15.75,6.65) U5(-15.05,6.65) U6(-14.35,6.65) U7(-13.65,6.65) U8(-12.95,6.65) U9(-12.25,6.65) U10(-11.55,6.65) U11(-10.85,6.65) U14(-8.75,6.65) U15(-8.05,6.65) U16(-7.35,6.65) U17(-6.65,6.65) U18(-5.95,6.65) U19(-5.25,6.65) U20(-4.55,6.65) U21(-3.85,6.65) U22(-3.15,6.65) U23(-2.45,6.65) U24(-1.75,6.65) U25(-1.05,6.65) U26(-0.35,6.65) U27(0.35,6.65) U28(1.05,6.65) U29(1.75,6.65) U30(2.45,6.65) U31(3.15,6.65) U32(3.85,6.65) U33(4.55,6.65) U34(5.25,6.65) U35(5.95,6.65) U36(6.65,6.65) U37(7.35,6.65) U38(8.05,6.65) U39(8.75,6.65) U42(10.85,6.65) U43(11.55,6.65) U44(12.25,6.65) U45(12.95,6.65) U46(13.65,6.65) U47(14.35,6.65) U48(15.05,6.65) U49(15.75,6.65) U50(16.45,6.65) U51(17.15,6.65) U52(17.85,6.65) V1(-17.85,5.95) V2(-17.15,5.95) V3(-16.45,5.95) V4(-15.75,5.95) V5(-15.05,5.95) V6(-14.35,5.95) V7(-13.65,5.95) V8(-12.95,5.95) V9(-12.25,5.95) V10(-11.55,5.95) V11(-10.85,5.95) V13(-9.45,5.95) V14(-8.75,5.95) V15(-8.05,5.95) V16(-7.35,5.95) V17(-6.65,5.95) V18(-5.95,5.95) V19(-5.25,5.95) V20(-4.55,5.95) V21(-3.85,5.95) V22(-3.15,5.95) V23(-2.45,5.95) V24(-1.75,5.95) V25(-1.05,5.95) V26(-0.35,5.95) V27(0.35,5.95) V28(1.05,5.95) V29(1.75,5.95) V30(2.45,5.95) V31(3.15,5.95) V32(3.85,5.95) V33(4.55,5.95) V34(5.25,5.95) V35(5.95,5.95) V36(6.65,5.95) V37(7.35,5.95) V38(8.05,5.95) V39(8.75,5.95) V40(9.45,5.95) V42(10.85,5.95) V43(11.55,5.95) V44(12.25,5.95) V45(12.95,5.95) V46(13.65,5.95) V47(14.35,5.95) V48(15.05,5.95) V49(15.75,5.95) V50(16.45,5.95) V51(17.15,5.95) V52(17.85,5.95) W2(-17.15,5.25) W4(-15.75,5.25) W6(-14.35,5.25) W8(-12.95,5.25) W10(-11.55,5.25) W14(-8.75,5.25) W15(-8.05,5.25) W16(-7.35,5.25) W17(-6.65,5.25) W18(-5.95,5.25) W19(-5.25,5.25) W20(-4.55,5.25) W21(-3.85,5.25) W22(-3.15,5.25) W23(-2.45,5.25) W24(-1.75,5.25) W25(-1.05,5.25) W26(-0.35,5.25) W27(0.35,5.25) W28(1.05,5.25) W29(1.75,5.25) W30(2.45,5.25) W31(3.15,5.25) W32(3.85,5.25) W33(4.55,5.25) W34(5.25,5.25) W35(5.95,5.25) W36(6.65,5.25) W37(7.35,5.25) W38(8.05,5.25) W39(8.75,5.25) W43(11.55,5.25) W45(12.95,5.25) W47(14.35,5.25) W49(15.75,5.25) W51(17.15,5.25) Y1(-17.85,4.55) Y2(-17.15,4.55) Y3(-16.45,4.55) Y4(-15.75,4.55) Y5(-15.05,4.55) Y6(-14.35,4.55) Y7(-13.65,4.55) Y8(-12.95,4.55) Y9(-12.25,4.55) Y10(-11.55,4.55) Y11(-10.85,4.55) Y14(-8.75,4.55) Y15(-8.05,4.55) Y16(-7.35,4.55) Y17(-6.65,4.55) Y18(-5.95,4.55) Y19(-5.25,4.55) Y20(-4.55,4.55) Y21(-3.85,4.55) Y22(-3.15,4.55) Y23(-2.45,4.55) Y24(-1.75,4.55) Y25(-1.05,4.55) Y26(-0.35,4.55) Y27(0.35,4.55) Y28(1.05,4.55) Y29(1.75,4.55) Y30(2.45,4.55) Y31(3.15,4.55) Y32(3.85,4.55) Y33(4.55,4.55) Y34(5.25,4.55) Y35(5.95,4.55) Y36(6.65,4.55) Y37(7.35,4.55) Y38(8.05,4.55) Y39(8.75,4.55) Y42(10.85,4.55) Y43(11.55,4.55) Y44(12.25,4.55) Y45(12.95,4.55) Y46(13.65,4.55) Y47(14.35,4.55) Y48(15.05,4.55) Y49(15.75,4.55) Y50(16.45,4.55) Y51(17.15,4.55) Y52(17.85,4.55)
