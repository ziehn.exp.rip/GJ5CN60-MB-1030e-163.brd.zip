# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCIO: length 80.1
  TOP w0.203: U26.J27 U26.H27 ; v1(127.57,114.06) 127.13,114.06 126.97,113.89 U26.J15 U26.H15 ; U26.AG12 140.46,111.55 v1(140.33,111.57) ; U26.J26 U26.H26
  TOP w0.254: v1(127.46,122.76) 127.46,122.8 U26.J27 ; R262.2 117.47,131.12 v1(117.88,131.52)
  TOP w0.305: v1(99.14,163.91) 99.31,163.73 R3369.1 ; U26.H16 U26.H15 ; 129.02,97.53 135.6,97.53 v1(136.09,98.02)
  TOP w0.381: 129.02,97.53 124.15,92.66 118.82,92.66 116.66,94.82 116.66,102.82 117.04,103.2 R148.1
  L3_IN1 w0.381: v1(140.33,111.57) 127.59,111.57 127.33,111.84 ; v1(127.47,118.62) 127.47,118.63 128.05,119.21 128.05,122.39 127.68,122.76 v1(127.46,122.76)
  L6_IN2 w0.381: v1(136.09,98.02) 137.3,98.02 138.55,99.26 138.55,107.53
  L8_IN3 w0.508: v1(105.99,155.53) 105.99,156.54 99.14,163.4 v1(99.14,163.91)
  BOTTOM w0.254: R54.2 v1(117.88,131.52)
  vias: v1(125.86,119) v1(125.88,118.24) v1(125.88,117.43) v1(125.88,116.67) v1(125.88,115.09) v1(127.47,117.83) v1(127.45,117.2) v1(127.48,115.47) v5(108.53,150.45) v5(108.53,149.43) v5(108.53,148.42) v5(109.55,150.45) v5(109.55,149.43) v5(109.55,148.42) v5(115.65,137.24) v5(115.65,136.22)
+VCCRTCEXT: length 4
  TOP w0.254: U28.BF47 U28.BG47 128.51,15.02 129.11,14.42 129.11,11.97 C339.2
+VCCSA: length 4
  TOP w0.203: U26.L36 128.13,129.39 v1(127.81,129.71) 128.14,130.04 U26.L37 ; U26.M34 128.93,128.09 v1(128.6,127.76) 128.92,127.44 U26.M33 U26.M32 128.93,126.79 v1(128.6,126.46)
  TOP w0.508: v1(125.07,134.75) 125.17,134.85 R55.2
  vias: v1(121.11,133.43) v1(125.85,131.09) v1(125.85,130.53) v1(127.05,128.43) v1(127.05,127.77) v1(127.05,125.76) v1(127.81,127.11) v1(127.81,126.47) v1(128.49,131.13) v1(128.6,129.09) v5(166.5,138.92) v5(166.5,137.95) v5(166.5,136.99) v5(167.46,138.92) v5(167.46,137.95) v5(167.46,136.99) v5(168.43,138.92) v5(168.43,137.95) v5(168.43,136.99) v5(169.39,138.92) v5(169.39,137.95) v5(169.39,136.99)
AGND_+1.0VA: length 10
  TOP w0.254: 91.52,46.82 91.39,46.94 PJP13.1 91.08,47.76 90.73,48.11 90.73,49.02 90.59,49.15 88.9,49.15 87.45,47.7 R62.1 86.94,47.02 86.94,45.8 87.33,45.41 U17.4
AGND_+3.3VA: length 7.6
  TOP w0.305: v1(177.37,13.16) 177.41,13.2 177.54,13.2 177.79,13.45 U12.4
  TOP w0.508: v1(175.84,16.34) 176.02,16.51 C87.1
  BOTTOM w0.381: v1(175.84,16.34) 176.1,16.59 PJP11.1
  BOTTOM w0.508: v1(175.84,16.34) 175.83,16.32 175.83,14.19 176.86,13.16 v1(177.37,13.16) 177.93,13.16 R61.1
AGND_+5VA: length 9.8
  TOP w0.254: U9.4 189.18,97.8 R228.1 189.91,98.35 190.19,98.63 v1(190.27,98.63) ; v1(194.98,98) C1315.2 194.28,98.96 PJP5.1
  BOTTOM w0.254: v1(190.27,98.63) 190.52,98.38 194.44,98.38 194.82,98 v1(194.98,98)
AGND_VCCIO: length 12.1
  TOP w0.254: U18.4 99.01,161.62 98.4,162.23 R65.1 98.25,162.39 97.87,162.77 v1(97.74,162.77)
  TOP w0.305: C89.1 R3370.1 PJP15.1 104.98,162.94 104.67,162.64 v1(104.47,162.64)
  L6_IN2 w0.254: v1(104.47,162.64) 104.44,162.61 97.89,162.61 v1(97.74,162.77)
GND POWER: length 3052.6
  TOP w0.076: U26.BT8 162.9,108.71 163.15,108.46 163.8,108.46 164.09,108.18 v1(165.39,108.18)
  TOP w0.1: v6(66,118.08) 66,118.29 v6(66.56,118.86) ; v6(90.25,97.98) G1.BD26 ; G1.P51 69.55,115.98 69.22,116.31 69.22,116.65 69.34,116.77 69.34,117.77 70.22,118.66 v6(70.22,118.68) ; G1.AU51 85.58,115.85 85.58,117.05 86.94,118.41 87.93,118.41 88.3,118.78 v6(88.66,118.78)
  TOP w0.102: v1(89.61,84.66) 89.85,84.43 G1.BC6 ; 96.6,83.9 95.71,83.9 95.45,83.64 G1.BL5 ; v2(127.2,33.86) 126.68,34.38 U28.G44 ; U28.A8 109.26,37.59 109.3,37.55 109.3,37.37 109.32,37.35 109.32,37.01 109.29,36.98 109.29,36.33 U28.D8 ; v6(94.47,103.76) 94.48,103.74 ; U28.J40 124.81,33.53 U28.K39 124.27,32.99 124.27,32.64 v2(123.99,32.36) ; G1.T45 G1.T43 v6(70.95,109.48)
  TOP w0.111: v1(72.15,139.18) 72.2,139.23 M41.J10
  TOP w0.125: v1(37.8,96.31) 37.75,96.26 M46.J10
  TOP w0.127: U28.BA44 126.92,18.17 127.4,18.65 v2(127.56,18.65) ; 121.91,30.35 121.9,30.36 U28.R34 U28.N34 121.9,31.74 121.69,31.96 v2(121.36,31.96)
  TOP w0.13: v6(75.41,111.93) 75.15,112.19 G1.AB47
  TOP w0.15: v6(64.25,104.28) 63.95,103.98 G1.F34 ; v6(66.57,112.06) 66.57,112.56 v6(66.45,112.68) G1.K47 ; v6(64.25,110.48) 64.37,110.36 v6(64.9,110.36) ; v6(64.25,110.48) G1.F43 63.91,110.18 v6(63.6,109.87) 63.29,110.18 ; v6(64.25,110.48) 64.25,110.58 G1.F44 ; v6(66.5,113.44) 66.5,113.23 G1.K47 ; v6(85.94,113.28) 85.65,113.58 G1.AU49 ; 63.29,110.18 G1.D43 ; 63.29,110.18 63.65,110.54 v6(63.65,110.58) G1.F44 ; 62.9,116.13 62.9,117.78 ; v6(65.85,105.82) 65.69,105.98 G1.H37 ; v6(79.05,110.49) 79.03,110.49 79.35,110.8 G1.AH45 ; G1.F31 63.25,101.78 v6(63.1,101.93) 62.95,101.78 G1.D31 ; v6(63.59,120.02) 63.55,119.98 v6(63.55,119.3) 63.74,119.1 63.74,117.33 v6(63.95,117.13) ; G1.K47 v6(67.05,112.68) ; 66.75,84.88 G1.K8 66.57,85.85 v6(66.27,85.85) ; G1.AL49 81.45,114.28 ; G1.AY51 87.75,116.45 v6(87.9,116.6) ; G1.W49 73.21,114.22 v6(73.21,113.92) ; v6(72.73,113.35) 73.05,113.03 G1.W47 ; G1.K34 v6(67.45,103.88) ; G1.D13 62.25,88.88 v6(62.25,88.78) ; G1.AP45 83.55,110.91 v6(83.44,110.81) ; v6(64.86,82.05) 64.75,81.94 64.75,81.58 G1.G2 ; G1.K13 v6(67.45,89.18) ; G1.T10 v6(70.95,87.78) ; v6(65.8,102.03) 66.05,101.78 G1.K31 v6(67.45,101.78) ; G1.BC22 v6(89.15,95.48) ; v6(61.77,99.61) 61.95,99.79 62.44,99.79 G1.D28 62.71,99.85 v6(62.95,99.85) 63.42,99.38 v6(63.65,99.38) G1.F28 63.96,99.7 64.06,99.7 64.07,99.71 64.31,99.71 v6(64.49,99.88) ; v6(89.55,119.49) 89.43,119.61 87.64,119.61 87.27,119.24 86.62,119.24 86.28,118.9 85.68,118.9 ; v6(73.05,87.78) G1.W10 73.25,86.88 v6(73.25,86.58) ; v6(79.22,113.81) 79.35,113.68 G1.AH47 ; v6(62.95,81.18) 62.9,81.13 62.9,80.55 62.78,80.43 62.77,80.43 62.54,80.2 62.54,80.19 62.5,80.15 62.5,79.9 62.88,79.52 v6(62.94,79.45) ; G1.AB10 v6(75.15,87.78) ; G1.H31 64.66,101.78 64.37,101.49 v6(64.27,101.49) ; G1.H40 66,108.08 v6(66.15,108.23) ; 64.76,99.68 G1.H28 ; G1.AB43 v6(75.15,109.48) ; v6(71.28,111.94) 70.95,112.27 G1.T47 ; G1.K49 66.8,114.33 66.8,114.03 v6(66.95,113.88) ; v6(67.45,95.48) G1.K22 ; G1.BC37 v6(89.15,105.98) ; G1.BC19 v6(89.15,93.38) ; v6(77.25,87.78) G1.AE10 ; v6(83.55,109.48) G1.AP43 ; v6(65.65,97.28) G1.H25 v6(65.05,97.88) ; v6(75.45,86.08) 75.15,85.78 G1.AB8 ; G1.AU45 G1.AU47 ; G1.W43 v6(73.05,109.48) ; v6(72.75,111.28) G1.W45 73.3,111.84 v6(73.3,112.01) ; 81.45,114.24 81.63,114.06 v6(81.63,113.83) ; G1.AB8 75.28,85.55 v6(75.45,85.38) ; G1.AB8 v6(74.81,85.35) ; G1.BC31 v6(89.15,101.78) ; G1.D37 v6(62.25,106.28) 62.09,106.28 v6(61.64,105.82) ; v6(68.85,109.48) G1.N43 ; v6(64.54,79.08) 65.31,79.85 ; 85.68,118.9 85.68,117.99 84.95,117.26 v6(84.95,116.96) ; 85.68,118.9 v6(85.23,119.35) ; G1.AH2 79.23,81.36 ; v6(61.58,91.39) 61.81,91.62 62.21,91.62 G1.D16 ; G1.F44 63.6,111.23 63.6,111.95 v6(63.59,111.95) ; v6(65.81,99.86) 65.81,99.82 65.95,99.68 G1.K28 v6(67.45,99.68) ; v6(77.07,111.13) 77.07,111.4 G1.AE45 ; v1(79.7,80.27) 79.7,80.93 80.05,81.28 G1.AJ2 ; G1.AP10 v6(83.55,87.78) ; 83.55,112.31 G1.AP47 ; v6(63.09,97.78) 62.9,97.78 62.7,97.58 G1.D25 ; G1.BC28 v6(89.15,99.68) ; G1.AL10 v6(81.45,87.78) ; v6(67.45,91.28) G1.K16 ; v6(67.45,97.58) G1.K25 ; v6(67.45,108.08) G1.K40 ; v6(88.05,115.48) v6(88.05,114.68) G1.AY49 87.75,113.78 v6(88.15,113.38) ; G1.AU10 v6(85.65,87.78) ; v6(61.47,116.16) G1.C51 ; v6(79.35,87.78) G1.AH10 79.2,86.93 v6(79.2,86.64) ; G1.AL43 v6(81.45,109.48) ; G1.AB49 75.21,114.32 75.21,114 75.34,113.87 v6(75.34,113.83) ; G1.H1 65.31,80.74 65.31,79.92 ; G1.K19 v6(67.45,93.38) ; v6(83.25,113.28) 83.55,113.58 G1.AP49 ; G1.AH43 v6(79.35,109.48) ; G1.N10 v6(68.85,87.78) ; v6(77.25,109.48) G1.AE43 ; G1.BC34 v6(89.15,103.88) ; G1.K37 v6(67.45,105.98) ; 66.75,83.56 G1.K6 ; G1.BC13 v6(89.15,89.18) ; G1.BC16 v6(89.15,91.28)
  TOP w0.152: v1(147.36,102.65) 147.37,102.67 U26.AR1 U26.AR2 U26.AR3 ; v1(162.82,105.12) 162.82,105.16 162.62,105.36 U26.BT3 ; U26.N3 U26.N2 U26.N1 129.77,103.93 129.76,103.93 129.76,103.35 129.94,103.17 v1(129.96,103.17) ; U26.N3 129.87,105.37 v1(130.2,105.03) ; U26.N3 U26.N4 U26.N5 ; U28.D30 U28.E31 ; U28.E31 U28.C30 ; U28.E31 120.4,36 v2(120.87,36) U28.D33 ; U28.AJ30 v2(119.49,24.43) ; U28.AJ30 v2(120.26,23.66) ; U28.AJ30 v2(119.49,23.66) ; U28.AJ30 v2(120.26,24.43) ; v2(119.49,24.43) U28.AJ28 ; v2(119.49,24.43) U28.AG30 v2(120.26,24.43) ; v2(119.49,24.43) U28.AG28 ; U28.R29 119.51,30.66 v2(119.18,30.99) ; U28.BC35 122.6,16.73 v2(123.07,16.73) ; U28.AJ27 v2(118.71,23.66) ; U28.AJ27 117.94,24.43 ; U28.AJ27 118.71,24.43 ; v2(118.71,23.66) U28.AK28 v2(119.49,23.66) ; v2(118.71,23.66) U28.AK27 ; v2(118.71,23.66) U28.AJ28 ; v2(121.26,23.93) 121.58,24.25 U28.AH33 ; U28.AG1 105.39,24.69 v1(104.85,25.23) ; v2(117.94,27.53) U28.AA25 ; v2(117.94,27.53) U28.AB25 117.16,26.76 U28.AD25 117.16,25.98 U28.AF25 v2(117.16,25.21) ; v2(117.94,27.53) U28.AA27 v2(117.94,28.3) ; U28.AA25 v2(117.16,28.3) ; U28.AA25 v2(117.94,28.3) ; v2(120.26,23.66) U28.AJ31 v2(120.26,24.43) ; v2(120.26,23.66) U28.AK30 v2(119.49,23.66) ; v2(120.26,23.66) U28.AK31 ; U26.AC5 137.31,106.54 137.3,106.53 137.3,106.2 137.31,106.19 U26.AC4 ; U28.E8 v2(109.83,36) 110.3,36 U28.E10 ; U28.AT1 105.23,20.27 v1(105.23,20.27) ; v1(129.87,32.46) 129.87,32.47 U28.M49 ; U28.T49 129.68,30.24 v1(129.87,30.05) ; v1(105.1,26.5) 105.23,26.37 U28.AD1 U28.AD2 ; v2(117.16,28.3) v2(116.39,28.3) v2(115.61,28.3) U28.AA20 ; v2(117.16,28.3) U28.W25 v2(117.94,28.3) ; U28.AE46 127.61,25.32 v2(127.69,25.24) ; U28.AJ28 118.71,24.43 ; U28.AJ28 v2(119.49,23.66) ; v2(119.4,34.24) 119.4,34.14 U28.J29 ; v2(120.7,35.42) 120.82,35.42 120.82,35.41 121.04,35.41 U28.E33 ; U28.AG25 117.94,24.43 ; U28.AG25 v2(117.16,25.21) ; U28.AG25 117.16,24.43 ; 117.94,24.43 U28.AG27 ; 117.94,24.43 U28.AJ25 ; U28.A8 109.26,37.76 109.31,37.81 109.31,38.33 109.64,38.66 v2(109.65,38.66) ; v1(118.82,38.08) 118.83,38.08 U28.A28 ; v1(132.72,105.05) 132.4,105.37 U26.T3 ; v1(130.05,22.58) 129.96,22.49 U28.AM49 ; 107.92,31.73 107.92,32.13 U28.M5 ; U26.AC4 137.43,106.02 v1(137.75,105.69) ; U26.AC4 U26.AC3 U26.AC2 137.31,104.67 137.32,104.67 137.31,104.54 U26.AC1 v1(137.31,103.52) ; U26.AJ3 U26.AJ2 U26.AJ1 v1(142.34,103.57) ; U26.AJ3 142.66,105.04 v1(142.78,105.04) ; U26.AJ3 U26.AJ4 U26.AJ5 U26.AJ6 ; U28.BG33 121.42,14.75 v1(121.61,14.56) ; U28.E35 122.52,35.48 v2(122.61,35.4) ; U28.R38 v2(123.99,31.27) ; U26.BE3 154.91,105.24 154.9,105.23 154.9,104.85 154.91,104.84 U26.BE2 154.91,104.59 154.9,104.58 154.9,104.2 154.91,104.18 U26.BE1 154.91,103.94 154.9,103.93 154.9,103.56 v1(155.35,103.1) ; v1(132.73,103.1) 132.28,103.56 132.28,103.97 132.28,103.97 U26.T1 U26.T2 U26.T3 ; U28.BC24 116.89,16.73 v2(116.42,16.73) ; U28.BC13 v2(112.03,16.73) 112.5,16.73 U28.BC15 ; U26.BH2 U26.BH3 U26.BH4 U26.BH5 ; 118.71,24.43 U28.AG28 ; 118.71,24.43 U28.AG27 ; v2(117.16,25.21) U28.AG23 117.16,24.43 ; 117.16,24.43 U28.AJ25 ; U28.AJ25 v2(117.16,23.66) U28.AK25 ; U28.N35 v2(122.47,32.36) U28.M34 ; U28.M24 116.65,32.19 v2(116.28,31.83) ; v2(114.88,32.21) 115.01,32.21 115.07,32.27 U28.M21 ; U28.BG37 123.62,14.78 v1(123.46,14.61) ; U28.AB19 v2(114.84,27.53) ; v2(114.84,27.53) U28.AA20 ; v2(114.84,27.53) U28.AA19 ; U28.AG28 v2(118.71,25.21) ; v2(120.26,27.53) U28.AA30 v2(119.49,28.3) ; v2(120.26,27.53) U28.AB31 ; v2(120.26,27.53) U28.AA31 ; U28.U38 123.97,29.73 v2(123.6,30.1) ; U28.M32 120.9,32.29 121.23,31.96 v2(121.36,31.96) ; v2(114.84,23.66) U28.AK19 v2(114.84,22.88) U28.AK20 ; v2(114.84,23.66) U28.AK20 ; v2(114.84,23.66) U28.AJ20 ; U28.AK4 108.02,23.07 v2(108.03,23.07) 108,23.04 108,22.44 107.79,22.23 107.79,21.69 107.5,21.39 U28.AP4 ; U28.W27 v2(117.94,28.3) ; v2(119.49,28.3) U28.W28 ; v2(119.49,28.3) U28.W30 ; v2(119.49,28.3) U28.AA28 ; v1(127.69,105.04) 127.37,105.37 U26.K3 ; v2(118.71,25.21) U28.AF28 v2(118.71,25.98) ; v2(118.71,25.21) U28.AG27 ; v1(113.68,14.46) U28.BG17 ; U28.AC33 v2(121.59,27.49) ; U26.K3 127.25,105.49 127.24,105.5 127.24,105.88 127.25,105.89 U26.K4 ; U26.K3 U26.K2 U26.K1 127.25,103.47 v1(127.47,103.25) ; U26.W3 134.94,105.37 135.24,105.06 v1(135.24,105.04) ; U26.W3 U26.W4 U26.W5 ; U26.W3 U26.W2 134.8,104.59 134.79,104.37 U26.W1 134.79,103.5 v1(135.24,103.13) ; U28.AJ20 U28.AG22 v2(115.61,25.21) U28.AF22 v2(115.61,25.98) U28.AD22 ; U28.AJ20 v1(115.61,23.66) U28.AK20 ; U28.AL17 113.48,23.55 v2(113.33,23.75) 113.46,23.75 113.52,23.81 U28.AH17 ; U28.AA5 107.54,27.93 107.4,27.69 v2(107.42,27.64) 107.42,27.49 107.49,27.42 U28.AC4 ; U28.P29 120.11,31.43 v2(120.11,31.44) ; U28.AA20 v2(115.61,27.53) ; U28.Y38 123.55,28.78 v2(123.52,28.78) ; v2(117.37,34.12) 117.37,34.09 117.74,33.72 U28.J26 ; v2(127.69,27.49) 127.61,27.42 U28.AC46 ; v1(140.27,105.01) 139.97,104.71 U26.AF2 ; U26.AE6 139.2,107.32 139.39,107.13 139.39,106.64 139.82,106.21 U26.AF4 U26.AF3 U26.AF2 ; U28.U33 v2(121.58,28.93) 121.58,28.93 U28.Y33 ; U28.R26 v2(117.54,30.67) ; U28.U15 U28.U17 ; U28.AE33 v2(121.59,25.24) ; v1(119.72,14.67) 119.6,14.67 119.23,15.04 U28.BG28 ; U26.T3 U26.T4 U26.T5 ; U28.N37 v2(123.23,32.36) ; U28.AA49 129.64,28.05 129.86,28.26 v1(129.88,28.26) ; U28.V22 v2(115.61,29.08) U28.V20 ; v1(105.33,22.61) 105.45,22.49 U28.AM1 ; U26.AF2 U26.AF1 139.82,103.76 v1(140.07,103.51) ; U26.BB6 U26.BB5 152.4,106.54 152.38,106.53 152.38,106.15 152.4,106.14 U26.BB4 152.4,105.89 152.38,105.88 152.38,105.5 152.4,105.49 U26.BB3 U26.BB2 152.4,104.57 152.4,104.57 152.4,104.2 152.4,104.2 U26.BB1 152.4,103.92 152.4,103.92 152.4,103.55 v1(152.84,103.1) ; U28.V4 107.49,29.61 v2(107.41,29.69) ; v1(121.42,38.18) U28.A33 ; U28.AD49 v2(129.87,26.37) ; U28.P26 v2(118.68,31.43) ; U26.AW5 U26.AW4 U26.AW3 U26.AW2 U26.AW1 149.88,103.45 v1(150.3,103.03) ; U28.J48 128.5,33.65 U28.J47 128.11,33.67 127.71,34.06 127.41,34.06 v2(127.2,33.86) 127.29,33.86 U28.J46 ; U28.A37 123.62,38.66 v1(124.03,39.07) ; v2(123.99,32.36) U28.N38 ; v2(107.72,26.27) 107.72,26.24 107.72,26.24 107.72,26.02 U28.AE4 ; v2(114.25,16.97) 114.41,16.81 U28.BC19 ; U28.AT21 v2(114.83,20.47) ; v2(130.25,24.84) 130.1,24.69 U28.AG49 ; v2(127.71,31.96) 127.71,31.91 127.61,31.81 U28.P46 ; U28.V46 127.61,29.44 127.77,29.6 v2(127.77,29.6) ; U28.R16 U28.N16 U28.M16 113.56,32.3 v2(113.87,31.96) 114.2,32.29 U28.M18 ; 114.06,25.98 U28.AD19 114.06,26.76
  TOP w0.2: v6(71.15,113.83) 71.1,113.83 v6(70.65,113.38) ; G1.B16 61.47,91.28 v6(61.58,91.39) ; 64.76,99.68 64.61,99.68 64.49,99.8 v6(64.49,99.88) ; G1.AE4 77.1,82.73 v6(77.1,82.46) ; v6(62.95,116.08) 62.9,116.13 ; v6(70.85,115.28) 70.85,114.98 v6(70.55,114.68) 70.65,114.68 G1.T49 ; v6(85.92,111.16) 85.92,111.3 G1.AU45 85.35,111.28 85.35,111.22 v6(85.37,111.19) ; G1.F37 64.26,106.29 v6(64.28,106.29) ; G1.AN4 G1.AN5 ; v6(66.91,115.32) 66.81,115.41 66.81,115.71 G1.K51 ; G1.AH10 79.44,87.08 79.75,86.77 v6(79.75,86.68) ; 62.9,117.78 62.27,118.41 62.27,120.33 64.12,122.18 v1(64.12,122.93) ; G1.K4 66.54,83.08 v6(66.54,83.35) 66.75,83.56 ; v6(60.2,84.73) 60.52,85.05 61.07,85.05 G1.B7 ; v6(67.05,85.98) G1.K8 ; 66.75,84.88 v6(67.05,84.58) G1.K6 ; 64.65,106.66 64.65,106.66 64.68,106.66 64.68,106.66 65.02,106.32 65.03,106.32 65.03,106.28 65.04,106.3 v6(65.06,106.3) ; G1.B52 v6(60.82,116.81) ; 83.74,112.05 83.67,112.12 83.55,112.25 83.55,112.31 ; v6(62.95,104.16) 62.99,104.16 ; G1.B5 v6(60.85,83.28) ; v6(63.51,103.72) 63.43,103.72 ; v6(64.83,104.05) 64.48,104.05 v6(64.25,104.28)
  TOP w0.203: U26.G9 125.57,109.24 v1(125.24,109.57) ; v1(157.23,103.33) 157.68,103.78 U26.BH1 157.68,104.46 U26.BH2 157.48,104.71 157.8,105.04 v1(157.87,105.04) ; U26.AL4 U26.AK4 142.78,105.57 v1(142.78,105.04) ; v1(154.04,110.94) 153.76,111.23 U26.BC12 U26.BC13 U26.BC14 ; U26.BH8 156.84,109.03 v1(156.79,109.03) ; U26.BH8 U26.BH7 157.24,107.5 U26.BH6 ; U26.BH8 U26.BH9 U26.BH10 U26.BH11 U26.BH12 157.38,111.23 v1(157.7,110.9) 158.07,111.27 U26.BJ12 ; v1(126.72,108.22) 126.46,107.96 U26.J7 125.99,107.96 U26.G8 U26.F8 124.92,108.45 v1(124.59,108.78) 124.27,109.1 U26.E9 ; v1(126.72,108.22) 127.13,108.63 U26.K8 127.08,108.69 127.08,109.21 U26.K9 127.09,109.34 127.09,109.87 U26.K10 ; v1(126.72,108.22) 126.97,107.98 U26.K7 ; U26.D18 123.36,116.01 123.36,115.87 U26.C17 122.66,115.16 122.66,115.12 122.63,115.09 122.63,115.08 v1(122.64,115.08) ; v2(108.15,36.27) 107.85,36.58 U28.C5 107.31,36.86 U28.C4 ; G1.BJ7 94.29,84.74 v1(94.44,84.74) ; U26.D16 123.36,114.43 123.35,114.43 122.97,114.05 U26.C15 123.28,113.58 v1(123.28,113.52) ; 123.36,109.57 U26.C9 122.97,109.1 v1(122.64,108.78) ; 123.36,109.57 123.36,109.69 123.62,109.94 U26.D10 ; 123.36,109.57 U26.D9 ; U13.19 153.37,150.81 153.3,150.74 152.74,150.74 152.25,151.23 C1196.2 ; v1(122.91,105.39) 122.89,105.41 122.4,105.41 U26.B3 122.24,105.32 U26.A3 ; v1(122.91,105.39) 123.4,105.39 U26.D3 123.76,105.57 123.79,105.57 U26.E4 124.38,106.02 124.42,105.97 124.8,105.97 124.84,106.02 U26.F4 ; v1(122.91,105.39) 122.91,104.88 U26.C2 ; U26.BB6 152.51,107.32 v1(152.84,106.99) 152.91,106.99 U26.BC6 U26.BD6 154.19,107.32 v1(154.52,106.99) 154.59,106.99 U26.BE5 154.91,106.54 154.9,106.53 154.9,106.15 154.91,106.14 U26.BE4 154.91,105.89 154.9,105.88 154.9,105.5 154.91,105.49 U26.BE3 155.03,105.37 v1(155.35,105.04) ; U26.BB6 152.01,107.7 152.01,107.72 U26.BA7 U26.BA8 U26.BA9 ; U26.BB6 U26.BA6 ; 125.15,105.04 v1(125.22,105.04) ; 125.15,105.04 U26.F3 ; 125.15,105.04 U26.F2 124.82,104.79 124.76,104.85 124.76,105.23 124.82,105.29 U26.F3 ; v1(145.81,109.03) 145.87,109.03 U26.AP8 145.83,108.19 145.83,107.84 145.69,107.7 U26.AN6 145.74,107.26 U26.AN5 145.42,106.34 v1(145.25,106.34) 144.92,106.67 U26.AM5 ; v1(145.81,109.03) 146.05,109.28 U26.AP9 ; v1(145.81,109.03) v1(145.81,109.67) ; U26.AW3 150,105.37 150.3,105.06 v1(150.3,104.35) ; U26.AT6 148.61,107.72 148.76,107.72 U26.AU7 ; U26.N8 U26.N7 129.81,107.72 129.77,107.67 U26.N6 ; U26.N8 129.41,109.03 129.35,109.03 v1(129.35,109.67) 129.75,109.28 U26.N9 U26.N8 ; U26.G10 125.28,109.67 125.28,109.6 v1(125.24,109.57) ; v1(141.24,111.54) 141.42,111.36 141.43,111.36 141.56,111.23 U26.AH12 ; U28.G6 108.42,34.11 v1(108.29,33.98) ; v1(121,114.76) 121.09,114.76 121.17,114.68 U26.A16 ; U26.G5 125.68,106.67 v1(126.01,106.34) ; U26.G5 125.47,106.81 U26.F5 ; U26.G5 125.61,106.74 125.55,106.79 125.55,107.17 125.61,107.23 U26.G6 ; v1(162.94,106.96) 162.84,106.88 U26.BT5 ; U28.A5 U28.A4 U28.A3 U28.A2 106.09,38.08 v2(105.87,38.31) ; U7.43 23.52,55.76 ; 23.52,55.76 v1(23.52,55.76) ; 23.52,55.76 23.12,56.16 U7.42 ; G1.BL34 95.15,103.88 v6(95.01,103.74) 94.48,103.74 ; v6(63.55,113.38) G1.E48 v6(63.55,113.98) ; U26.AG11 140.42,110.94 v1(140.33,110.94) 140.17,111.09 140.14,111.09 140.01,111.23 U26.AF12 U26.AF13 U26.AF14 ; U26.AW5 149.48,107.06 149.3,107.06 U26.AU6 149.01,107.35 U26.AU7 ; U26.BM13 159.69,112.02 v1(159.37,111.7) ; U28.C25 117.55,36.51 U28.E26 118.6,35.93 v2(118.68,36) ; U26.Y8 U26.Y9 U26.Y10 U26.Y11 135.12,110.58 135.03,110.48 135.02,110.48 v1(134.84,110.3) ; U26.Y8 134.89,109.03 v1(134.84,109.03) v1(134.84,109.67) ; U26.Y8 U26.Y7 135.55,107.72 135.96,107.72 136.07,107.62 136.17,107.62 U26.AB6 U26.AC6 ; U26.BD12 U26.BD11 U26.BD10 U26.BD9 U26.BD8 ; v1(162.9,106.02) 162.77,106.08 U26.BT4 ; U26.BR21 U26.BT21 163.07,118.39 v1(163.4,118.06) ; U26.H12 126.29,111.46 126.29,110.82 U26.H11 126.22,110.73 125.93,110.44 v1(125.93,110.34) ; U26.AD8 137.64,109.03 v1(137.58,109.03) ; U26.AD8 U26.AD7 ; U26.AD8 U26.AD9 U26.AD10 U26.AD11 U26.AD12 137.87,111.23 v1(137.58,110.94) ; v1(137.58,110.94) 137.3,111.23 U26.AC12 136.99,111.36 136.35,111.36 U26.AA12 ; v1(137.58,110.94) 137.58,110.93 v1(137.58,110.3) ; v1(126.01,106.34) 125.68,106.02 U26.G4 U26.F4 ; v1(126.01,106.34) 126.09,106.34 U26.J4 U26.K4 127.25,106.14 127.24,106.15 127.24,106.53 127.25,106.54 U26.K5 ; C1193.2 117.88,156.29 118.69,156.29 118.75,156.35 U11.19 ; v1(145.81,110.94) 146.1,111.23 U26.AP12 ; v1(145.81,110.94) 145.53,111.23 U26.AN12 145.1,111.49 144.7,111.49 U26.AM12 144.18,111.49 143.79,111.49 U26.AL12 143.18,111.57 v1(143.07,111.57) ; v1(145.81,110.94) 145.81,110.31 v1(145.81,110.3) v1(145.81,109.67) ; v1(145.81,110.94) 145.91,110.94 U26.AP11 ; U26.N6 129.88,107.32 v1(130.21,106.99) 130.53,107.32 U26.P6 ; U26.N6 U26.M6 ; U26.N6 129.73,107.28 129.73,106.71 U26.N5 ; U26.AU7 U26.AU8 148.61,109.03 v1(148.56,109.03) v1(148.56,109.67) v1(148.55,110.3) 148.73,110.48 148.75,110.48 148.84,110.58 U26.AU11 ; v1(108.29,33.98) 107.81,33.5 107.52,33.5 U28.J4 ; v1(108.29,33.98) 108.65,33.98 108.94,34.27 U28.H8 ; v1(115.67,14.61) 115.87,14.81 U28.BG22 ; U26.AL8 U26.AL7 143.22,107.67 143.03,107.67 142.93,107.57 142.59,107.57 U26.AJ6 U26.AH6 U26.AG6 ; U26.AL8 143.48,108.63 v1(143.07,109.03) ; U26.AL8 U26.AL9 U26.AL10 143.33,109.93 v1(143.09,109.69) ; U26.T9 132.11,109.59 v1(132.1,109.67) ; U26.BH6 157.43,107.22 157.39,107.18 157.39,106.8 157.43,106.76 U26.BH5 ; U26.BH6 U26.BG6 U26.BF6 U26.BE6 ; U26.BH6 157.52,107.32 v1(157.85,106.99) 157.94,106.99 U26.BK6 U26.BL6 159.44,106.98 159.64,106.98 U26.BM6 159.9,107.24 v1(160.27,107.62) 160.27,108.08 U26.BN7 ; v2(109.6,30.41) 109.04,30.97 v1(109.04,31.35) ; U26.F3 124.93,105.47 U26.F4 ; v1(120.99,116.37) 121.11,116.26 U26.A18 ; U26.A3 121.66,105.05 121.46,104.85 v1(121.4,104.85) ; U26.A3 U26.A4 ; U26.AU10 U26.AU11 ; U26.AU11 U26.AU12 149.33,110.91 149.62,110.91 U26.AW12 150.08,111.08 150.69,111.08 U26.AY12 151.13,110.94 v1(151.3,110.94) ; U26.A12 121.06,111.53 v1(120.88,111.71) ; C1195.2 142.24,156.06 142.65,156.06 142.85,156.26 142.85,156.27 U10.19 ; U26.AG7 U26.AG8 ; v1(123.8,106.24) 123.6,106.24 123.03,106.81 U26.C5 122.53,107.24 122.17,107.24 121.8,107.61 U26.A6 ; U26.A24 121.05,120.98 v1(120.88,121.14) ; v1(120.94,117.94) 121.05,117.83 U26.A20 ; U26.BN7 U26.BP7 U26.BR7 161.77,108.28 162.7,108.28 162.8,108.18 163.74,108.18 164.2,107.72 165.58,107.72 165.58,107.73 v1(165.84,107.73) ; U26.BN7 U26.BM7 159.94,108.4 159.94,108.69 U26.BM8 159.94,109.19 159.94,109.48 U26.BM9 ; U26.D14 123.52,113.11 122.97,112.55 U26.C13 122.97,112.25 v1(122.64,111.93) ; U26.BG13 U26.BG12 156.47,111.23 156.6,111.09 156.63,111.09 v1(156.79,110.94) ; v1(125.89,119.8) 125.88,119.8 125.57,120.11 U26.G23 ; v1(122.71,120.57) 122.71,120.45 U26.C23 123.36,120.59 123.36,120.73 U26.D24 ; v1(129.35,110.3) 129.49,110.3 129.81,109.98 U26.N10 ; v6(62.25,114.08) G1.D49 v6(62.25,114.68) ; U26.A22 121.05,119.41 v1(120.97,119.49) ; U26.F19 124.92,117.04 124.58,116.7 v1(124.58,116.65) ; U26.BK13 158.39,112.15 158.65,112.41 ; U26.F9 124.92,109.24 v1(125.24,109.57) ; U15.19 162.1,150.83 162.03,150.9 161.44,150.9 C1197.2 ; U26.AC5 137.31,106.79 137.29,106.8 137.29,107.18 137.31,107.19 U26.AC6 ; v1(147.81,105.04) 147.49,105.37 U26.AR3 147.36,105.38 147.36,105.88 147.37,105.89 U26.AR4 147.37,106.15 147.37,106.16 147.37,106.52 147.37,106.53 U26.AR5 ; U4.19 127.51,156.42 127.38,156.29 126.74,156.29 C1176.2 ; v6(76.95,113.28) G1.AE47 v6(77.54,113.28) ; U26.AE6 U26.AD6 138.12,107.32 v1(137.77,106.97) 137.65,106.97 U26.AC6 ; U26.AM4 144.85,105.94 144.79,105.88 144.79,105.5 144.85,105.43 U26.AM3 U26.AM2 U26.AM1 v1(144.85,103.52) ; U26.BD8 154.09,109.03 v1(154.04,109.03) ; U26.BD8 U26.BD7 ; G1.BF4 91.77,82.7 v6(91.77,81.99) ; S17.2 v1(183.21,162.39) ; v1(122.71,117.4) 122.71,117.3 U26.C19 123.06,117.04 123.36,117.35 123.36,117.58 U26.D20 ; U26.BA12 U26.BA11 U26.BA10 ; v1(24.97,59.77) 25.17,59.97 U7.7 ; U26.A9 U26.B9 122.31,109.1 v1(122.64,108.78) ; v1(133.76,156.54) 133.88,156.42 C1194.2 133.96,155.88 134.67,155.88 134.73,155.94 U6.19 ; 114.06,26.76 113.87,26.95 U28.AC17 ; v1(145.81,109.67) U26.AP10 ; U26.BL29 158.83,124.9 U26.BK29 157.99,125.3 U26.BJ30 ; S107.2 v1(42.49,49.48) ; U28.BG25 117.39,14.9 v1(117.39,14.61) ; G1.BL37 95.14,105.98 v6(95.01,105.85) 94.48,105.85 v6(94.47,105.86) ; v1(159.37,111.7) 159.37,111.77 U26.BL13 158.72,112.41 158.65,112.41 ; v1(159.37,111.7) 159.37,111.63 U26.BM12 159.69,111.23 v1(160.02,110.91) ; S106.2 40.97,49.23 41,49.26 v1(41,49.48) ; v6(64.25,87.38) G1.F10 v6(63.65,86.78) ; 158.65,112.41 158.39,112.67 U26.BK14 ; U26.AG10 140.41,110.3 v1(140.32,110.3) ; U26.A10 120.96,109.96 120.91,109.91 v1(120.91,109.9) ; v1(152.84,105.04) 152.51,105.37 U26.BB3 ; v1(115.49,35.39) 115.52,35.39 115.86,35.72 U28.E22 ; v1(125.24,110.35) 125.24,110.35 124.92,110.68 U26.F11 ; U26.AG29 140.8,124.22 v1(140.79,124.21) ; U26.A14 121.18,113.11 v1(121.12,113.17) ; U26.D22 123.36,119.15 123.36,119.02 U26.C21 122.72,118.87 v1(122.72,118.99) ; v1(122.64,108.78) 122.64,108.71 U26.C8 ; S109.2 v1(44.02,49.48) ; v6(69.14,111.88) G1.N45 68.6,111.83 68.6,112.11 68.61,112.11 v6(68.61,112.1) ; U28.AW4 v2(107.41,18.65) 107.6,18.33 U28.BA5 U28.BA6 ; v6(63.65,107.78) G1.F40 63.72,108.31 v6(63.48,108.31) ; S23.2 v1(55.19,172.93) ; v1(122.64,110.35) 122.97,110.68 U26.C11 122.97,111.01 123.48,111.53 U26.D12 ; U26.W5 134.79,106.82 134.3,107.32 U26.V6 U26.U6 132.81,107.63 132.81,107.72 U26.T7 U26.T8 132.15,109.03 v1(132.1,109.03) ; U26.F13 124.92,112.21 v1(125.22,111.9) 125.57,111.56 U26.G12 ; v6(85.94,113.28) G1.AU47 v6(85.35,113.28) ; v6(65.05,108.38) G1.H40 65.05,107.78 v6(65.02,107.78) ; S108.2 v1(39.45,49.48) ; G1.BH5 v1(93.03,83.89)
  TOP w0.25: M41.E3 v1(66.7,142.83) ; G1.C51 v6(62.15,115.48) ; M42.C1 94.9,134.42 v1(94.5,134.02) ; G1.J52 66.05,117.01 v6(65.98,117.08) 66,117.1 v6(66,118.08) ; v6(65.94,110.3) 65.86,110.22 65.83,110.25 ; v6(96.47,80.85) 96.47,81.16 G1.BM2 ; G1.BL31 95.09,101.78 ; G1.BE13 v6(90.95,88.88) ; G1.BK1 94.75,80.29 v6(94.82,80.22) ; G1.N43 68.85,110.23 68.68,110.4 v6(68.68,110.58) ; G1.A32 60.05,102.48 v6(60,102.43) ; G1.BD32 v6(90.25,102.18) ; G1.AF45 77.65,111.88 v6(77.55,111.88) ; v6(89.47,117.01) 89.58,117.12 90.26,117.12 v6(90.46,116.93) ; G1.F17 63.65,91.68 v6(63.65,91.63) 63.65,91.58 G1.F16 ; v6(65.06,106.3) 65.34,106.02 65.35,106.02 G1.H37 ; v6(63.61,88.86) 63.63,88.86 G1.F13 ; G1.B7 61.44,84.69 v6(61.55,84.69) ; v6(74.85,114.68) 74.75,114.68 G1.AA49 ; G1.AF5 77.66,83.29 v6(77.54,83.29) ; G1.E8 63.43,85.5 v6(63.43,85.24) ; G1.BD35 v6(90.25,104.28) ; v6(81.77,86.76) 82.15,86.39 G1.AM9 ; v6(75.45,86.78) G1.AB10 ; G1.F37 63.63,105.66 v6(63.62,105.66) ; G1.BG28 v6(92.35,99.98) ; G1.N4 68.65,83.08 v6(68.65,83.28) ; G1.AP6 v6(83.85,84.58) ; M43.R1 v1(42.95,108.96) ; G1.D24 62.26,97.17 v6(62.26,97.24) 62.26,97.28 62.29,97.31 62.29,97.33 G1.D25 ; G1.D13 62.7,89.33 62.95,89.33 v6(62.96,89.32) ; G1.G4 64.62,82.88 64.43,82.69 v6(64.43,82.44) ; G1.AH4 79.2,82.73 v6(79.2,82.48) 78.95,82.48 G1.AG3 78.94,81.89 v6(79.22,81.89) ; v6(72.75,111.28) v6(72.75,110.48) G1.W43 ; v6(62.92,82.56) 63.24,82.88 G1.E4 ; v6(66.47,114.73) 66.47,114.65 G1.K49 ; G1.A26 60,98.28 v6(59.95,98.33) ; G1.AH43 79.35,110.21 79.03,110.53 ; G1.G6 64.65,84.37 v6(64.94,84.67) ; G1.BL10 94.82,87.08 v6(94.69,86.95) 94.61,86.87 94.26,86.87 G1.BJ10 ; G1.E5 63.55,83.28 63.55,83.23 v6(63.57,83.21) ; v6(64.83,104.05) 65.18,104.05 G1.H34 65.35,103.9 65.57,104.13 65.6,104.13 v6(65.67,104.2) ; v6(93,85.31) 92.98,85.3 G1.BG7 G1.BF6 ; G1.G49 64.94,114.67 v6(64.94,114.78) ; v6(81.33,81.91) 81.37,81.87 81.45,81.79 G1.AL2 ; G1.K25 66.69,97.58 v6(66.38,97.27) ; G1.BJ42 v6(94.35,109.78) 94.35,109.88 G1.BJ43 ; v6(63.59,111.95) 63.92,112.28 G1.F46 ; v6(79.22,113.81) 79.22,114.26 G1.AH49 79.42,114.45 79.42,114.99 v6(79.26,115.15) ; G1.R52 70.25,116.88 v6(70.22,116.9) ; v6(66.57,112.06) 67.05,112.54 v6(67.05,112.68) ; G1.AY10 v6(88.05,86.78) ; G1.AW52 v6(87.35,116.78) 87.72,116.78 v6(87.9,116.6) ; G1.AK1 v6(80.75,80.33) ; G1.AP47 v6(83.25,113.28) ; G1.V52 v6(72.35,116.93) ; v6(88.15,113.38) G1.BA48 ; v6(72.75,82.58) 72.73,82.6 72.73,82.62 G1.W4 ; v6(61.7,103.73) 62.05,104.08 62.35,104.08 G1.D34 62.83,104.16 v6(62.95,104.16) ; v6(66.15,108.23) 66.6,108.23 G1.K40 ; v6(66.5,113.44) 66.94,113.88 v6(66.95,113.88) ; G1.D31 62.25,101.48 v6(62.15,101.48) G1.D30 ; G1.M52 v6(68.15,116.93) ; G1.BG42 v6(93.05,109.88) ; G1.BL40 95.1,108.08 v6(95.02,108.01) 94.85,108.18 v6(94.5,108.18) ; v6(62.17,116.92) 62.17,116.8 G1.C52 61.64,116.69 v6(61.64,117.23) ; G1.BC4 90,82.73 v6(90,82.03) 89.85,81.88 G1.BC2 ; G1.BH42 93.6,109.73 v6(93.62,109.88) ; G1.AP49 83.7,114.54 v6(83.7,114.79) ; G1.C5 v6(61.55,83.28) ; M44.R14 49.5,144.03 ; v6(62.18,85.27) 62.26,85.27 G1.D7 62.79,84.74 v6(62.96,84.74) ; v1(33.35,102.56) M46.R1 ; G1.F35 v6(64.25,104.28) ; G1.W49 v6(72.7,114.73) 72.36,114.38 G1.V49 ; G1.N10 69,86.93 v6(69,86.53) ; G1.AF1 v6(77.95,80.33) ; v1(59.5,134.83) M44.C1 ; G1.BL5 95.17,83.3 v6(95.17,83.27) ; M46.C1 v1(42.95,102.56) ; G1.AB43 74.96,110.37 v6(74.96,110.76) ; v6(79.2,112.55) 79.2,112.83 G1.AH47 ; G1.T51 70.95,115.38 v6(70.85,115.28) ; G1.D16 62.73,91.1 62.92,91.1 62.93,91.11 v6(62.93,91.11) ; G1.D12 v6(62.25,88.78) ; G1.G38 64.65,106.66 v6(64.28,106.29) ; v6(95.02,97.46) 95.14,97.58 G1.BL25 ; v6(74.85,82.58) G1.AB4 ; G1.BL43 v6(95,110.18) ; M44.A1 v1(59.5,133.23) ; G1.AP2 83.55,81.79 83.48,81.87 v6(83.45,81.91) ; v1(58.7,134.03) M44.C3 ; G1.AE43 77.55,110.48 v6(77.55,110.55) ; v6(70.55,114.68) G1.R49 ; G1.C29 61.77,100.31 v6(61.77,99.61) ; G1.A29 v6(60,100.38) ; G1.G51 G1.F52 v6(63.95,117.13) ; G1.D4 v6(62.25,83.18) ; G1.BD29 v6(90.25,100.08) ; G1.BH2 v6(93.65,81.18) ; 61.5,80.48 v6(61.55,80.48) ; G1.BL2 v6(95.9,81.03) ; G1.AA8 v6(74.87,86.1)
  TOP w0.254: U26.AR38 147.04,130.69 146.72,130.38 v1(146.72,130.38) ; U26.AJ13 142.92,111.57 v1(143.07,111.57) ; v6(61.7,103.73) 61.7,103.33 G1.C33 ; U26.AU9 148.62,109.67 v1(148.56,109.67) ; U26.BT14 162.46,113.05 163.18,113.05 163.63,112.6 v1(163.65,112.6) ; U26.BD10 154.13,110.3 v1(154.04,110.3) ; U26.BC34 153.33,128.09 v1(153.01,128.41) ; U28.BC26 118.52,17.2 v2(118.62,17.2) ; U26.AC37 137.34,130.36 v1(137.26,130.36) ; U26.BH12 157.1,111.23 156.82,110.94 v1(156.79,110.94) ; U26.Y14 135.17,112.53 v1(134.85,112.21) 135.18,111.88 U26.Y13 ; v1(132.51,127.77) 132.47,127.77 ; 132.47,127.77 132.47,127.77 U26.T33 ; 132.47,127.77 U26.T34 ; U26.AB34 137.22,127.74 ; 137.22,127.74 137.17,127.74 U26.AB33 ; 137.22,127.74 v1(137.24,127.74) ; U28.T4 107.24,29.87 v2(107.41,29.69) 107.69,29.97 U28.T5 ; U26.BH14 U26.BG14 U26.BG13 155.94,111.49 155.68,111.49 U26.BF12 ; U26.W12 134.22,111.39 133.63,111.39 U26.V12 133.33,111.23 133.17,111.39 132.72,111.39 U26.T12 132.39,111.23 v1(132.1,110.94) 131.93,110.94 U26.R12 131.38,111.49 130.99,111.49 U26.P12 130.47,111.49 130.07,111.49 U26.N12 129.64,111.23 v1(129.35,110.94) ; U26.AH36 141.65,129.39 v1(141.98,129.06) 141.67,128.74 U26.AH35 ; U26.BL22 159.04,119.12 v1(158.72,118.8) 158.39,119.13 U26.BK22 ; U26.N34 129.83,128.09 130.16,127.76 v1(130.17,127.76) 129.85,127.44 U26.N33 ; C3896.1 v1(75.64,65.87) ; U26.AY34 150.98,128.09 v1(150.65,127.76) 150.97,127.44 U26.AY33 ; U26.BP14 160.99,112.94 v1(161.32,113.27) 161.64,112.95 U26.BR14 ; v1(148.28,127.11) 148.28,127.12 148.61,127.44 U26.AU33 ; U28.K11 110.47,33.69 U28.J10 ; v1(154.58,125.82) 154.63,125.82 154.98,125.47 U26.BE30 ; v1(126.7,110.24) 127.01,109.93 U26.K10 ; v1(126.7,110.24) 127.04,110.58 U26.K11 ; v1(126.7,110.24) 126.42,109.96 U26.J10 ; U26.BN19 160.37,116.81 160.65,117.1 v1(160.65,117.2) ; U26.L29 U26.L30 128.21,125.46 128.56,125.82 v1(128.6,125.82) ; v1(103.48,94.31) 103.33,94.31 103.07,94.57 R2799.2 ; U26.BJ25 U26.BK25 158.39,121.49 v1(158.72,121.16) ; U26.BA10 151.5,109.67 v1(151.3,109.67) v1(151.3,109.03) 151.51,109.03 U26.BA9 ; U26.BN4 160.29,106.17 U26.BM3 159.72,105.6 U26.BM2 159.72,104.61 v1(159.81,104.52) 160.11,104.52 U26.BN2 ; U26.BB12 152.99,111.54 v1(153.12,111.54) 153.17,111.54 153.49,111.23 U26.BC12 ; U26.AW30 150.25,125.48 149.91,125.82 v1(149.86,125.82) ; v1(145.52,124.18) 145.53,124.2 U26.AN29 U26.AN30 ; G1.AP45 83.74,111.78 83.74,112.05 ; U26.BN14 160.34,112.91 v1(160.02,113.24) 159.69,112.91 U26.BM14 ; U26.P37 130.62,130.04 130.94,130.36 v1(130.96,130.36) 130.62,130.69 U26.P38 ; U26.BF33 155.69,127.44 v1(155.37,127.76) 155.37,127.8 155.66,128.09 U26.BF34 ; M43.J10 37.75,115.26 v1(37.8,115.21) ; U26.AE33 139.32,127.44 v1(139.65,127.77) 139.32,128.09 U26.AE34 ; U26.L34 128.14,128.09 v1(127.81,127.76) 127.88,127.76 U26.L33 ; R3382.1 C308.2 195.4,95.33 195.53,95.46 v1(195.55,95.46) ; U28.BC40 125.2,16.81 v2(125.27,16.73) 125.3,16.76 125.3,17.1 125.57,17.37 U28.BB41 ; v1(156.17,131.13) 156.17,131.08 U26.BG38 ; v1(154.04,109.67) 154.11,109.67 U26.BD9 ; v2(112.09,36.03) 112.19,35.93 U28.E15 113.04,35.93 U28.D16 ; v2(112.09,36.03) 111.78,35.72 U28.E13 ; v2(112.09,36.03) 111.94,36.18 U28.D12 111.34,36.6 U28.C12 ; v1(126.24,127.09) 126.29,127.09 126.63,127.42 U26.J33 ; v1(126.24,127.09) 126.53,126.79 U26.J32 ; v1(126.24,127.09) 125.94,126.79 U26.H32 125.42,127.21 v1(125.42,127.71) 125.44,127.73 125.44,128.4 125.77,128.74 U26.H35 ; U26.BA11 151.48,110.3 v1(151.3,110.3) ; U26.W33 134.58,127.44 v1(134.9,127.76) 134.83,127.76 U26.W34 ; v1(162.89,111.46) 162.73,111.3 U26.BT12 ; v6(81.22,83.84) 81.22,84.06 G1.AL6 81.45,84.37 v6(81.74,84.66) ; v1(151.31,112.22) 151,112.53 U26.AY14 ; v1(156.79,109.67) 156.98,109.67 U26.BH10 ; v1(1.85,114.63) 1.65,114.43 R867.2 ; U26.AU34 148.61,128.09 v1(148.28,128.41) ; U26.AA30 135.7,125.82 135.69,125.82 v1(135.69,125.82) ; v1(192.48,93.42) 192.37,93.31 U9.19 ; U26.T11 132.28,110.3 132.18,110.3 ; v1(53.28,139.15) 53.2,139.23 M44.J10 ; v1(129.35,110.94) 129.45,110.94 U26.N11 ; v1(129.35,110.94) 129.07,111.23 U26.M12 U26.M13 128.89,111.88 128.89,112.52 U26.M14 ; v1(100.35,163.88) 100.28,163.81 C3742.1 ; U26.E34 124.27,128.04 123.62,127.39 U26.D33 ; Q44.1 73.21,158.16 73.61,157.76 v1(73.74,157.76) ; v6(77.62,86.03) 77.25,86.41 G1.AE10 ; U26.BE29 154.98,124.54 154.72,124.29 v1(154.63,124.29) ; U26.AJ38 142.48,130.59 142.48,130.15 U26.AJ37 142.45,130.04 v1(142.77,129.72) ; U26.BA12 151.81,111.23 152.15,111.57 v1(152.21,111.57) ; v1(121.61,126.34) 121.66,126.29 U26.A30 ; v1(153.01,127.11) 153.34,127.44 U26.BC33 ; U26.BP25 160.66,121.21 v1(160.66,121.13) 160.34,120.81 U26.BN24 ; U26.AK30 143.17,125.45 143.54,125.82 v1(143.56,125.82) ; U26.AG30 U26.AG29 ; CNSSD1.15 142.82,39.32 142.82,39.32 v1(142.82,39.33) ; U26.BP29 160.99,124.63 v1(161.31,124.31) 161.64,124.64 U26.BR29 ; 95.09,101.78 v6(95.03,101.72) 94.97,101.66 v6(94.47,101.66) ; C3893.1 v1(74.37,65.87) ; U26.BP26 160.99,122.41 v1(161.31,122.74) ; C3892.2 76.71,61.5 v1(76.66,61.55) ; U26.A26 121.66,122.55 121.36,122.24 v1(121.36,122.18) ; U28.E17 113.95,35.72 v2(114.23,36) ; U26.AG13 140.9,111.88 v1(141.24,111.54) ; U26.AL33 144.03,127.44 v1(144.35,127.76) 144.35,127.84 144.09,128.09 U26.AL34 ; U28.E19 114.3,35.93 v2(114.23,36) ; U26.BR24 161.64,120.78 v1(161.29,121.14) 161.29,121.05 U26.BP24 ; v1(138.84,125.82) 138.82,125.82 U26.AD30 U26.AD29 ; PJP5.2 195.38,99.49 v1(195.55,99.32) ; U26.BM26 159.69,122.41 v1(159.99,122.71) ; U107.11 v1(75.01,63.58) ; v1(159.99,119.59) 159.69,119.89 U26.BM23 ; U26.BN20 160.04,117.3 v1(160.04,117.2) ; v1(154.04,110.94) 154.33,111.23 U26.BD12 ; U26.G26 125.57,122.62 v1(125.23,122.95) 125.23,123.03 U26.F27 125.17,123.6 125.17,123.78 125.52,124.13 U26.G28 ; U26.BM24 159.69,120.86 v1(159.99,121.16) 159.69,121.46 U26.BM25 ; U26.Y38 134.96,130.36 v1(134.9,130.36) 135.22,130.04 U26.Y37 ; U26.A3 121.56,105.32 v1(121.09,105.78) ; v1(156.78,110.3) 156.97,110.3 U26.BH11 ; 110.6,28.93 U28.Y12 ; U26.G20 125.24,117.51 v1(125.24,117.44) ; U26.AH34 141.59,128.09 ; 141.59,128.09 U26.AH33 ; 141.59,128.09 141.7,128.09 v1(141.98,128.37) ; v1(191.46,104.85) 191.34,104.98 C113.2 ; D62.3 108.99,173.94 v1(108.99,174.09) ; U28.E24 117.21,35.93 v1(117.42,35.72) ; v1(159.99,118.8) 159.69,119.1 U26.BM22 ; U26.BB29 U26.BB30 152.63,125.44 v1(153.01,125.82) ; v1(103.5,93.7) 103.48,93.68 R2800.2 ; U26.U37 132.9,130.04 132.57,130.36 v1(132.54,130.36) 132.58,130.4 132.64,130.4 U26.U38 ; U26.AG6 140.66,107.85 U26.AG7 ; v1(143.59,124.29) 143.17,124.7 U26.AK29 ; U28.BB43 126.38,17.37 v2(126.64,17.11) ; 132.18,110.3 U26.T10 ; 132.18,110.3 v1(132.09,110.3) ; U28.BB9 109.36,17.43 U28.BC8 109.55,17.01 v2(109.83,16.73) 109.9,16.81 U28.BC10 ; v1(122.63,124.54) 122.97,124.87 U26.C29 ; G1.AW46 v6(87.35,111.98) ; U28.H8 109.41,34.27 U28.J9 ; U26.BM29 159.69,124.64 v1(159.36,124.31) 159.04,124.63 U26.BL29 ; G1.BM3 96.49,82.18 v6(96.85,81.82) ; v1(80.85,59.64) 80.85,59.39 80.61,59.15 Q130.1 ; U26.AM37 144.42,130.36 v1(144.35,130.36) 144.35,130.4 144.64,130.69 U26.AM38 ; v2(126.64,17.11) 126.46,16.94 U28.BD43 126.46,16.19 U28.BE44 ; v2(126.64,17.11) U28.BC45 ; U26.BJ31 158.46,125.81 v1(158.52,125.81) ; v2(114.23,36) 114.05,36.18 U28.D17 ; U26.T13 132.68,111.88 v1(133,112.2) 132.68,112.53 U26.T14 ; v1(35.35,80.21) 35.6,80.21 M45.G10 ; v1(159.56,106.14) 159.56,106.35 U26.BM5 159.9,106.69 U26.BM6 ; U28.BC31 120.4,16.73 v2(120.87,16.73) ; U26.C8 122.97,108.25 U26.D6 ; v1(130.96,125.82) 130.96,125.78 131.31,125.44 U26.R30 U26.R29 ; v1(161.32,110.12) 161.64,109.8 U26.BR9 ; U26.BD38 154.12,130.69 153.8,130.37 v1(153.8,130.36) 154.12,130.04 U26.BD37 ; U26.AR37 147.04,130.04 v1(146.71,129.71) ; U26.BM28 159.69,123.98 v1(160.02,124.31) 160.34,124.63 U26.BN29 ; v1(136.09,124.29) 136.08,124.3 U26.AA29 ; R150.1 75.89,157.31 v1(76.28,156.92) ; v1(156.16,129.71) 156.49,130.04 U26.BG37 ; U26.AT30 U26.AT29 v1(147.89,124.23) ; U26.V30 U26.V29 133.68,124.79 v1(133.17,124.29) ; U26.BM9 159.49,109.93 159.49,110.31 U26.BM11 ; v1(127.69,106.99) 127.58,106.99 U26.K5 ; U26.F31 124.92,126.44 124.56,126.09 v1(123.93,126.09) 123.62,125.78 U26.D30 123.34,125.98 123.34,126.06 122.97,126.44 U26.C31 ; v6(94.47,99.56) 94.99,99.56 v6(95,99.58) 95.11,99.68 G1.BL28 ; U26.BP21 160.99,118.44 v1(161.33,118.78) 161.64,118.47 U26.BR21 ; U26.BR25 161.64,121.47 162.29,120.82 U26.BT24 162.65,121.11 v1(162.76,121.11) ; v1(137.26,131.01) 137.31,131.01 137.63,130.69 U26.AC38 ; C1419.1 99.59,86.13 98.75,85.3 v1(98.5,85.3) 95.76,85.3 G1.BL7 95.05,84.98 v6(94.9,85.13) ; v1(127.48,116.26) U26.J18 ; C3895.1 73.18,61.37 v1(73.35,61.55) ; v1(120.98,128.6) 121.06,128.52 U26.A34 ; C1418.1 99.19,83.9 v1(98.5,83.9) 96.6,83.9 ; R854.2 v1(188.01,105.84) ; v1(143.99,112.2) 143.67,112.53 U26.AL14 ; U26.BE6 154.91,107.65 154.58,107.98 U26.BD7 154.3,107.98 154.07,107.74 U26.BD6 ; G1.BF2 91.95,81.82 v6(91.77,81.99) ; G1.BG10 92.84,87.28 93.85,87.28 G1.BJ10 ; 113.18,30.32 113.2,30.33 U28.R16 ; M42.J10 88.2,139.23 v1(88.25,139.18) ; U26.BT29 163.37,124.69 v1(163.4,124.67) ; U26.AM4 144.89,106.02 145.04,106.17 145.08,106.17 v1(145.25,106.34) ; U26.AW29 150.25,124.62 v1(149.92,124.29) ; v1(126.95,130.51) 127.13,130.69 U26.K38 ; U26.AP33 146.64,127.77 v1(146.73,127.77) 146.72,127.78 146.63,127.78 U26.AP34 ; U26.AV38 149.41,130.69 149.08,130.36 v1(149.07,130.36) 149.39,130.04 U26.AV37 ; U26.BA38 151.76,130.69 v1(151.44,130.36) 151.76,130.04 U26.BA37 ; v6(96.09,80.47) 95.77,80.47 95.46,80.78 G1.BL1 ; v1(121.1,124.13) U26.A28 ; U17.19 v1(90.37,42) ; 194.13,85.55 v1(194.16,85.55) ; 159.69,123.01 159.69,123.02 ; 129.38,14.68 U28.BG48 128.88,15.18 U28.BF48 129.23,15.54 U28.BF49 129.74,15.03 v2(129.74,14.68) 129.74,14.68 129.38,14.68
  TOP w0.279: CN1.234 120.9,80.11 v1(120.32,79.53)
  TOP w0.3: G1.B40 61.55,108.08 v6(61.7,107.93) 61.98,108.22 62.41,108.22 G1.D40 ; G1.B2 v6(60.77,81.11) ; v6(79.05,110.49) 79.03,110.51 79.03,110.53 78.67,110.88 G1.AG44 ; G1.AU51 85.65,115.23 v6(85.57,115.16) 85.78,114.95 85.78,114.52 G1.AU49 ; G1.BB49 v6(89.45,114.08) ; G1.H31 65.6,102.03 v6(65.8,102.03) ; G1.AB47 75.15,113.01 v6(74.83,113.33) 75.33,113.83 v6(75.34,113.83) ; v6(81.58,115.31) 81.45,115.44 G1.AL51 ; G1.G51 64.65,115.53 v6(64.45,115.33) ; v6(84.95,116.96) G1.AT52 G1.AT51 ; G1.N47 68.67,113.16 v6(68.67,113.38) ; G1.B13 61.54,89.18 v6(61.71,89.01) ; G1.AB51 75.15,115.38 v6(75,115.23) ; v6(87.45,112.68) G1.AY47 ; G1.AB6 v6(75.45,83.98) ; v6(75.41,111.93) 75.41,111.84 G1.AB45 ; v6(90.46,116.93) 90.55,116.84 G1.BD52 ; G1.AE51 77.25,115.38 v6(77.1,115.23) 77.37,114.96 77.37,114.5 G1.AE49 ; v6(89.61,116.22) 89.61,116.02 G1.BC51 ; v6(64.95,91.53) 65.1,91.53 G1.H16 ; v6(64.25,84.68) G1.F7 ; G1.N2 68.85,81.83 v6(68.95,81.93) ; G1.AD44 v6(76.85,110.58) ; G1.H22 v6(65.65,95.78) ; G1.E51 v6(62.95,116.08) ; G1.B48 v6(60.85,113.98) ; G1.G6 64.9,84.03 v6(64.9,83.83) ; G1.N51 v6(68.85,115.3) 68.85,115.24 69.06,115.03 69.06,114.59 G1.N49 ; G1.B28 61.7,99.68 v6(61.77,99.61) ; G1.T4 70.76,82.69 70.76,82.27 v6(71.1,81.93) 70.95,81.78 G1.T2 ; G1.AL45 81.74,111.88 v6(81.74,111.89) ; G1.B37 61.48,105.98 v6(61.64,105.82) ; v6(81.05,112.68) G1.AK47 ; G1.AJ9 v6(79.75,86.68) ; v6(60.55,80.33) 60.7,80.33 G1.B1 ; G1.AL8 v6(81.15,85.98) ; G1.J17 66.2,91.83 v6(66.2,91.48) ; G1.AH2 79.35,81.76 v6(79.22,81.89) ; G1.D10 62.45,87.18 v6(61.9,87.18) ; G1.B31 61.49,101.78 v6(61.59,101.68) ; G1.AL47 81.14,113.28 81.14,113.31 v6(81.12,113.34) ; G1.K2 66.8,81.54 66.8,82.07 v6(66.66,82.22) 66.66,82.8 G1.K4 ; v6(63.55,97.31) 63.75,97.51 63.84,97.51 63.92,97.58 G1.F25 ; G1.F46 64.22,112.55 v6(64.34,112.55) ; v6(61.55,80.48) G1.C1 ; G1.J1 v6(66.05,80.33) ; G1.AY51 v6(88.05,115.48) ; v6(71.15,86.58) 71.45,86.58 G1.U9 ; G1.A3 v6(59.85,82.18) ; v6(73.25,86.58) 73.55,86.58 G1.Y9 ; v6(66.36,93.65) 66.36,93.77 G1.J20 ; v6(62.95,81.18) G1.E2 ; v6(74.85,114.68) G1.AB49 ; v6(61.7,103.73) 61.55,103.88 G1.B34 ; G1.F19 63.7,93.13 v6(63.56,93.13) ; v6(61.7,97.43) 61.55,97.58 G1.B25 ; G1.AP51 83.6,115.73 v6(83.6,115.33) ; G1.W2 v6(73.05,82.08) ; G1.D22 62.35,95.68 62.05,95.68 v6(61.7,95.33) 61.55,95.48 G1.B22 ; G1.AE6 v6(76.91,84.63) ; v6(79.26,115.15) 79.35,115.23 G1.AH51 ; G1.D19 62.41,93.52 61.98,93.52 v6(61.7,93.23) 61.55,93.38 G1.B19 ; G1.B43 61.55,110.18 v6(61.7,110.03) 61.92,110.26 62.47,110.26 G1.D43 ; G1.F34 63.79,103.72 v6(63.51,103.72) ; G1.T47 70.65,113.28 v6(70.65,113.38) ; G1.B10 v6(60.85,86.78) ; v6(65.81,99.86) 65.53,99.86 G1.H28 ; G1.T45 71.28,111.91 v6(71.28,111.94) ; v6(59.9,80.93) G1.A2 ; G1.W6 73.35,83.98 v6(73.35,83.88) ; G1.B46 61.55,112.28 v6(61.7,112.13) 61.98,112.42 62.41,112.42 G1.D46 ; v6(72.75,85.38) G1.W8 ; G1.AB2 75.15,81.79 v6(75.25,81.89) ; v6(79.65,111.88) G1.AH45 ; G1.B51 v6(60.7,116.23) ; G1.H10 v6(65.05,87.38) ; G1.AE45 v6(77.55,111.88) ; G1.A51 v6(60.09,116.14) ; G1.AE2 77.25,81.84 v6(77.41,82) ; G1.AK44 v6(81.05,110.58) ; 66.01,110.38 v6(65.94,110.3) ; G1.H19 v6(65.05,93.68) ; G1.A50 v6(60,115.08)
  TOP w0.305: CNSSD1.71 156.82,39.35 157.66,40.19 v1(157.78,40.19) ; v1(161.15,91.19) 160.67,91.19 160.14,90.67 CN1.85 ; CN1.81 v1(161.14,88.04) ; v1(125.24,115.06) 125.24,115.15 U26.F17 ; CN1.61 166.14,91.34 v1(167.12,92.31) ; CN11.171 136.65,77.69 137.47,78.51 v1(137.47,78.51) ; CN1.47 v1(169.65,88) ; CN1.251 116.64,90.37 v1(116.94,90.66) ; v6(79.2,112.55) 79.2,112.42 79.65,111.97 v6(79.65,111.88) ; v1(156.92,69.68) 157.56,69.68 157.89,69.34 CN11.94 ; CN11.60 v1(166.4,66.97) ; v1(148.79,37.04) 148.82,37.06 CNSSD1.39 ; CN17.5 v1(107.85,7.27) ; CN1.213 126.15,88.23 v1(125.99,88.08) ; CN11.251 v1(116.65,74.94) ; U18.19 102.04,158.33 v1(102.18,158.19) ; v1(164.74,77.75) 165.15,77.34 CN11.65 ; v1(82.9,18.39) 82.95,18.35 CNWLAN1.13 ; CN11.168 137.4,66.98 v1(137.37,66.96) ; v1(121.23,91.39) 120.64,90.8 CN1.235 ; CN1.89 v1(159.14,86.97) ; CNSSD1.45 150.32,39.44 v1(150.52,39.65) ; CN11.188 v1(132.4,69.44) ; v1(129.15,72.3) CN11.201 ; v1(159.35,115.63) 159.69,115.98 U26.BM18 U26.BN18 160.67,115.7 v1(160.67,115.63) 160.99,115.96 U26.BP18 161.13,115.89 161.5,115.89 U26.BR18 161.97,115.7 v1(161.97,115.64) 162.29,115.96 U26.BT18 ; CN11.231 v1(121.65,74.77) ; CN1.18 v1(176.89,82.38) ; v1(155.53,83.37) 154.9,82.73 CN1.106 ; CN11.10 178.89,69.14 178.84,69.19 178.84,70.7 v1(179.39,71.25) ; v1(156.98,77.82) 157.93,77.82 158.14,77.61 CN11.93 ; v1(118.03,72.88) 118.65,73.49 CN11.243 ; v1(95.83,18.37) 95.45,17.98 CNWLAN1.63 ; G1.W51 73.05,115.49 v6(72.84,115.28) ; U26.G18 125.57,116.14 v1(125.3,115.87) ; v1(133.94,79.1) 134.63,79.1 135.39,79.86 CN1.176 ; v1(122.73,90.51) 123.38,90.51 123.64,90.24 CN1.223 ; CN1.5 180.14,87.82 v1(179.21,86.89) ; CN11.102 v1(155.9,66.91) ; U26.E35 124.32,128.74 v1(124.64,128.43) 124.28,128.07 U26.E34 ; v1(169.99,77.73) 169.65,77.38 CN11.47 ; v1(156.99,78.63) 157.85,78.63 159.14,77.34 CN11.89 ; v1(155.56,82.63) 155.9,82.3 CN1.102 ; v1(127.66,77.7) 127.84,77.7 128.15,77.4 CN11.205 ; CNWLAN1.33 87.95,18.1 v1(87.96,18.11) ; v1(124.38,82.96) 124.54,82.96 124.9,82.6 CN1.218 ; G1.K16 66.55,91.48 v6(66.2,91.48) ; v1(158.52,129.11) 158.41,129.11 U26.BJ36 ; CN1.1 181.14,87.98 v1(181.1,87.94) ; CN11.107 154.65,77.65 155.03,78.03 v1(155.77,78.03) ; v1(124.59,119.8) 124.92,120.13 U26.F23 124.93,120.19 v1(125.34,120.6) ; CN11.51 168.65,78.32 167.74,79.22 v1(167.74,79.22) ; CN1.185 133.15,90.39 134.89,92.14 v1(137,92.14) ; U26.BN30 160.03,125.79 v1(160.03,125.87) 160.03,125.95 U26.BN31 ; v1(164.54,39.7) 164.54,39.7 164.54,39.45 164.32,39.23 CNSSD2.9 ; CNKB1.33 118.26,5.11 v1(118.08,5.29) ; v2(127.56,18.65) 127.61,18.7 U28.AW46 ; v1(146.73,126.47) 146.78,126.47 U26.AR32 ; CN11.23 175.65,75.28 v1(175.3,74.93) ; U26.F25 124.92,121.71 124.78,121.57 124.78,121.56 v1(124.59,121.38) ; v1(159.55,83.04) 159.38,83.04 158.9,82.55 CN1.90 ; CN11.64 v1(165.4,66.96) ; CN11.22 v1(175.9,66.94) ; U26.AR34 147.06,128.09 v1(146.73,127.77) ; CN1.247 v1(117.64,88.06) ; v1(166.01,78.31) 166.38,78.31 167.15,77.55 CN11.57 ; v1(180.52,66.88) 180.89,67.26 CN11.2 ; U28.E42 125.55,35.72 v2(125.27,36) 124.8,36 U28.E40 ; U28.E42 126.1,35.37 U28.F43 ; U28.E42 125.57,35.56 U28.F41 ; CN1.31 173.65,86.86 174.23,86.27 v1(174.63,86.27) ; v1(137,91.54) 135.11,91.54 134.15,90.58 CN1.181 ; CN1.244 118.39,79.78 118.38,79.76 118.38,79.74 117.99,79.35 v1(117.89,79.35) ; v1(167.33,39.58) 167.32,39.56 CNSSD2.21 ; CN1.180 134.39,83.7 v1(133.78,84.31) ; v1(167.02,90.68) 167.04,90.68 167.14,90.58 CN1.57 ; v1(162.88,75.06) 163.15,75.33 CN11.73 ; v1(164.12,90.78) 163.61,90.78 163.14,90.32 CN1.73 ; U26.BM38 159.55,130.92 v1(159.21,131.27) 158.84,130.9 U26.BL38 ; U26.H25 U26.J25 127.31,122.16 v1(127.34,122.16) ; v1(81.61,18.24) 81.45,18.08 CNWLAN1.7 ; v1(89.58,18.14) 89.45,18.01 CNWLAN1.39 ; CN42.4 175.42,7.27 v1(175.72,7.57) 175.92,7.37 CN42.3 ; CN1.93 158.14,90.49 157.44,91.19 v1(156.65,91.19) ; v1(126,91.32) 126.39,91.32 C3466.1 127.15,90.57 CN1.209 ; M42.R11 v1(87.3,144.43) M42.T10 ; v1(171.56,82.34) 171.39,82.17 CN1.40 ; U1.3 6.78,65.76 v1(6.81,65.74) ; U28.J10 110.29,34.22 v1(110.57,34.5) ; v1(161.8,78.35) 161.15,77.69 CN11.81 ; C3465.1 154.65,91.69 CN1.107 ; v1(164.2,86.19) 164.2,86.19 164.92,86.9 164.92,88.14 165.14,88.36 CN1.65 ; v1(168.81,39.37) 168.82,39.36 CNSSD2.27 ; CNSSD1.73 157.32,39.26 157.62,39.57 v1(157.82,39.57) CNSSD1.75 ; v1(153.29,39.75) 153.34,39.7 153.34,38.24 CNSSD1.57 ; v1(180.36,78.55) 180.38,78.55 181.15,77.78 CN11.1 ; CN11.234 v1(120.9,69.42) ; G1.AP43 83.44,110.28 v6(83.44,110.81) ; CN11.31 173.65,75.44 v1(173.24,75.04) ; U26.D26 123.62,122.51 v1(123.32,122.21) 122.97,121.86 U26.C25 ; CN11.19 v1(176.65,77.66) ; G1.AL43 81.45,110.25 81.11,110.58 v6(81.05,110.58) ; CN1.27 v1(174.65,88.08) ; v1(161.62,131.27) 161.7,131.19 U26.BR38 ; CN1.188 v1(132.39,82.4) ; CN11.90 158.9,69.24 v1(159.33,69.68) ; CN11.52 168.4,67.08 v1(168.57,66.91) ; U28.AN38 v2(123.99,21.47) ; v1(128.89,83.82) 128.74,83.82 127.9,82.98 CN1.206 ; CNSSD2.15 165.82,36.92 v1(165.68,36.78) ; v1(147.27,39.45) 147.32,39.4 147.32,39.27 CNSSD1.33 ; CNWLAN1.18 v1(84.2,10.59) ; M43.G10 36.15,115.61 v1(35.75,115.21) ; CN11.5 v1(180.15,77.75) ; CN1.103 155.65,88.36 155.94,88.07 v1(156.65,88.07) ; U26.BL14 159.04,112.94 v1(158.72,113.26) 158.39,113.59 U26.BK15 ; CN1.248 v1(117.39,82.34) ; M42.T10 v1(87.3,145.23) ; M42.T10 v1(88.1,145.23) ; CN11.227 122.65,77.57 v1(123.21,78.14) ; CNSSD1.9 141.32,36.3 v1(141.3,36.27) ; v1(179.15,78.42) 178.52,78.42 177.65,77.54 CN11.15 ; CN11.185 133.15,77.46 132.7,77.91 v1(131.99,77.91) ; v1(169.3,84.23) 169.29,84.23 168.4,83.33 CN1.52 ; v1(167.09,91.54) 167.34,91.54 168.65,90.24 CN1.51 ; CN11.56 167.4,67.19 v1(167.13,66.92) ; U26.BJ35 158.42,128.45 v1(158.52,128.45) 158.62,128.45 U26.BL35 ; CNWLAN1.45 90.95,18.18 v1(91.01,18.24) ; M41.D10 v1(73.1,143.63) M41.C11 ; M41.D10 v1(73.09,142.84) ; M41.D10 v1(72.15,143.23) ; CN1.193 v1(131.15,88.09) ; U26.BP12 160.99,111.35 v1(161.31,111.67) 161.31,111.63 U26.BR12 162,111.66 v1(162,111.69) 162.29,111.39 U26.BT12 ; CN1.189 132.15,87.28 132.94,86.48 v1(133.64,86.48) ; CN11.36 v1(172.4,66.88) ; v1(131.99,78.85) 131.15,78 CN11.193 ; CN1.205 128.15,88.17 v1(128.33,87.99) ; CN1.14 177.89,82.36 v1(178.78,83.24) ; CN1.60 166.39,82.26 v1(166.33,82.33) ; v1(131.55,74.84) 131.83,74.84 132.15,75.15 CN11.189 ; CNSSD2.33 170.32,39.41 v1(170.31,39.42) ; v1(123.34,131.13) 123.42,131.13 123.76,130.79 U26.D38 U26.E38 ; v1(147.03,124.14) 147.1,124.22 U26.AR29 U26.AR30 ; CN1.19 v1(176.65,88.07) ; v1(171.88,73.22) 171.88,74.6 172.65,75.37 CN11.35 ; CN1.184 133.39,82.14 v1(133.6,82.35) ; v1(96.9,18.72) 96.95,18.67 CNWLAN1.69 ; CNSSD2.45 v1(173.32,36.93) ; CN11.98 156.9,67.07 v1(156.75,66.93) ; CNWLAN1.51 92.45,18.07 v1(92.28,18.24) ; CNSSD2.57 176.32,37.06 v1(176.3,37.04) ; CN11.238 v1(119.9,66.82) ; v1(176.64,78.25) 176.64,78.75 175.9,79.49 CN1.22 ; v1(130.67,66.81) 130.4,67.08 CN11.196 ; v1(42.15,109.76) M43.R3 v1(42.95,110.56) M43.R4 ; CN11.77 162.15,75.01 161.2,74.07 v1(161.2,73.72) ; v1(51.38,55.83) 51.76,55.45 C355.2 ; CN11.27 174.65,77.72 173.95,78.41 v1(173.16,78.41) ; v1(98.63,18.82) 98.63,18.16 98.45,17.99 CNWLAN1.75 ; v6(83.7,114.79) 83.6,114.89 v6(83.6,115.33) ; U28.AC38 v2(123.88,27.49) ; CN1.23 175.65,90.51 v1(175.5,90.66) ; v1(171.38,77.83) 171.65,77.57 CN11.39 ; v1(67.5,146.03) M41.A3 v1(67.5,145.23) ; R219.1 63.3,57.31 v1(63.27,57.28) ; CN1.202 128.9,80.12 129.2,79.82 v1(130.08,79.82) 130.08,79.81 130.39,80.12 CN1.196 ; CN11.192 131.4,69.59 v1(130.88,70.1) ; v1(161.18,90.59) 161.93,90.59 162.14,90.37 CN1.77 ; CNWLAN1.57 93.95,18.35 v1(94.07,18.47) ; CNSSD2.3 162.82,39.26 v1(162.51,39.58) 162.32,39.39 162.32,39.01 CNSSD2.1 ; U28.AE38 123.88,25.5 v2(124.15,25.23) ; CN11.14 177.89,70.91 v1(177.02,71.78) ; CN1.69 164.14,88.2 v1(163.98,88.04) ; CNSSD1.51 151.82,39.43 151.82,39.68 v1(151.84,39.7) ; U28.AP46 127.61,20.93 v2(127.69,20.85) 127.41,20.57 U28.AT45 ; v1(134.44,71.07) 135.4,70.11 CN11.176 ; CN11.222 v1(123.9,69.48) ; U26.C27 122.97,123.4 v1(123.32,123.75) 123.32,123.83 U26.D28 ; CN11.167 137.65,75.26 v1(137.37,74.99) ; CN1.68 164.39,80.08 v1(164.14,79.82) ; CN1.86 159.9,82.06 v1(159.54,82.41) ; CN1.48 v1(169.39,82.34) ; v1(145.87,39.45) 145.82,39.4 145.82,39.27 CNSSD1.27 ; CN11.72 v1(163.4,66.95) ; CN11.103 155.65,74.93 v1(155.71,74.86) ; CN11.230 v1(121.9,69.49) ; CN11.99 156.65,75 v1(155.79,74.15) ; U26.AR13 147.06,111.88 v1(146.73,112.21) 147.05,112.53 U26.AR14 ; CN1.30 173.9,79.87 v1(173.98,79.78) 174.68,79.78 174.9,79.99 CN1.26 ; v1(157.09,82.57) 156.9,82.37 CN1.98 ; U28.AR38 v2(123.99,20.38) 124.03,20.35 124.03,19.64 124.27,19.39 U28.AV39 124.81,19.21 U28.AW40 ; v6(79.17,85.13) 79.17,85.51 G1.AH8 ; v6(83.74,112.09) 83.74,112.05 ; CN11.206 v1(127.9,69.45) ; CN1.231 121.64,90.4 121.36,90.68 v1(121.31,90.68) ; U26.AR31 146.78,125.82 v1(146.71,125.82) ; v1(125.29,113.46) 125.29,113.39 U26.G14 ; CN11.248 v1(117.39,69.41) ; CNSSD1.21 144.32,39.5 144.22,39.59 v1(144.09,39.73) ; U26.J18 U26.H18 ; CN11.213 126.14,73.72 v1(125.99,73.57) ; CN1.15 177.65,90.49 177.87,90.72 178.93,90.72 v1(178.96,90.68) 179.14,90.5 CN1.9 ; v1(157.09,83.21) 157.31,83.21 157.9,82.62 CN1.94 ; CN1.10 178.89,82.36 v1(178.78,82.48) ; v1(166.13,77.72) 166.15,77.7 CN11.61 ; CN1.171 136.64,88.29 v1(136.99,87.94) ; v1(124.61,124.54) 124.61,124.61 U26.F29 ; U26.AR36 146.78,129.07 v1(146.72,129.07) ; CN11.9 v1(179.15,77.74) ; G1.F31 64.24,101.49 v6(64.27,101.49) ; CN11.82 v1(160.9,66.98) ; CN11.44 v1(170.4,66.96) ; M41.C11 v1(73.9,144.43) M41.C12 ; M41.C11 v1(73.1,144.43) ; v1(125.97,90.7) 125.57,90.7 125.15,90.28 CN1.217 ; CN11.217 v1(125.15,78.96) ; CN1.44 170.39,80.14 170.06,79.81 v1(169.43,79.81) ; v1(164.47,78.42) 164.15,78.09 CN11.69 ; U26.AR35 146.79,128.43 v1(146.71,128.43) ; CN1.243 118.64,86.84 v1(117.71,85.91) ; CN11.244 v1(118.39,66.06) ; U28.AL38 v2(123.97,22.56) ; v1(116.8,79.53) 116.8,79.73 116.39,80.14 CN1.252 ; v1(121.02,83.73) 121.59,83.73 121.9,83.42 CN1.230 ; M43.N3 v1(41.35,109.76) ; CN1.56 167.39,83.59 166.78,84.21 v1(166.32,84.21) ; CN11.210 v1(126.9,69.43) ; U26.G23 125.36,120.4 125.36,120.47 125.34,120.49 v1(125.34,120.6) ; v1(137.45,79.81) 137.39,79.86 CN1.168 ; v1(125.34,120.6) 125.34,120.75 U26.G24 ; CN11.252 v1(116.39,69.98) ; v1(130.15,74.85) CN11.197 ; CN11.235 120.65,74.76 119.76,73.87 v1(119.67,73.87) ; U12.19 v1(181.05,16.43) ; CN11.181 134.15,77.63 134,77.78 v1(134,77.88) 135.33,77.88 135.65,77.57 CN11.175 ; CN11.218 v1(124.9,69.44) ; CN1.214 125.9,82.38 v1(125.95,82.43) ; C402.2 v1(62.74,59.39) ; v1(177.52,16.97) 177.6,17.05 C82.1 ; v1(124.37,82.35) 124.21,82.35 123.9,82.04 CN1.222 ; v1(124.59,118.23) 124.92,118.55 U26.F21 124.93,118.62 125.24,118.93 v1(125.24,119.01) 125.24,119.08 U26.G22 125.89,119.73 v1(125.89,119.8) 126.27,119.42 U26.H22 U26.J22 v1(127.47,119.41) ; CN11.184 133.4,67.25 v1(133.11,66.96) ; CN1.239 119.64,87.07 v1(120.33,86.39) ; CN11.247 117.65,77.56 v1(117.89,77.8) ; CN11.226 v1(122.9,69.42) ; CN11.85 160.15,75.46 160.06,75.37 160.04,75.37 159.22,74.56 v1(159.22,74) ; CN1.72 163.39,79.7 163.83,79.26 v1(164.42,79.26) ; CN1.175 135.64,90.41 136.12,90.89 v1(137,90.89) 137.55,90.33 137.64,90.24 CN1.167 ; CN11.18 v1(176.89,66.93) ; CN1.78 161.9,80.02 161.53,79.66 v1(160.95,79.66) 160.9,79.71 CN1.82 ; CN11.209 127.15,75.19 v1(127.05,75.1) ; U26.G16 125.57,114.61 v1(125.24,114.29) 125.24,114.22 U26.F15 ; U26.BJ14 157.74,112.92 v1(157.36,113.3) 157.73,113.67 U26.BJ15 ; CN1.238 119.9,79.95 v1(120.32,79.53) ; v1(170.06,78.38) 170.65,77.79 CN11.43 ; v1(174.83,36.93) 174.82,36.94 CNSSD2.51 ; M43.K13 v1(38.95,118.56) M43.K14 ; v1(165.62,79.67) 165.39,79.89 CN1.64 ; CN11.106 v1(154.9,66.96) ; CN11.30 v1(173.9,66.95) ; CN11.78 v1(161.9,66.85) ; v1(171.8,36.91) 171.82,36.92 CNSSD2.39 ; C1423.2 v1(61.99,57.24) ; U28.AK46 127.69,23.52 v1(127.69,23.05) ; CN1.36 172.39,80 171.4,79.01 v1(171.4,78.52) ; CN1.2 180.89,80.02 180.61,79.74 v1(180.39,79.74) ; G1.K22 v6(66.45,95.78) ; CN1.201 129.14,86.84 128.53,86.23 v1(128.37,86.23) ; v6(71.15,86.58) 71.15,86.88 G1.T10 ; U26.AR33 146.77,127.11 v1(146.71,127.11) ; CN1.227 v1(122.64,88.07) ; CN1.43 170.65,90.46 v1(170.5,90.61) 170.52,90.63 171.33,90.63 171.65,90.32 CN1.39 ; v1(84.9,142.83) M42.N14 ; CN1.172 v1(136.39,82.31) ; CNWLAN1.19 v1(84.45,15.87) ; CN1.226 v1(122.9,82.35) ; M43.T5 v1(43.75,111.36) ; CN1.6 v1(179.89,82.33) ; v1(123.65,77.71) CN11.223 ; CN11.40 v1(171.4,66.94) ; CN11.86 v1(159.9,66.95) ; CN11.172 v1(136.4,69.49) ; v1(132.42,83.75) 132.35,83.75 131.84,83.24 131.84,82.95 131.39,82.5 CN1.192 ; CNSSD1.3 139.82,36.45 v1(139.65,36.27) 139.62,36.27 139.32,36.58 CNSSD1.1 ; CNKB1.36 v1(116.76,5.38) ; v1(159.33,128.98) U26.BM35 ; CN11.6 v1(179.89,66.94) ; U28.AH38 v2(123.95,23.81) ; U26.BN12 160.02,110.98 v1(160.02,110.91) 160.02,110.81 159.72,110.52 U26.BM11 ; CN11.48 v1(169.4,66.92) ; CN11.68 v1(164.4,66.95) ; CN11.214 v1(125.9,69.42) ; CN11.26 v1(174.9,66.9) ; CN11.239 v1(119.65,75.19) ; v1(129.47,66.88) 129.2,66.88 128.9,67.19 CN11.202 ; v1(172.65,90.74) CN1.35 ; CN11.180 v1(134.4,69.43) ; CN1.210 126.9,83.38 128.35,84.83 v1(128.35,85.64) 128.89,85.64 129.62,86.37 129.62,87.75 130.15,88.28 CN1.197 ; v1(156.65,90.6) CN1.99
  TOP w0.356: CON3.A1 154.06,181.51 154.41,181.16 v1(154.91,181.16) ; v1(148.44,180.37) 148.55,180.49 CON3.A12
  TOP w0.381: 132.16,10.02 132.66,10.52 C320.1 ; 132.16,10.02 131.77,10.4 C284.1 ; 132.16,10.02 v1(132.16,10.01) ; R3310.2 71.07,44.28 v1(71.32,44.02) ; 86.08,145.63 85.7,145.25 v1(85.7,145.23) ; 86.08,145.63 M42.V12 ; 86.08,145.63 85.7,146.01 ; C255.1 v1(113.66,5.21) ; v1(95.55,139.2) 95.52,139.23 M42.J1 ; Q104.4 96.45,60.64 96.15,60.34 v1(95.96,60.34) ; M42.T5 v1(91.3,145.23) ; R2879.2 20.65,71.07 v1(20.52,70.95) ; R820.2 98.63,72.34 98.88,72.6 ; C256.2 79.35,38.04 v1(79.34,38.03) ; R30.1 193.67,136.1 194.59,137.01 v1(194.59,137.35) ; M44.T10 v1(53.1,145.23) ; M44.T10 v1(52.3,144.43) M44.R11 ; M44.T10 v1(52.3,145.23) ; v1(164.79,11.64) 164.22,12.21 Q48.S ; U16.8 v1(189.43,167.85) ; v1(57.1,141.23) M44.M5 56.3,142.03 v1(56.3,142.03) ; v5(4.65,74.25) 4.44,74.45 R252.1 ; C322.1 132.02,35.94 131.9,36.07 v1(131.85,36.07) ; v1(3.12,64.85) 3.3,64.85 3.68,64.47 R306.1 ; v1(161.47,100.31) 162.28,100.31 R24.1 ; R215.2 81.74,55.15 v1(81.74,54.94) ; R1912.1 v1(100.02,53.42) ; PJP3210.2 190.45,152.22 190.07,152.61 v1(189.81,152.61) ; M42.E3 93.3,136.04 v1(93.69,136.43) ; C1327.1 166.21,27.24 v1(166.45,27) ; v1(87.32,58.25) 87.32,57.75 C379.2 87.96,57.88 v1(87.96,58.25) ; C492.2 148.97,8.77 v1(148.67,8.46) ; v1(143.84,1.53) 143.84,1.6 144.18,1.94 CNDEG2.S2 ; C231.1 65.99,63.35 v1(66.5,63.86) ; C1367.2 12.04,65.03 v1(12.01,65.05) ; CN9.S2 170.3,4.83 v1(170.76,5.29) ; v1(59.5,143.63) M44.R1 59.9,144.03 ; v1(180.28,22.46) 180.29,22.46 180.31,22.48 R113.1 ; Q66.S 170.51,10.19 v1(170.48,10.21) ; R2781.1 v1(94.51,77.83) ; R357.1 71.5,35.46 71.96,35 72.82,35 v1(72.85,35.03) ; v1(88.85,52.66) 88.98,52.53 C252.2 C263.2 ; R433.2 117.17,131.98 v1(117.17,131.65) ; C145.2 190.93,102.95 v1(191.41,103.43) ; C259.2 175.26,24.41 v1(175.21,24.46) ; v1(130,12.61) 130.17,12.43 130.17,12.02 C324.1 ; U83.4 v1(102.92,78.82) ; C1318.1 140.54,27.26 v1(140.31,27.03) ; v1(102.4,49.01) v1(104.72,49.01) 104.98,49.27 104.98,51.35 v1(104.81,51.51) 104.98,51.68 104.98,53.62 104.71,53.89 v1(104,53.89) ; v1(102.4,49.01) 101.41,49.01 v1(101.17,49.25) 100.79,49.63 C247.2 ; v1(102.4,49.01) Y2.2 ; v1(94.48,143.62) 94.89,144.03 M42.R1 v1(95.3,144.43) 95.28,144.43 ; R359.1 186,157.69 186.26,157.43 v1(186.49,157.43) ; v1(72.47,39.45) 72.47,39.26 Q67.S ; v1(137.24,1.53) 137.24,1.6 137.57,1.94 CNDEG2.S1 ; v1(30.94,88.32) 31.73,88.32 32.27,87.77 Q64.S ; M41.K1 65.13,138.43 v1(64.96,138.26) ; 35.76,120.6 35.64,120.6 35.05,121.19 C884.1 ; v1(30.56,63.73) 30.07,64.21 R97.1 C130.1 ; v1(177.24,9.55) 177.29,9.6 C1272.2 ; C1419.1 99.77,86.57 v1(100.02,86.82) 100.15,86.95 v1(103.45,86.95) 103.83,86.57 103.83,82.52 103.56,82.25 v1(103.45,82.25) 100.46,82.25 v1(100.35,82.15) 99.77,82.73 C1418.1 ; 77.79,140.4 76.77,140.4 v1(76.6,140.23) 76.4,140.03 M41.H14 M41.H13 v1(74.7,139.63) ; Q53.E 53.48,167.78 v1(53.54,167.72) ; v1(6.55,65.1) 6.5,65.05 R304.1 ; M45.R14 v1(42.95,83.56) ; C1321.1 159.46,28.04 v1(158.93,27.51) 158.83,27.51 158.57,27.77 C1322.1 ; v1(148.54,21.92) 147.9,21.92 147.52,21.54 147.52,21.16 ; 98.88,72.6 v1(98.91,72.6) ; 98.88,72.6 98.25,73.23 R860.2 ; v1(182.96,134.06) 183.19,134.3 Q2.1 ; PJP13.2 92.07,48.26 v1(92.28,48.47) ; v1(93.8,46.18) 94.18,46.56 R1936.2 ; v1(20.67,64.52) 20.52,64.52 20.22,64.82 AB4.1 ; v1(29.16,83.52) 29.03,83.39 C1029.2 ; C221.2 131.52,30.31 v1(131.27,30.05) ; v1(98.01,60.86) 98.08,60.79 98.12,60.79 R2798.1 99.01,60.4 99.28,60.67 Q92.1 ; R307.1 v1(57.56,170.84) ; v1(74.7,134.83) M41.R12 v1(73.9,134.03) M41.R11 v1(73.1,134.83) M41.P10 ; v1(42.95,73.16) M45.R1 v1(42.95,73.96) ; C3558.1 26.67,46 v1(26.36,46.31) ; R56.1 v1(126.59,135.56) ; M46.B10 v1(43.75,95.36) ; C240.2 78.1,38.06 v1(78.07,38.03) ; C610.2 v1(61.75,177.19) ; 78.81,138.63 76.89,138.63 v1(76.3,138.03) M41.K14 v1(75.5,138.03) M41.K13 ; C260.1 110.04,10.71 v1(110.04,11.33) ; C137.1 v1(30.56,62.44) ; CN1.262 185.52,75.31 v1(185.65,75.44) ; v1(91.9,45.29) 91.82,45.29 C83.1 ; v1(49.9,135.63) M44.E14 48.9,136.03 v1(48.9,136.03) ; C925.2 61.69,142.09 v1(60.95,142.83) ; C86.1 104.09,160.1 v1(104.14,160.15) ; v1(80.67,37.98) 80.62,38.03 C258.2 ; v1(18.87,45.8) 19.25,46.18 C456.1 ; D61.3 112.02,173.25 111.58,173.69 v1(111.58,173.82) ; C432.2 57.47,158.7 v1(58.3,157.87) ; 36.78,70.56 37.64,70.56 37.74,70.46 49.31,70.46 49.41,70.56 50.62,70.56 57.86,77.8 57.86,84.08 v6(58.1,84.32) ; Q44.4 74.51,160.75 v1(75.01,161.24) 74.7,161.55 C452.2 ; v1(173.05,21.16) 172.54,21.16 172.26,21.44 JP1.2 ; C3635.1 75.13,56.85 v1(75.01,56.72) ; v1(54.36,67.52) 54.13,67.75 R896.1 ; R869.2 v1(6.5,108.21) ; M42.R12 v1(85.7,143.63) ; v1(77.55,57.86) 77.04,58.37 C3913.2 ; CN18.S2 v1(158.43,5.78) ; v1(19.51,70.95) 19.38,71.07 R954.2 ; CNWLAN1.77 78.85,14.64 v1(78.43,14.23) ; R901.2 54.43,69.42 v1(54.81,69.8) ; Q125.S 23.38,104.82 v1(23.04,105.16) ; v1(180.29,27) 179.91,27.38 C1329.1 ; v1(116.53,131.65) 116.53,130.64 117.17,130 R432.2 ; U31.1 118.06,170.9 117.42,171.54 v1(117.42,171.66) ; v1(189.05,134.7) 189.31,134.95 C2.1 ; v1(92.06,133.28) 91.72,133.63 M42.B5 ; C3634.1 113.94,125.12 114.6,125.78 v1(114.78,125.78) ; Q116.1 187.8,161.13 188.04,161.37 v1(188.54,161.37) ; R787.2 v1(101.68,77.8) ; ESD1.8 ESD1.3 v1(150.95,179.38) ; C654.1 191.77,143.97 v1(191.46,143.97) ; C311.2 59.29,62.77 58.83,62.31 v1(58.8,62.31) ; v1(185.88,160.35) 185.3,160.93 Q47.1 ; C926.2 47.13,132.4 48.47,132.4 v1(48.9,132.83) ; C292.2 169.11,9.22 v1(168.6,9.73) 168.22,9.35 C296.2 ; C1180.2 17.35,149.05 v5(17.09,149.3) ; v1(67.51,36.63) 67.77,36.88 C3583.1 ; R360.2 101.42,15.32 v1(101.55,15.45) ; v1(191.46,139.78) 191.34,139.91 190.48,139.91 190.21,139.64 Q3.4 ; CN18.3 152.6,8.84 v1(152.35,9.1) 152.02,8.77 C493.2 ; R14.1 v1(169.37,116.41) ; R12.1 v1(169.37,118.19) ; C445.2 28,163.34 Q182.E 26.87,162.72 v1(26.29,162.13) ; v1(113.41,11.1) 113.36,11.15 R442.1 ; v1(92.1,144.43) 92.1,144.43 M42.R4 v1(92.9,144.43) M42.R3 93.3,144.03 v1(93.7,144.43) ; C1028.2 31.62,85.01 v1(31.61,85) ; C669.2 79.07,156.82 v1(78.51,156.26) ; 190.96,99.27 190.96,98.45 C286.2 ; 190.96,99.27 v1(191.08,99.39) ; 190.96,99.27 R221.2 ; v1(35.75,99.28) 36.15,99.68 M46.L5 ; 185.04,103.29 185.37,103.29 185.75,102.91 v1(185.75,102.64) ; 185.04,103.29 C1237.2 ; 185.04,103.29 185.04,102.72 v1(185.16,102.59) ; C232.2 v1(36.01,38.93) ; 58.3,144.03 M44.R3 ; C129.2 v1(59.89,54.82) ; v1(67.39,165.41) 67.27,165.3 Q113.4 ; v1(29.92,58.12) 29.92,58.25 30.38,58.7 C172.1 ; C1441.2 66.66,57.6 v1(66.42,57.36) ; C1445.1 v1(85.55,77.04) ; v1(126.24,129.11) 126.52,129.39 U26.J36 ; M45.J10 37.75,80.26 v1(37.8,80.21) ; C339.1 129.23,10.37 128.98,10.11 128.75,10.11 v1(128.73,10.09) 128.73,10.11 128.35,10.49 C285.1 ; Q1.S 193.81,137.87 v1(194.13,137.87) ; v1(49.9,144.43) M44.R14 ; Q119.1 v1(37.14,34.75) ; U26.B37 123.07,129.97 U26.C37 123.11,129.97 123.39,130.25 v1(123.52,130.25) ; C431.2 61.62,170.08 v1(61.8,170.26) ; CN11.261 114.53,60.3 117.45,63.22 v1(117.75,63.22) ; v1(141.22,156.21) 141.58,156.21 C1195.2 ; R203.1 185.37,163.78 v1(185.75,164.16) ; CN18.S1 145.49,6.48 v1(145.49,6.94) ; C290.1 R96.1 95.2,24.34 v1(94.69,23.83) ; D60.3 113.99,173.64 v1(113.66,173.97) ; C248.2 v1(100.79,53.29) 100.79,53.51 101.17,53.89 v1(104,53.89) ; v1(107.77,77.3) 109.93,77.3 CN1.261 ; v1(104.85,27.66) 104.32,28.2 R340.1 ; D37.3 131,174.31 v1(131.01,174.32) ; C330.2 v1(89.99,65.61) ; v1(65.1,144.43) 65.5,144.03 M41.C1 v1(65.9,143.63) ; C2821.2 v1(18.36,107.83) ; U16.7 v1(190.7,167.85) ; Q128.1 93.56,65.5 93.8,65.74 93.96,65.74 v1(94.31,66.08) ; v1(97.76,46.31) 97.66,46.31 C332.2 ; R200.2 9.4,64.52 9.85,64.97 v1(9.85,64.97) ; v1(76.39,148.55) 76.13,148.29 C889.2 ; M41.A12 74.54,145.87 v1(74.54,146.16) ; Q96.3 76.42,50.1 77.37,49.15 C412.1 v1(77.37,48.47) ; v1(153.97,179.48) 153.87,179.38 ESD2.8 ESD2.3 ; v1(72.59,48.85) 72.59,48.59 72.97,48.21 C1427.2 ; C872.1 108.15,62.44 v1(108.28,62.31) ; R3204.2 108.53,74.17 108.15,74.55 v1(107.77,74.55) ; 8.33,74.12 8.53,73.92 C546.2 C1043.2 ; v1(88.14,50.12) 87.72,50.12 87.32,49.72 R3368.1 ; C1197.2 160.83,151.51 v1(159.99,151.51) ; R99.1 18.85,120.55 v1(19.28,120.98) 19.43,120.98 C1362.1 ; C965.2 50.13,146.62 v1(50.74,146.01) ; Q45.E 188.73,117.49 v1(188.54,117.3) ; v1(78.43,19.31) 79.95,17.79 CNWLAN1.1 ; v1(101.29,56.98) 101.29,57.23 102.06,57.99 R195.1 ; Q163.S v1(48.84,64.91) ; C1452.1 107.72,73.56 v1(107.83,73.68) ; v1(99.77,20.7) 99.85,20.78 100.28,20.78 R293.1 ; Q3.1 188.91,136.97 v1(188.67,136.73) ; v1(159.59,14.43) 159.79,14.23 C126.2 ; v1(95.55,138.23) 95.43,138.23 95.23,138.43 M42.H1 ; C297.2 153.36,15.18 153.11,15.44 v1(153.11,15.45) ; C254.2 v1(179.78,23.73) ; C1326.1 v1(163.7,27.69) ; C85.1 89.25,47.98 v1(89.36,48.09) ; v1(89.86,76.58) 89.48,76.2 R2836.2 ; v1(68.27,36.66) 68.66,37.04 R3308.2 ; Q99.3 v1(108.04,68.79) ; C3912.2 v1(73.15,58.68) ; v1(42.15,74.76) M45.R3 ; Q2.4 v1(184.49,137.89) ; Q4.1 96.1,64.33 v1(96.21,64.21) ; C1347.1 67.26,159.21 v1(67.26,157.43) ; v1(75.5,143.63) M41.C14 ; C435.1 v1(57.56,168.68) ; v1(116.66,173.56) 116.43,173.33 C3962.2 ; v1(177.11,161.24) 176.68,161.67 C4.2 ; R3247.1 93.78,7.85 v1(94.3,7.85) ; v1(95.3,135.63) M42.E1 ; v1(101.68,81.11) 101.42,81.36 R792.2 ; R11.1 v1(169.24,122.89) ; R835.2 3.89,103.33 v1(4.14,103.08) 4.77,103.71 C673.2 ; C4114.2 v1(174.95,158.19) ; M42.V14 84.5,145.65 ; C3847.2 7.11,65.31 6.81,65.61 v1(6.81,65.74) ; v1(95.55,140.08) 95.5,140.03 M42.K1 M42.K2 ; C181.2 186.12,111.85 v1(185.5,112.47) 185.27,112.47 C1236.2 184.76,113.14 v1(185.37,113.74) ; v1(93.74,138.8) 94.1,138.44 M42.H2 ; v1(14.25,104.47) C1371.2 15.12,105.11 Q139.S ; C1328.1 180.8,27.51 v1(181.3,27) ; v1(38.93,120.74) 38.55,121.11 37.54,121.11 37.24,121.42 R2716.2 ; R544.2 v1(59.08,174.5) ; R3333.2 C3551.2 27.33,37.6 v1(27.25,37.67) ; v1(128.56,99.34) 128.54,99.31 R2.1 ; C3464.1 172.86,92.36 v1(172.6,92.1) ; Q116.4 v1(186.5,158.05) ; CNSSD1.MTG77 158.92,39.29 v1(158.95,39.32) ; v1(65.9,146.03) M41.A1 ; v1(170.51,17.35) 170.89,17.35 171.53,16.72 C3631.1 ; C1374.2 92.28,62.06 v1(92.02,62.31) 92.02,62.56 92.26,62.8 Q128.4 ; v1(99.57,3.93) 99.67,3.83 CN19.S1 ; v1(89.23,159.21) 89.2,159.24 C529.2 ; v1(37.29,49.36) 37.97,48.67 CN30.U9 ; v1(100.02,52.4) C359.2 ; v1(17.98,106.51) 18.68,105.81 Q126.S ; C298.2 v1(154.63,15.45) ; v1(25.35,108.41) 25.09,108.66 R957.1 ; R35.2 v1(186.12,114.24) ; Q113.1 65.97,161.69 C393.2 ; D38.3 133.16,174.19 v1(133.3,174.32) ; v1(68.3,142.03) 68.3,142.01 68.68,141.63 M41.F5 v1(69.1,141.23) ; C4115.2 v1(176.73,158.07) ; v1(75.5,134.03) M41.R14 v1(76.3,134.03) ; R283.1 v1(2.56,66.93) ; R836.2 v1(9.47,108.03) ; C136.1 v1(30.56,61.55) ; C1425.2 68.58,56.85 68.66,56.77 68.66,56.67 v1(68.68,56.65) ; v1(171.65,19.38) 171.65,18.99 R189.2 ; R217.1 v1(187.15,164.04) ; C15.2 v1(174.75,161.67) ; C3989.2 183.97,164.29 v1(183.84,164.16) ; U16.5 v1(193.24,167.97) ; Q92.4 101.94,59.37 102.28,59.03 v1(102.62,59.03) ; R183.1 102.46,55.32 v1(102.18,55.6) ; CNKB1.S2 135.26,1.28 v1(135.2,1.22) ; CNSSD2.MTG76 161.22,39.56 v1(161.24,39.58) ; v1(179.4,160.23) 179.69,160.23 180.01,160.54 Q30.S 181.16,159.54 C436.2 ; C353.2 R337.2 v1(53.85,54.26) ; v1(151.43,151.39) 151.59,151.23 C1196.2 ; v1(135.2,15.07) C280.1 R285.1 ; C267.2 96.16,46.33 v1(96.34,46.15) ; C120.2 v1(188.6,113.42) ; C46.1 v1(143.2,7.06) ; CN30.9 37.97,41.91 v1(37.03,40.97) ; R948.2 v1(15.32,106.81) ; R4.1 127.94,100.86 127.74,101.05 v1(127.74,101.05) ; R945.2 v1(13.03,115.52) ; M42.C1 94.91,134.43 v1(95.34,134) ; Q16.1 171.61,23.03 v1(171.91,23.32) ; M42.H13 v1(84.9,138.03) M42.H14 84.05,138.43 v1(83.9,138.28) ; v1(84.88,144.41) 84.5,144.03 M42.R14 ; CN42.S1 v1(178.92,6.27) ; R816.2 v1(95.45,77.8) ; v1(114.25,135) 114.36,134.89 C173.2 ; v1(96.93,55.73) 96.82,55.73 96.01,56.54 C264.2 ; 47.69,143.24 48.04,143.24 v1(48.45,142.83) ; CN19.S2 93.16,1.48 93.17,1.48 v1(93.17,0.61) ; v1(13.44,71.68) 13.73,71.39 Q124.S ; v1(114.5,2.37) 114.18,2.05 CNKB1.S1 ; C295.2 92.58,58.7 91.98,59.3 v1(91.97,59.3) 91.74,59.07 Q20.E ; C281.1 v1(135.2,16.46) ; v1(68.4,63.86) 68.67,63.59 C1440.2 ; CNSSD1.MTG76 v1(138.22,35.67) ; M42.F5 v1(92.1,137.23) M42.G5 ; C3463.1 164.01,92.36 v1(164.09,92.28) ; v1(13.16,66.91) 13.16,66.88 12.9,66.63 Q123.S ; M44.L10 v1(53.1,141.23) ; v1(124.66,129.75) 125.02,129.39 U26.F36 ; D59.3 v1(62.31,173.82) ; v1(78.82,57.36) 78.93,57.36 79.31,56.98 Q130.4 ; v1(88.1,142.83) M42.P10 ; M45.M10 40.15,80.82 v1(40.47,81.14) ; Q88.1 52.38,68.39 v1(52.53,68.53) ; R46.2 v1(169.24,121.11) ; R27.2 v1(169.11,126.19) ; v1(94.5,142.03) M42.N1 v1(95.3,142.83) ; C1368.2 v1(24.79,106.33) ; C13.2 v1(182.7,164.16) ; v1(172.54,13.03) 170.84,13.03 C2745.2 ; v1(178.64,134.95) 179.26,135.57 U23.3 ; v1(160.35,2.75) 160.5,2.9 CN9.S1 ; R3541.1 v1(16.15,107.9) ; v1(97.74,78.06) 98.12,77.68 R824.2 ; D10.1 v1(56.53,172.48) ; PJP15.2 v1(106.3,163.22) ; v1(81.63,58.78) 81.66,58.75 C1426.2 ; R9.1 v1(169.24,122) ; v1(120.6,7.67) R157.2 ; CN42.S2 172.41,6.17 v1(172.8,6.56) ; C871.2 77.93,77.06 77.93,80.31 v6(77.95,80.33) ; v1(39.67,81.13) 39.35,80.81 M45.L10 ; CNDEG2.2 140.48,4.71 v1(139.78,5.41) ; CN9.6 v1(165.8,7.2) ; C588.1 v1(189.43,152.1) ; C666.2 v1(6.5,105.92) ; R19.1 v1(169.37,117.3) ; R303.1 1.85,70.06 v1(2.11,70.31) ; v1(183.21,158.32) 183.34,158.32 183.83,158.81 Q47.4 ; Q4.4 94.8,62.88 v1(94.61,62.69) ; Q119.4 v1(38.44,38.55) ; C653.2 186.26,163.78 v1(186.51,164.04) ; Q165.3 v1(10.47,113.76) ; C3495.1 96.87,7.55 96.87,6.84 v1(96.43,6.39) 95.91,6.91 R443.1 ; R765.2 106.96,83.65 v1(107.39,83.65) 107.64,83.39 R180.1 108.1,83.37 R167.1 ; 43.64,124.48 43.33,124.78 v1(43.33,126.83) ; v1(49.9,134.03) M44.C14 v1(48.9,134.43) 48.65,134.18 47.13,134.18 C927.2 ; v1(72.3,145.23) M41.B10 v1(73.1,144.43) ; C1271.2 v1(185.01,7.32) ; Q88.4 v1(49.21,69.69) 49.15,69.75 C309.2 ; R791.2 v1(101.68,79.58) ; R2801.1 93.67,77.24 v1(93.67,78.44) ; v1(42.15,82.76) M45.R12 ; v1(141.3,26.5) 141.3,26.95 C205.2 ; C253.2 v1(173.66,21.8) ; CNWLAN1.76 99.55,17.79 v1(99.82,18.06) 100.15,18.39 R367.2 ; R818.2 v1(101.68,76.15) ; Q190.S v1(173.81,158.07) ; U16.6 v1(191.97,167.85) ; R3585.1 v1(165.05,9.71) ; C3743.1 v1(104.22,161.12) ; R22.1 v1(169.37,115.52) ; M45.G5 36.15,76.88 v1(35.75,77.28) ; R187.2 v1(35.12,38.8) ; C1176.2 125.98,156.57 v1(125.88,156.47) ; JP2.2 v1(172.67,23.7) ; C545.2 v1(58.37,162.51) ; M41.E1 65.85,142.07 v1(65.85,142.07) ; Q57.S v1(77.61,168.93) ; Q146.S v1(195.57,118) ; v1(104,53.89) Y2.4 ; v1(151.59,27.13) 151.59,27.51 150.7,28.4 150.44,28.65 C227.2 ; R2773.1 v1(3.5,109.3) ; v1(40.59,38.56) R3316.2 ; R241.1 v1(3.76,71.07) ; R2755.1 v1(3.58,110.29) ; v1(100.02,54.05) 99.21,54.05 C246.2 ; R897.1 v1(47.14,69.75) ; R821.2 v1(99.14,77.8) ; M43.P10 v1(42.15,116.16) ; Q137.S v1(10.87,103.71) ; v1(65.1,134.03) M41.R1 v1(65.9,134.83) ; R377.2 v1(135.2,34.12) ; U26.BR36 161.75,129.38 U26.BT36 162.5,129.38 v1(162.89,128.98) 162.47,128.56 U26.BT35 ; C1375.2 79.25,55.91 v1(79.2,55.96) ; Q136.S v1(11.31,108.47) ; C164.1 v1(30.56,59.64) ; C3384.2 v1(167.69,25.99) ; C738.2 v1(173.81,161.62) ; C225.2 76.83,38.2 77.11,37.93 v1(77.21,37.93) ; v1(53.94,55.47) 54.06,55.59 U2.2 ; CNSSD2.MTG77 v1(181.92,35.66) ; C1270.2 v1(185.01,8.72) ; v1(85.7,139.63) M42.K13 M42.K14 84.1,140.03 v1(83.85,140.28) 83.56,140.57 82.62,140.57 ; C1319.1 v1(138.52,27.24) ; R1.1 117.47,101.81 H19.1 ; R196.2 v1(35.14,34.76) ; C550.2 v1(22.68,105.74) ; Q104.1 94.55,61.94 v1(94.06,62.44) ; C128.2 v1(59,54.82) ; C244.2 v1(36.02,34.76) ; C964.2 51.29,148.16 v1(51.2,148.07) ; Q86.S v1(61.73,165.75) ; U20.4 v1(137.36,23.07) ; C668.2 v1(8.46,108.03) ; D39.3 128.77,173.82 128.77,174.02 128.9,174.15 v1(128.92,174.15) ; C800.2 v1(13.03,114.63) ; 59.9,145.63 M44.V1 ; R946.2 98.91,111.18 v1(98.5,111.59) ; Q49.S v1(185.94,166.26) ; Q12.S 30.05,37.1 29.54,37.61 v1(29.54,37.67) ; v1(87.3,142.03) 87.3,142.03 M42.M10 v1(88.1,141.23) ; v1(168.48,25.99) 168.48,24.71 168.86,24.33 Q16.4 ; CN17.S2 v1(103.7,4.64) ; R987.2 v1(19.38,107.72) ; v1(78.65,45.42) 79.32,45.42 79.83,45.93 C413.1 ; C279.2 v1(190.7,157.31) ; PJP28.2 v1(57.99,43.01) ; C14.2 v1(171.53,159.97)
  TOP w0.4: v1(48.45,142.83) v1(49.1,142.83) 49.34,142.58 M44.N14 49.72,142.2 v1(49.9,142.03) ; v1(50.7,139.63) M44.K13 M44.K14 49.1,140.03 v1(48.85,140.28) ; C920.2 36.65,106.25 v1(37.29,105.62) 37.03,105.36 C1046.2 ; M43.K2 v1(38.15,109.76) ; M45.V12 v1(44.55,82.76) v1(45.15,82.76) ; v1(59.5,146.03) M44.V1 59.9,145.63 v1(60.3,146.03) v1(60.95,146.03) ; M46.E1 v1(41.35,103.36) ; M44.A14 v1(48.9,132.83) ; v1(73.1,133.23) M41.T10 ; M42.V1 95.11,145.84 v1(95.3,146.03) v1(95.95,146.03) ; v1(40.55,95.36) M46.F10 v1(39.75,95.36) M46.G10 ; M45.K1 38.55,73.31 v1(38.7,73.01) ; v1(60.95,144.43) v1(60.3,144.43) M44.R1 v1(59.5,144.43) ; v1(60.29,134.05) 60.29,134.04 M44.C1 ; v1(60.55,140.08) 60.5,140.03 M44.K1 M44.K2 ; v1(74.7,131.83) v1(74.7,132.43) M41.V12 ; M42.C12 v1(86.5,134.03) M42.C11 87.34,134.87 v1(87.34,134.88) ; M43.T10 43.35,115.78 43.73,116.16 v1(43.75,116.16) ; M45.V3 v1(44.55,74.76) v1(45.15,74.76) ; v1(66.7,131.83) v1(66.7,132.43) M41.V3 ; M43.L10 v1(39.75,116.16) M43.M10 v1(40.55,116.16) ; 77.66,132.53 76.4,132.53 v1(76.3,132.43) M41.V14 ; M43.N1 v1(41.35,108.16) ; C1017.1 36.45,86.41 36.45,84.96 v1(36.77,84.64) 36.95,84.46 M45.H14 M45.H13 v1(37.35,82.76) ; v1(95.3,142.83) v1(95.95,142.83) ; M43.H1 36.95,108.36 v1(36.85,108.01) ; M41.R3 67.1,134.42 67.3,134.22 67.31,134.22 v1(67.5,134.03) M41.R4 ; v1(84.1,142.83) v1(83.45,142.83) ; M46.B5 v1(43.75,100.16) ; v1(53.1,141.23) M44.M10 v1(52.3,142.03) ; M44.G10 v1(52.3,137.23) M44.F10 v1(52.3,136.43) ; v1(93.7,142.83) M42.N3 93.28,142.43 92.9,142.82 v1(92.9,142.83) ; v1(58.7,146.03) M44.V3 ; v1(67.5,142.83) M41.E3 ; M45.V1 44.36,73.35 v1(44.55,73.16) ; M45.T5 v1(43.75,76.36) ; M42.A14 v1(83.91,132.83) ; 49.5,144.03 v1(49.1,144.43) v1(48.45,144.43) ; v1(48.94,138.28) 49.09,138.43 M44.H14 49.65,138.28 v1(49.9,138.03) 49.92,138.03 50.3,138.4 M44.H13 ; M43.V1 v1(44.55,108.16) ; M44.A3 v1(58.7,132.43) v1(58.7,131.78) ; v1(45.15,101.76) v1(44.55,101.76) M46.A3 v1(43.75,101.76) ; M41.E1 65.5,142.43 65.1,142.83 ; v1(42.95,108.16) M43.R1 ; M42.A12 85.68,132.41 v1(85.68,132.4) ; M41.N1 v1(65.1,135.63) ; M44.J1 60.5,139.23 v1(60.52,139.2) ; v1(57.9,142.83) M44.N3 v1(58.7,142.83) ; M45.R14 v1(42.95,84.36) ; M46.H1 38.55,103.21 v1(38.75,103.61) ; v1(73.1,142.03) 72.91,141.85 M41.F10 72.3,141.23 ; v1(93.7,133.23) M42.A3 v1(93.7,132.43) ; M41.M10 72.7,136.83 73.1,137.23 v1(73.1,137.23) M41.L10 ; v1(84.1,144.43) M42.R14 ; M45.N3 v1(41.35,74.76) ; M45.R12 v1(42.95,81.96) M45.R11 42.16,81.16 ; M42.A1 94.91,132.83 v1(95.34,132.4) ; M41.H2 M41.H1 65.22,140.03 v1(64.95,140.13) ; M44.D10 v1(52.3,134.83) M44.C11 v1(51.5,134.03) M44.C12 ; v1(53.1,142.83) 53.08,142.83 52.7,143.21 M44.P10 ; v1(42.95,103.36) M46.C1 ; M42.C4 v1(92.9,134.83) M42.C3 v1(93.7,134.83) ; M45.N14 v1(41.35,84.36) ; M46.E3 v1(40.55,101.76) ; M44.A12 v1(50.7,132.43) ; v1(38.7,108.01) 38.55,108.31 M43.K1 ; M41.M5 v1(68.3,137.23) M41.L5 ; M42.N12 v1(85.7,142.83) ; v1(60.57,138.16) 60.45,138.28 60.44,138.28 60.14,138.43 M44.H1 ; M41.N3 66.99,135.93 66.99,135.85 66.77,135.63 v1(66.7,135.63) ; v1(65.1,144.43) v1(64.5,144.43) ; v1(45.15,109.76) v1(44.55,109.76) M43.V3 ; M42.T5 v1(92.1,144.43) ; v1(57.15,134.77) 57.5,134.43 ; M45.K2 v1(38.15,74.76) ; M46.F5 v1(39.75,100.16) M46.G5 ; 72.3,141.23 M41.G10 ; 72.3,141.23 v1(72.15,141.23) ; v1(60.3,132.43) M44.A1 ; v1(93.7,146.03) M42.V3 ; v1(69.1,145.23) M41.B5 v1(68.3,144.43) 68.23,144.36 M41.C4 67.72,144.21 v1(67.5,144.43) M41.C3 ; M46.J1 37.75,103.56 v1(37.8,103.61) ; v1(74.7,136.43) M41.N12 ; 57.5,144.03 M44.R4 v1(57.9,144.43) M44.R3 58.3,144.03 v1(58.7,144.43) ; M45.R3 v1(42.95,75.56) M45.R4 ; M46.H2 v1(38.15,101.76) ; M44.E1 v1(60.3,135.63) ; C1070.2 42.82,91.83 v1(42.95,91.96) ; M44.E12 50.77,135.71 v1(50.7,135.63) ; M44.E3 58.3,136.03 v1(58.7,136.43) ; v1(35.75,112.23) 35.75,112.16 M43.G5 ; 84.5,145.65 v1(84.12,146.03) v1(83.45,146.03) ; v1(91.2,141.23) 91.3,141.23 M42.L5 ; v1(95.3,144.43) v1(95.95,144.43) ; v1(64.5,146.03) v1(65.1,146.03) 65.14,145.98 M41.A1 v1(65.9,145.23) ; v1(30.61,98.89) 30.43,98.71 C1076.1 ; M42.L10 v1(88.1,141.23) ; M45.N1 41.21,73.3 v1(41.35,73.16) ; v1(35.75,96.16) M46.L10 ; M45.M5 v1(39.75,76.36) M45.L5 ; v1(42.15,101.76) M46.C3 v1(42.15,100.96) M46.C4 ; M44.N12 v1(50.7,142.83) ; v1(58.7,138.83) 58.7,138.82 58.74,138.77 58.75,138.77 M44.H2 ; M46.K2 M46.K1 36.95,103.56 v1(36.9,103.61) ; M44.T5 v1(56.3,145.23) ; M41.E14 v1(75.5,142.83) ; v1(48.45,146.03) v1(49.1,146.03) 49.1,145.98 49.45,145.63 49.5,145.63 M44.V14 ; M46.A1 v1(44.55,103.36) ; v1(57.1,141.23) M44.L5 v1(56.3,141.23) ; M43.L5 v1(39.75,111.36) M43.M5 ; v1(32.55,104.16) v1(32.55,103.36) M46.R1 ; v1(42.13,81.15) 42.17,81.15 42.16,81.16 ; v1(36.81,73.03) 36.96,73.54 M45.H1 M45.H2 ; M46.N12 v1(34.15,93.76) ; v1(91.3,142.03) M42.M5 ; v1(76.3,135.63) M41.N14 v1(75.5,135.63) ; M44.F5 56.7,136.85 57.07,137.23 v1(57.1,137.23) 57.1,137.24 56.71,137.63 M44.G5 ; 42.16,81.16 M45.P10 ; C1048.2 28.97,92.14 v1(29.65,91.46) ; M44.R12 v1(50.7,143.63) ; v1(60.95,142.83) v1(60.3,142.83) 60.3,142.82 60.09,142.61 60.08,142.61 M44.N1 ; M44.C3 v1(57.9,134.83) ; M45.T10 v1(43.75,81.16) ; M41.A12 v1(73.9,145.23) ; v1(42.15,95.36) M46.D10 ; 85.7,146.01 v1(85.7,146.03) ; M41.E12 v1(74.7,142.83) ; M41.K2 v1(66.7,138.83) ; M41.G5 v1(69.1,141.23)
  TOP w0.406: R2803.1 87.02,75.77 v1(86.92,75.77) ; M43.H1 M43.H2
  TOP w0.508: C556.2 v1(3.5,106.51) ; C1193.2 117.09,156.49 v1(116.92,156.67) ; C641.2 v1(183.77,163.35) ; v1(2.23,142.07) 2.3,142.13 H5.1 v1(2.3,151.14) ; v1(174.95,14.43) 174.99,14.47 C84.1 ; CN17.S1 v1(111.5,2.49) ; v1(76.91,161.88) 76.91,162.31 C473.2 ; v1(88.39,147.28) 88.58,147.46 C900.2 ; R950.2 v1(24.08,119.33) ; C540.2 12.44,82.25 10.31,82.25 9.8,82.76 ; C629.2 74.82,174.59 v1(74.78,174.63) ; C180.2 v1(32.89,58.32) 32.89,57.35 C1235.2 ; v1(179.27,60.91) 180.96,60.91 CN11.262 ; v1(178.64,114.51) 178.64,113.69 ; 19.39,40.85 v1(19.39,38.53) ; v1(82.49,148.17) 82.61,148.29 C988.2 ; AC5.2 22.3,53.29 v1(22.55,53.04) 23.08,53.04 AC8.2 ; C1035.2 48.08,73.82 v1(48.08,73.29) ; v1(15.87,120.86) C3941.2 R2880.2 ; 19.39,44.53 v1(19.39,45.4) ; v1(179.65,114.51) 179.65,113.69 ; C294.2 v1(157.17,8.72) ; v1(12.9,56.29) 13.08,56.11 AB5.1 ; C419.2 v1(53.03,158.58) ; R886.1 v1(187.02,8.46) ; C3543.2 53.36,56.31 53.36,56.13 v1(53.38,56.12) ; C428.1 v1(60.73,164.24) ; C803.1 v1(18.01,110.04) ; C3545.2 v1(17.84,45.94) ; C663.2 v1(9.09,97.62) ; AC4.2 26.2,53.62 AC9.2 24.56,53.62 v1(24.28,53.34) ; C1376.2 v5(151.47,139.23) ; C3548.2 v1(29.03,42.12)
  L3_IN1 w0.102: v1(30.61,98.89) 31.39,98.1 36.37,98.1 37.8,96.67 v1(37.8,96.31)
  L3_IN1 w0.15: 85.37,111.2 85.41,111.17 v6(85.41,110.64) ; 85.37,111.2 85.37,111.26 85.65,111.53 ; 85.37,111.2 v6(85.37,111.19) ; v6(76.95,113.28) 77.25,112.98 77.25,112.85 77.25,112.85 77.25,112.36 77.55,112.06 v6(77.55,111.88) ; v6(74.96,110.76) 75.14,110.94 75.14,111.1 75.15,111.11 75.15,111.46 75.14,111.47 75.14,111.66 v6(75.41,111.93) 75.15,112.19 75.15,113.01 v6(74.83,113.33) ; 85.65,111.53 85.7,111.53 85.92,111.3 v6(85.92,111.16) ; 85.65,111.53 G1.AU47 ; G1.AU47 v6(85.94,113.28) v6(85.35,113.28) G1.AU47
  L3_IN1 w0.25: v6(75,115.23) 74.85,115.08 v6(74.85,114.68) 75.34,114.19 v6(75.34,113.83) 75.33,113.83 v6(74.83,113.33)
  L3_IN1 w0.254: v1(137.37,66.96) 136.97,67.37 136.97,71.11 136.28,71.8 136.28,73.33 135.32,74.29 135.32,79.9 133.13,82.1 133.13,87.36 133.38,87.61 133.38,94.25 135.57,96.44 135.57,98.94 136.59,99.96 v1(136.79,99.96) 137.26,99.96 137.82,100.52 137.82,105.62 v1(137.75,105.69) 137.75,106.95 v1(137.77,106.97) 137.77,108.84 v1(137.58,109.03) ; v1(154.33,69.47) 157.5,72.64 157.5,80.19 156.42,81.26 156.42,86.62 156.16,86.88 156.16,93.13 156.16,93.13 156.16,93.53 155.05,94.64 155.05,94.65 152.63,97.07 152.63,97.94 151.29,99.28 151.29,102.04 v1(150.3,103.03) v1(150.3,104.35) 150.3,107.14 149.82,107.62 149.82,108.3 149.09,109.03 v1(148.56,109.03)
  L3_IN1 w0.3: v6(77.07,111.13) 77.07,111.4 v6(77.55,111.88) ; v6(77.07,111.13) 76.85,110.91 v6(76.85,110.58) 77.52,110.58 v6(77.55,110.55) ; v6(77.07,111.13) 76.27,111.93 ; v6(76.95,113.28) 76.77,113.28 76.27,112.78 76.27,111.93 ; 76.27,111.93 v6(75.41,111.93)
  L3_IN1 w0.381: v6(66.54,83.35) 66.54,84.08 v6(67.05,84.58) v6(67.05,85.98) 66.4,85.98 v6(66.27,85.85) ; v6(79.22,81.89) 79.2,81.91 v6(79.2,82.48) 79.6,82.88 v6(79.6,83.93) 79.1,83.93 v6(79.05,83.98) 79.05,85.01 v6(79.17,85.13)
  L8_IN3 w0.1: 63.81,101.78 63.81,101.78 63.48,101.78
  L8_IN3 w0.15: 63.81,101.78 63.98,101.78 v6(64.27,101.49) ; v6(58.1,84.32) 58.15,84.32 v6(58.76,84.93) 58.89,85.06 59.87,85.06 v6(60.2,84.73) 60.46,85 61.24,85 v6(61.55,84.69) 61.59,84.69 v6(62.18,85.27) 62.71,84.74 v6(62.96,84.74) 63.43,85.21 v6(63.43,85.24) ; v6(66.54,83.35) 66.54,82.33 v6(66.66,82.22) ; 66.75,85.58 66.48,85.85 v6(66.27,85.85) ; 66.75,85.58 66.75,84.88 v6(67.05,84.58) ; 66.75,85.58 G1.K8 v6(67.05,85.98) ; v6(83.25,113.28) G1.AP47 83.54,112.25 83.67,112.12 83.74,112.05 v6(83.74,112.09) ; v6(79.22,113.81) 79.35,113.68 79.35,112.7 v6(79.2,112.55) 79.65,112.1 v6(79.65,111.88) ; v6(67.45,99.68) 65.95,99.68 65.81,99.82 v6(65.81,99.86) 65.44,99.86 65.25,99.68 65.11,99.68 65.11,99.68 64.78,99.68 64.78,99.68 64.69,99.68 v6(64.49,99.88) ; 63.48,101.78 63.33,101.93 v6(63.1,101.93) 62.6,101.93 v6(62.15,101.48) 61.79,101.48 v6(61.59,101.68) ; v6(65.05,97.88) 64.75,97.58 63.82,97.58 v6(63.55,97.31) ; v6(61.77,99.61) 61.87,99.71 62.81,99.71 v6(62.95,99.85) 63.42,99.38 v6(63.65,99.38) ; v6(65.94,110.3) 65.86,110.22 65.03,110.22 v6(64.9,110.36) ; v6(62.95,104.16) 63.07,104.16 v6(63.51,103.72) 63.69,103.72 v6(64.25,104.28) 64.6,104.28 v6(64.83,104.05) 65.52,104.05 v6(65.67,104.2) 66.43,104.2 v6(66.45,104.18) ; v6(77.54,113.28) 77.54,113.21 77.25,112.91 77.25,112.37 77.55,112.07 v6(77.55,111.88)
  L8_IN3 w0.2: v6(63.65,107.78) 63.48,107.95 v6(63.48,108.31) ; v6(71.15,113.83) 71.1,113.83 v6(70.65,113.38)
  L8_IN3 w0.25: v6(64.49,99.88) 64.15,99.88 v6(63.65,99.38) ; v6(61.7,97.43) 61.89,97.24 v6(62.26,97.24) 62.8,97.78 v6(63.09,97.78) v6(63.55,97.31) ; v6(76.95,113.28) v6(77.54,113.28) ; v6(65.67,111.48) 65.67,111.72 65.43,111.96 64.93,111.96 v6(64.34,112.55) 64.19,112.55 v6(63.59,111.95) ; v1(72.3,145.23) 72.44,145.37 72.44,145.38 72.95,145.89 72.95,145.89 72.96,145.89 v1(72.96,146.15) ; v6(63.6,109.87) 63.65,109.92 v6(63.65,110.58) 63.75,110.48 v6(64.25,110.48) 64.37,110.36 v6(64.9,110.36) ; v6(77.55,110.55) 76.88,110.55 v6(76.85,110.58) 76.85,110.91 v6(77.07,111.13) 77.07,111.4 v6(77.55,111.88)
  L8_IN3 w0.254: v1(150.3,103.03) 150.3,102.05 150.85,101.5 150.85,100.6 153.73,97.72 153.73,97.63 153.76,97.6 153.76,96.67 158.04,92.39 158.04,85.51 155.89,83.37 v1(155.53,83.37) ; v1(140.07,103.51) 140.07,103.95 139.63,104.39 138.54,104.39 138.18,104.03 138.18,97.69 134.62,94.13 134.62,89.8 136.23,88.19 136.23,87.08 136.66,86.66 136.66,84.4 136.91,84.15 136.91,82.62 136.6,82.31 v1(136.39,82.31)
  L8_IN3 w0.3: v6(66.38,97.27) 66.37,97.28 v6(65.65,97.28) v6(65.05,97.88) ; v6(65.67,111.48) 66.07,111.08 66.07,110.43 v6(65.94,110.3)
  L8_IN3 w0.381: v1(28.83,115.88) 28.83,121.8 33.48,126.44 v1(33.83,126.44) ; v1(122.91,105.39) 122.91,104.12 122.38,103.58 117.8,103.58 114.88,100.66 114.88,90.5 116.15,89.23 116.15,80.33 v1(115.6,79.77)
  BOTTOM w0.076: v3(53.21,138.33) 53.21,139.09 v1(53.28,139.15) ; v3(37.79,116.03) 37.79,115.22 v1(37.8,115.21)
  BOTTOM w0.089: v2(109.6,30.41) 109.09,30.91 108.11,30.91 107.53,31.49 106.46,31.49 106.12,31.83 105.28,31.83 C276.2 ; v2(109.65,29.14) 109.63,29.14 109.42,28.93 108.18,28.93 v2(107.41,29.69)
  BOTTOM w0.152: S20.2 66.8,180.08 CN26.5 67.79,180.08 S19.2 ; S10.2 64.79,180.08 CN26.11 63.8,180.08 S11.2 ; S13.2 68.32,179.5 CN26.2 69.29,179.52 S12.2
  BOTTOM w0.2: C1421.1 75.15,108.83 v6(75.15,109.48) ; v6(77.25,87.78) 77.25,88.69 C1444.1
  BOTTOM w0.203: 131.07,176.49 130.99,176.41 S27.2 ; 131.07,176.49 CN23.7 ; 131.07,176.49 S26.2 ; v1(163.91,16.43) 163.63,16.71 U5.27 ; U5.3 161.81,26.31 161.62,26.5 v1(161.62,27.13) ; v1(158.93,27.51) 158.82,27.63 U5.122 ; S16.2 76.28,156.99 v1(76.28,156.92) ; S29.2 134.06,175.62 CN23.4 134.44,174.86 S28.2 ; S117.2 110.57,176.09 110.96,176.48 ; S25.2 125.17,176.39 CN23.H1 ; CN23.H2 137.07,176.41 S30.2 ; S14.2 v1(68.4,157.81) ; v1(182.7,164.16) 182.5,164.37 S111.2 ; S4.2 164.73,172.29 v1(164.73,171.5) ; C3625.1 117.65,125.07 116.91,125.07 116.89,125.1 116.88,125.1 116.22,125.76 U105.11 ; U5.91 148.29,25.11 v1(148.41,25.23) ; v1(28.84,173.65) 28.32,173.12 S1.2 ; S115.2 105.16,176.48 CN32.H1 ; S113.2 117.05,176.33 CN32.H2 ; v1(77.21,37.93) 76.88,38.26 S7.2 ; v1(154.89,29.8) 155.22,29.47 U5.113 ; v1(154.63,15.45) 154.82,15.27 U5.49 ; U104.11 172.67,60.38 v1(172.64,60.4) ; S5.2 79.37,38.06 v1(79.34,38.03) ; CN32.7 111.42,176.16 S116.2 ; CN32.7 110.96,176.48 ; CN32.7 111.04,176.56 S114.2 ; U5.75 148.33,18.71 v1(148.41,18.62) ; v1(73.74,157.76) 73.94,157.56 S15.2 74.43,157.95 74.3,158.09 CNEDP1.36 ; 110.96,176.48 S112.2 ; S18.2 65.54,156.21 v1(65.28,156.21) ; v1(78.07,38.03) 78.05,38.04 S8.2 ; U106.11 v1(168.68,15.64) ; v1(14.93,163.66) 15.18,163.41 S110.2 ; S6.2 v1(80.67,37.98)
  BOTTOM w0.25: C1340.1 C1416.1 79.35,88.66 v6(79.35,87.78)
  BOTTOM w0.254: R202.1 92.29,95.84 v6(92.35,95.78) ; CNEDP1.22 67.3,157.47 v1(67.26,157.43) ; v1(129.35,110.94) 129.35,110.93 v1(129.35,110.3) v1(129.35,109.67) ; v1(24.48,147.53) 24.47,147.52 24.16,147.52 23.76,147.52 23.75,147.53 23.7,147.53 23.63,147.6 U32.4 ; Q120.4 v1(45.54,161) ; v1(132.1,110.94) 132.09,110.93 v1(132.09,110.3) ; CNEDP1.4 v1(58.3,157.87) ; v1(64.96,138.26) 64.02,138.26 C895.2 ; CNEDP1.20 v1(66.3,157.88) ; C1395.1 81.45,108.57 v6(81.45,109.48) ; v1(132.1,109.03) v1(132.1,109.67) ; v1(8.08,72.22) 8.08,71.81 8.52,71.36 CN12.45 ; v1(36.75,119.66) 36.75,118.36 v1(37.35,117.76) ; v2(109.65,29.14) 109.65,30.36 v2(109.6,30.41) ; R165.1 91.85,91.89 v1(92.29,92.33) ; PJP34.2 v1(188.01,112.55) ; v1(9.79,68.53) 9.62,68.36 CN12.39 ; v1(68.4,157.81) 68.3,157.91 CNEDP1.24 ; CNEDP1.16 64.3,157.98 64.34,157.94 v1(64.34,157.91) ; R2771.1 95.01,85.25 v6(94.9,85.13) ; CNEDP1.13 v1(62.8,157.81) ; CNFAN1.S1 14.9,146.93 14.05,147.78 v1(13.28,147.78) ; CNEDP1.1 v1(56.8,157.86) ; CNEDP1.10 v1(61.3,157.82) ; v1(43.26,159.08) 43.26,159.26 Q120.1 ; CNEDP1.7 v1(59.8,157.85) ; v1(65.48,157.81) 65.8,158.13 CNEDP1.19 ; CN12.26 9.86,61.86 v1(9.98,61.98) ; v1(140.33,110.94) 140.33,110.31 v1(140.32,110.3) ; CNEDP1.23 v1(67.8,157.72) ; v1(137.58,109.67) v1(137.58,109.03)
  BOTTOM w0.3: 76.85,104.23 v6(76.85,104.93) 76.91,105 76.91,106.27 v6(76.85,106.33) v6(76.85,107.03) ; v6(81.15,107.03) v6(81.15,106.33) 81.02,106.21 C1336.1 81.02,105.05 v6(81.15,104.93) ; v6(72.65,100.03) 72.65,99.63 ; 72.65,101.15 v6(72.65,100.73) ; C1398.1 C1393.1 71.94,107.64 71.08,107.64 C1432.1 ; C1398.1 73.36,107.62 ; C1398.1 72.85,107.23 v6(72.65,107.03) ; 83.95,98.48 v6(83.95,98.63) ; v6(75.45,100.03) 75.45,99.51 ; 72.92,103.25 v6(72.65,103.53) 72.9,103.78 72.9,104.19 ; 76.83,103 76.83,103.52 v6(76.85,103.53) 76.83,103.54 76.83,104.19 ; v6(76.85,90.23) 76.85,90.24 76.85,90.93 v6(76.85,90.93) 76.86,90.95 C1298.1 76.86,92.27 v6(76.8,92.33) ; v6(72.65,98.63) 72.65,99 ; C1266.1 77.47,105.11 v6(77.65,104.93) ; v6(71.25,100.03) v6(71.25,100.73) ; 75.43,96.51 v6(75.45,96.53) v6(75.45,97.23) ; v6(82.55,90.23) v6(82.55,90.93) 82.72,91.11 82.72,92.15 v6(82.55,92.33) ; 73.98,95.76 73.98,96.47 v6(74.05,96.53) ; v6(81.15,93.73) 81.15,93.74 ; 76.78,89.23 77.21,88.8 C1444.1 ; C1277.1 81.15,103.84 v6(81.15,103.53) ; v6(81.15,92.33) 81.27,92.21 C1261.1 81.27,91.05 v6(81.15,90.93) 81.17,90.91 81.17,90.25 v6(81.15,90.23) ; v6(75.45,106.33) 75.45,105.63 C1291.1 75.45,105.61 v6(75.45,104.93) 75.39,104.87 75.39,103.59 v6(75.45,103.53) 75.39,103.47 75.39,102.19 v6(75.45,102.13) ; v6(78.98,97.93) 78.33,97.93 ; C1399.1 C1421.1 75.44,107.74 ; v6(82.55,96.53) v6(82.55,97.23) ; 79.75,99.52 v6(79.75,100.03) v6(79.75,100.73) ; v6(74.05,93.73) 73.93,93.61 C1333.1 73.93,92.45 v6(74.05,92.33) ; v6(81.15,100.73) v6(81.15,100.03) ; 75.39,100.79 v6(75.45,100.73) ; 81.1,95.91 81.1,96.49 v6(81.15,96.53) v6(81.15,97.23) 81.15,97.64 ; v6(82.55,103.53) 82.55,103.53 C1384.1 ; 82.55,98.91 v6(82.55,98.63) ; 83.95,97.48 v6(83.95,97.23) ; v6(78.95,92.33) 78.62,92.01 C1390.1 78.62,91.25 v6(78.95,90.93) ; v6(71.25,97.23) 71.25,97.31 ; 71.25,98.57 v6(71.25,98.63) ; 81.15,98.48 v6(81.15,98.63) ; v6(79.8,104.93) 79.8,104.96 80.16,105.33 C1183.1 80.16,105.94 79.8,106.3 v6(79.72,106.33) 79.75,106.38 v6(79.75,107.03) ; 82.55,99.9 v6(82.55,100.03) v6(82.55,100.73) 82.55,101.3 ; 76.85,98.09 v6(76.85,98.63) ; v6(71.25,106.33) v6(71.25,107.03) ; 72.9,104.68 v6(72.65,104.93)
  BOTTOM w0.305: C1420.2 78.25,102.04 v6(78.25,100.68) ; C1420.2 79.8,103.59 v6(79.8,104.93) ; C1420.2 79.75,101.76 v6(79.75,100.73) ; C1420.2 78.05,103.46 78.05,103.84 77.65,104.25 v6(77.65,104.93) ; C1339.1 79.53,92.12 v6(79.75,92.33) ; v6(75.45,98.63) 75.45,99.23 C1163.1 75.45,99.25 75.45,99.51 ; CN12.36 9.51,66.86 v1(9.8,66.58) 9.58,66.36 CN12.35 ; 81.15,93.74 81.15,95.13 v6(81.15,95.13) 81.1,95.18 81.1,95.91 ; 72.65,99.63 72.65,99.32 C1257.1 72.65,99.16 72.65,99 ; 72.9,104.68 72.9,104.24 C1128.1 72.9,104.19 ; v1(8.08,72.22) 8.08,72.47 8.47,72.86 CN12.48 ; 76.83,104.19 C1383.1 76.85,104.23 ; v6(81.15,102.13) 81.15,101.57 C1273.1 81.15,101.47 v6(81.15,100.73) ; v6(83.95,92.33) 84.23,92.05 C1342.1 83.95,91.37 v6(83.95,90.93) v6(83.95,90.23) ; v6(92.99,113.31) 92.68,113.62 C971.2 ; v6(81.15,93.73) 81.15,92.66 81.14,92.65 81.14,92.45 81.15,92.44 v6(81.15,92.33) ; v6(82.55,106.33) v6(82.55,107.03) 82.29,107.29 C1265.1 82.32,107.69 C849.1 81.43,108.54 C1395.1 ; v6(85.94,113.28) 86.03,113.36 C1181.1 ; v6(82.55,102.13) 82.62,102.06 C970.2 82.55,101.45 82.55,101.3 ; v6(81.15,107.03) 81.42,107.31 C1264.1 ; v6(74.05,104.93) 74.05,105.05 73.66,105.44 C1313.1 73.66,105.95 v6(74.05,106.33) v6(74.05,107.03) 74.05,107.04 73.83,107.25 73.83,107.47 C1382.1 73.63,107.62 73.36,107.62 ; v6(74.05,96.53) v6(74.05,97.23) 73.95,97.33 C1167.1 73.95,98.54 v6(74.05,98.63) ; C1396.2 84.15,107.23 v6(83.95,107.03) ; v1(181.96,70.06) 182.8,69.22 C1349.1 ; v6(83.95,96.53) 83.95,96.14 83.69,95.89 C1337.1 83.95,95.58 v6(83.95,95.13) 83.69,94.88 C1332.1 83.95,94.19 v6(83.95,93.73) 83.95,93.3 C1249.1 ; C323.1 115.19,20.66 114.99,20.47 v2(114.83,20.47) ; CNHDD1.1 v1(187,86.74) ; v6(90.26,97.34) 90.26,96.82 89.97,96.52 C1295.2 ; U5.1 163.27,27.16 163.7,27.59 v1(163.7,27.69) ; 76.83,103 76.83,102.85 C1182.1 76.85,102.81 v6(76.85,102.13) 76.85,101.44 C1137.1 76.85,101.41 v6(76.85,100.73) ; v6(78.35,98.58) 78.24,98.48 C1161.1 78.27,97.93 78.33,97.93 ; 82.55,99.9 82.55,99.3 C1169.1 82.55,99.17 82.55,98.91 ; 71.25,98.57 C1286.1 71.25,97.31 ; v1(42.24,38.56) 42.57,38.56 C3550.2 ; CNHDD1.18 186.84,78.24 v1(187.02,78.06) ; v1(181.86,67.11) 182.22,67.47 184.38,67.47 184.82,67.91 Q100.1 ; v1(161.62,27.13) 161.62,27.26 161.26,27.61 U5.128 ; v1(146.71,127.11) 146.57,126.98 C60.2 ; C1424.2 78.35,95.31 v6(78.35,96.58) ; C1424.2 76.85,95.44 v6(76.85,96.53) ; C1424.2 76.8,93.76 v6(76.8,92.33) ; C1424.2 78.43,93.85 78.43,93.42 78.95,92.91 v6(78.95,92.33) ; v6(74.05,92.33) 74.05,91.72 C1299.1 74.16,91.09 74.05,90.97 v6(74.05,90.93) v6(74.05,90.23) ; 81.15,97.64 81.15,97.95 C1144.1 81.15,98.08 81.15,98.48 ; C1289.1 84.1,105.08 v6(83.95,104.93) ; v1(9.85,64.97) 9.74,64.86 CN12.32 ; v1(146.72,129.07) 146.68,129.11 C370.2 ; AB1.1 22.12,57.66 v1(21.67,58.12) ; CN12.17 8.33,57.36 7.67,58.02 v1(7.67,58.27) ; 79.75,99.52 79.75,99.31 C1288.1 79.82,98.7 v6(79.75,98.63) ; v6(75.45,95.13) 75.45,95.71 C1250.1 75.43,96.51 ; CNHDD1.8 186.74,83.24 v1(187.02,83.52) 186.8,83.74 CNHDD1.7 ; v6(76.85,107.03) 76.85,107.03 76.85,107.25 C1388.1 77.23,107.61 C1394.2 C1408.1 78.87,107.6 C1422.1 79.75,107.56 v6(79.75,107.03) ; v6(82.55,96.53) 82.55,95.87 C1191.1 82.58,95.51 82.58,95.16 v6(82.55,95.13) 82.57,95.1 C1335.1 82.55,94.41 v6(82.55,93.73) 82.55,93.07 C1262.1 82.57,92.36 v6(82.55,92.33) ; C1268.1 76.85,98.09 ; C1386.1 73.79,103.79 v6(74.05,103.53) 73.79,103.27 C1389.1 73.79,102.39 v6(74.05,102.13) 73.79,101.87 C1334.1 73.79,100.99 v6(74.05,100.73) ; 83.95,98.48 83.95,98.05 C1138.1 83.95,97.98 83.95,97.48 ; v6(79.75,97.23) v6(79.75,96.53) ; v6(85.35,100.03) 86.05,99.32 C1356.2 85.38,98.63 v6(85.35,98.63) 85.26,98.54 85.26,97.32 v6(85.35,97.23) v6(85.35,96.53) 85.47,96.41 C1192.1 85.47,95.26 v6(85.35,95.13) 85.42,95.06 85.42,94.49 C1338.1 85.35,94.32 85.35,94.16 v6(85.35,93.73) 85.47,93.61 C1248.1 85.35,92.92 v6(85.35,92.33) 85.29,92.28 85.29,90.99 v6(85.35,90.93) v6(85.35,90.23) ; 73.98,95.76 C1245.1 73.98,95.2 v6(74.05,95.13) ; 72.92,103.25 C1188.1 72.92,102.41 v6(72.65,102.13) 72.65,101.7 C1164.1 72.65,101.15 ; v1(181.94,70.92) 182.68,70.92 183.52,71.77 Q100.4 ; CNHDD1.4 v1(187.02,85.24) ; C79.2 v1(147.03,124.14) ; v6(71.25,106.33) 71.37,106.2 C1279.1 71.37,105.06 v6(71.25,104.93) 71.14,104.83 C1151.1 71.14,103.66 71.25,103.56 v6(71.25,103.53) 71.14,103.43 C1152.1 71.2,102.77 71.2,102.18 v6(71.25,102.13) 71.25,101.53 C1186.1 71.25,101.32 v6(71.25,100.73) ; CNHDD1.17 v1(187,78.74) ; v6(72.65,107.03) v6(72.65,106.33) ; 75.44,107.74 C1284.1 75.45,107.64 v6(75.45,107.03) v6(75.45,106.33) ; C1384.1 82.55,104.93 v6(82.55,104.93) ; C1400.1 76.6,89.23 76.78,89.23 ; v1(12.27,55.36) CN12.13 ; C1260.1 v6(95.1,113.36) C1263.1 ; 75.39,100.79 75.39,102.07 v6(75.45,102.13) ; CN12.19 v1(9.98,58.36)
  BOTTOM w0.381: v1(82.75,138.28) 82.59,138.13 C876.1 R2686.2 ; C916.2 29.88,107.89 v1(30.15,108.16) ; C115.2 153.17,111.59 v1(153.12,111.54) ; v1(30.94,153.24) 30.86,153.17 C3988.2 ; v1(48.9,132.83) 48.53,132.46 C932.1 ; C989.1 87.42,133.1 v1(87.31,133.21) ; v1(140.41,131.19) 140.36,131.19 140.16,131.4 C52.2 140.16,132.81 C77.2 140.58,133.45 v1(140.74,133.45) 141.05,133.15 R48.1 ; v1(43.75,111.36) 43.71,111.4 C911.2 ; v1(140.79,124.21) 141.02,124.44 C56.2 ; v1(156.41,1.98) 156.48,2.05 Q161.S ; v1(150.62,78.67) 151.33,77.95 151.33,77.37 C3423.2 ; C3443.1 118.69,66.36 v1(118.39,66.06) ; C277.2 105.87,29.42 107.14,29.42 v2(107.41,29.69) ; C1281.1 86,105.59 v6(85.35,104.93) ; v1(38.81,40.97) 39.06,40.72 D42.3 ; v1(97.1,164.16) 97.1,162.47 U24.3 ; v1(57.1,141.23) 57.23,141.1 C934.2 ; C933.2 61.03,137.7 v1(60.57,138.16) ; v1(134.9,130.36) 134.95,130.41 C50.2 ; v1(119.58,131.52) 120.22,132.16 C204.2 ; v6(90.95,99.28) 90.95,99.11 90.7,98.87 C1302.2 ; v1(68.3,133.23) 68.3,133.23 C885.2 ; v1(95.55,140.08) 95.75,140.29 C908.2 ; C63.2 144.3,131.47 v1(144.35,131.52) 144.4,131.47 C396.2 ; v2(118.71,23.66) 118.07,24.3 C340.2 ; v1(83.45,142.83) 83.24,142.62 C906.2 ; R894.2 65.09,135.64 v1(65.1,135.63) ; v1(83.35,132.83) 83.35,132.83 ; C1061.2 39.65,95.25 v1(39.75,95.36) ; C923.2 31.68,120.03 v1(31.75,119.96) ; C388.2 142.65,77.49 v1(143.14,77.98) ; CNFAN1.1 8.66,149.36 v5(8.58,149.43) ; Q69.S 108.11,2.05 v1(108.09,2.07) ; C3992.2 11.25,66.25 v1(11.76,66.75) ; C123.2 150.2,124.01 v1(149.92,124.29) 150.14,124.51 C372.2 150.14,125.54 v1(149.86,125.82) ; v6(71.25,92.33) 71.25,92.1 71.47,91.88 C1402.1 ; C450.2 114.63,165.76 114.63,166.64 Q183.S v1(115.42,167.43) ; C3901.2 v1(145.49,6.94) ; v6(79.75,92.33) 79.63,92.45 C421.2 79.63,93.61 v6(79.75,93.73) 79.63,93.85 C1330.1 79.61,94.46 79.61,95 v6(79.75,95.13) 79.6,95.27 79.6,95.81 C1246.1 79.63,96.41 v6(79.75,96.53) ; C3440.2 155.03,77.29 v1(155.77,78.03) ; v1(145.06,74.83) 145.09,74.87 C3438.2 ; R190.2 v1(169.37,11.26) ; C214.2 166.45,25.48 v1(166.95,25.99) ; C2746.2 v1(112.09,6.58) ; v1(107.85,39.2) 107.77,39.12 R83.1 R84.1 106.7,38 106.45,37.75 R78.1 105.99,38.18 v2(105.87,38.31) ; R3722.2 24.64,70.95 C818.2 ; v1(116.06,66.76) 115.77,67.05 C392.2 ; v6(91.65,108.48) 91.65,108.77 C1254.1 ; C978.1 43.84,81.07 v1(43.75,81.16) ; C3422.2 141.43,83 v1(141.31,83.11) ; C341.1 112.05,16.72 v2(112.03,16.73) 111.65,16.35 C283.2 ; C196.2 142.84,105.09 v1(142.78,105.04) ; C299.2 109.41,10.7 v1(110.04,11.33) ; C3553.2 v1(41.22,38.43) ; C367.2 v1(137.24,127.74) C364.2 ; v1(106.42,7.19) 106.12,6.89 C291.2 ; C3439.2 169.75,77.48 v1(169.99,77.73) ; C114.2 157.61,113.54 v1(157.36,113.3) ; C3627.1 120.7,124.54 v1(121.1,124.13) ; CNEDP1.S1 54.7,165.7 v1(55.32,166.32) ; C168.2 C175.2 v1(167.08,23.19) ; v1(159.99,151.51) 160.48,151.51 161.16,150.83 C305.2 ; v1(156.17,131.13) 156.16,131.14 C125.2 ; v1(82.49,148.17) 82.61,148.29 C988.2 ; R363.1 115.85,16.16 v2(116.42,16.73) ; C1057.2 32.89,91.17 v1(32.55,91.51) ; v1(68.52,123.15) 68.27,122.91 R2759.2 R2760.2 ; v1(30.95,103.36) v1(30.95,104.16) 30.76,104.35 C1053.1 ; Y3.2 98.25,31.51 v1(98.25,31.96) ; C385.2 116.03,80.2 v1(115.6,79.77) ; R2878.1 91.31,86.49 v6(91.52,86.69) 92.24,87.41 C677.2 ; v1(110.06,14.07) 109.85,14.07 109.52,14.4 R358.2 109.5,14.48 R354.2 109.5,15.93 C326.1 109.35,16.26 v2(109.83,16.73) ; C1049.2 45.3,104.36 44.55,103.61 v1(44.55,103.36) ; ESD3.8 ESD3.3 v1(148.44,180.37) ; C1066.2 92.02,133.24 v1(92.06,133.28) ; v6(76.85,90.23) 76.85,90.15 C1400.1 C1387.1 75.38,90.16 v6(75.45,90.23) v6(75.45,90.93) 75.4,90.98 75.4,92.28 v6(75.45,92.33) 75.45,92.47 75.71,92.73 C1331.1 75.71,93.1 75.45,93.36 v6(75.45,93.73) ; v1(143.99,112.2) 144.02,112.18 C45.2 ; C1184.1 86.82,105 v6(86.75,104.93) ; v1(132.39,82.4) 132.49,82.31 R40.2 ; C3418.2 142.32,69.33 v1(142.45,69.47) 143.17,69.47 C176.2 ; v1(181.69,31.32) 181.38,31.01 CN4.2 ; C3621.1 166.77,16.03 v1(166.45,15.7) 167.01,15.14 C3620.1 ; C3616.1 v1(171.58,62) ; v1(12.39,165.81) 12.38,165.8 SW3.1 ; C387.2 171.91,77.31 v1(171.38,77.83) ; C54.2 141.81,128.55 v1(141.98,128.37) 142.06,128.3 C368.2 ; R211.1 v1(134.7,66.75) ; CNHDD1.S2 193.96,76.45 194.17,76.24 v1(194.17,76.22) ; CNFAN1.S2 7.3,144.75 v1(7.57,144.48) ; CN4.S2 v1(177.5,27.01) ; v2(124.15,25.23) 124.61,25.68 C325.1 ; v1(139.65,127.77) 139.6,127.82 C398.2 ; C3626.1 111.35,123.02 110.67,122.33 v1(110.06,122.33) ; C1361.1 19.71,74.7 19.27,75.15 ; C3419.2 146,69.56 v1(146.01,69.58) ; v1(42.95,119.36) 42.82,119.49 C1002.1 ; v1(136.85,66.63) 136.6,66.37 R44.2 C78.1 ; C993.2 45.23,109.68 v1(45.15,109.76) ; v1(37.8,80.21) 37.74,80.27 C1067.2 ; C948.2 96.59,143.48 v1(95.95,142.83) ; v1(159.99,122.71) 160.27,122.43 C107.2 ; v1(155.4,11.13) 155.07,10.8 C177.2 ; C3643.2 118.44,123.4 v1(118.69,123.65) 118.69,123.9 118.31,124.29 C3641.2 ; v1(83.26,160.1) 83.47,159.89 CN41.S1 ; v1(76.3,138.03) 77.03,138.76 R2685.2 C875.1 ; SW1.5 29.9,169.34 v1(28.14,171.1) ; v2(117.16,25.21) 117.17,25.21 C331.1 ; v1(157.7,110.9) 157.68,110.92 C207.2 ; v1(44.55,73.16) 45.06,72.65 C1072.2 ; C983.2 76.89,140.53 76.88,140.51 ; v1(5.03,76.91) 5.03,76.84 CN12.S2 ; v1(20.95,66.96) 20.95,67.41 C1364.1 ; v1(30.15,117.76) 29.96,117.95 C922.2 ; v1(149.38,132.08) 149.45,132.16 C399.2 ; U29.3 85.45,154.75 87.15,156.44 v1(87.15,156.54) 87.91,155.78 Q188.S ; v1(160.65,117.2) 160.65,116.77 C105.2 ; v6(94.69,86.95) 94.19,86.95 C719.2 ; ACN1.S1 83.46,37.09 v1(83.01,37.54) ; C1255.1 90.25,106.69 v6(90.25,106.38) ; C1255.1 89.33,106.44 89.33,106.17 v6(89.15,105.98) ; C1255.1 90.08,107.02 90.74,107.68 v6(90.95,107.68) ; C3638.1 97.1,160.99 96.34,161.75 94.56,161.75 v1(93.93,162.39) ; C3904.2 95.02,1.73 v1(94.28,2.47) 94.06,2.7 C4085.2 ; v1(45.15,82.76) 45.16,82.77 C974.2 ; v1(142.95,23.96) 143.08,24.08 R105.2 ; v1(11.12,72.22) 11.38,72.22 12.01,71.58 12.01,71.15 C548.2 ; C75.2 137.44,130.18 v1(137.26,130.36) ; v1(94.94,167.08) 94.92,167.11 C4092.2 ; C209.2 130.92,125.86 v1(130.96,125.82) ; v1(154.33,69.47) 154.04,69.18 C187.2 ; SW1.3 v1(25.55,167.47) ; C1050.1 40.59,95.39 v1(40.55,95.36) ; C466.2 65.53,157.76 v1(65.48,157.81) ; C59.2 v1(144.35,127.76) ; C1020.2 34.26,72.34 ; CN14.4 186.4,57.12 v1(186.89,57.61) ; v6(93.05,109.88) 92.77,109.6 C1190.1 ; C93.2 155.4,127.74 v1(155.37,127.76) ; v1(121.61,126.34) 121.88,126.08 122.29,126.08 R52.1 ; R988.1 13.71,72.01 13.72,71.96 v1(13.44,71.68) ; v1(141.43,65.61) 141.1,65.94 R45.2 ; C347.2 143.46,16.34 143.39,16.34 v1(143.11,16.05) ; v1(147.81,105.04) 147.76,105.09 C189.2 ; C65.2 137.24,131.04 v1(137.26,131.01) ; C1016.2 56.26,141.99 v1(56.3,142.03) ; C1013.2 31.49,112.42 v1(31.75,112.16) ; C945.2 81.48,145.47 v1(81.73,145.71) ; v1(95.3,135.63) 95.43,135.77 C904.1 ; C48.2 134.39,111.75 v1(134.85,112.21) ; C818.2 24.66,70.87 R939.2 ; C818.2 24.89,70.92 v1(25.2,71.22) ; v1(42.95,108.16) 42.95,107.7 43.43,107.22 C912.2 ; v1(143.56,125.82) 143.59,125.79 C69.2 ; v6(94.35,109.78) 94.35,110.52 C1253.1 93.62,110.65 v6(93.62,109.88) ; C182.2 v1(143.08,17.73) ; R51.1 v1(145.62,132.29) ; R192.2 161.95,31.52 v1(162.76,32.34) ; v1(34.15,107.56) 34.44,107.27 C914.2 ; R903.2 39.01,107.7 v1(38.7,108.01) ; v1(76.3,132.43) 76.52,132.21 C890.1 ; v1(88.1,141.23) 88.72,141.23 C956.1 ; v1(30.15,112.16) 29.95,112.36 C1001.2 ; v1(99.57,3.93) 99.17,3.93 98.58,3.33 C3902.2 ; v1(159.37,111.7) 159.31,111.64 C203.2 ; v1(60.95,146.03) 60.99,146.08 C963.1 ; C218.2 140.35,105.09 v1(140.27,105.01) ; C1446.1 90.95,90.26 v6(90.95,90.88) ; C1272.2 v1(178.11,8.73) ; C979.1 44.98,84.79 ; v6(95,110.18) 95.07,110.26 C1401.1 ; 57.06,137.27 57.01,137.32 C1014.2 ; v1(146.73,112.21) 146.96,111.98 C44.2 ; C986.2 95.91,138.84 v1(95.55,139.2) ; v1(148.92,1.5) 149.32,1.5 149.87,2.05 Q162.S ; C149.2 135.29,105.09 v1(135.24,105.04) ; v1(74.34,156.44) 74.57,156.22 D45.3 ; v1(76.3,134.03) 76.34,133.99 C985.1 ; C907.2 83.02,146.46 v1(83.45,146.03) ; v1(42.15,116.16) 42.19,116.12 C1044.2 ; C1003.2 48.41,144.46 v1(48.45,144.43) ; CNDEG1.S2 170.9,2.1 v1(170.26,2.75) ; Q157.S 142.35,2.05 v1(141.81,1.5) ; v1(40.55,116.16) 40.41,116.02 C917.1 ; C1015.2 52.32,136.4 v1(52.3,136.43) ; C376.2 156.19,129.75 v1(156.16,129.71) ; C960.2 52.03,105.27 52.03,105.98 v1(52.02,106) ; v1(120.22,131.14) 120.6,130.76 C213.2 ; SW3.6 v1(16.73,160.48) ; C378.2 132.03,108.96 v1(132.1,109.03) ; C939.1 64.54,142.88 v1(64.58,142.84) ; v1(168.22,167.08) 167.8,167.51 SW6.4 ; v1(38.95,83.56) 38.89,83.62 R2718.2 ; v1(91.2,141.23) 91.2,140.55 C950.1 ; v1(129.87,174.04) 129.82,173.99 C500.2 ; C2578.2 v1(69.34,156.16) C2579.2 ; v1(67.26,157.43) 67.44,157.25 C465.2 ; v1(130.2,105.03) 130.26,105.09 C212.2 ; v1(44.55,108.16) 45.27,108.16 C1052.2 ; C3903.2 158.32,5.67 v1(158.43,5.78) ; C282.1 20.6,151.13 v1(20.27,151.46) ; 19.27,75.15 v1(19.38,75.26) ; 19.27,75.15 C817.2 ; C329.1 121.82,28.69 v2(121.58,28.93) ; C942.1 72.16,141.22 v1(72.15,141.23) ; C996.2 57.1,133.23 v1(57.1,133.23) ; v1(103.83,30.69) 103.83,30.81 104.42,31.4 C276.2 ; C991.2 R2715.2 36.57,119.84 v1(36.75,119.66) ; C397.2 130.56,128.15 v1(130.17,127.76) ; ACN1.S2 73.01,34.87 v1(72.85,35.03) ; v1(160.67,115.63) 160.93,115.37 C101.2 ; C3622.1 171.78,19.15 171.78,19.26 v1(171.65,19.38) ; v1(121.11,175.21) 121.08,175.18 SW5.2 ; v1(59.5,146.03) 59.5,146.89 C998.2 ; Q148.S 103.64,7.13 v1(103.58,7.06) ; C1251.1 95.46,110.18 95.19,110.18 ; C1251.1 96.48,111.2 97.59,111.2 C1187.1 97.65,111.12 v6(97.65,110.53) ; C1251.1 96.51,110.64 R2729.1 ; C3424.1 115.14,80.19 v1(114.75,79.8) ; v1(142.95,18.37) 143.2,18.62 C147.2 ; C162.2 v1(166.85,21.42) ; v1(51.37,82.81) 51.37,82 C687.2 50.74,82.15 v1(50.74,82.79) ; v1(60.95,142.83) 61.25,142.52 C423.2 ; C894.2 67.5,146.89 v1(67.5,146.03) ; R141.2 v1(166.85,19.64) ; v1(65.1,134.03) 65.08,134.01 C893.1 ; v2(111.11,21.47) 111,21.36 C328.1 ; C816.2 15.82,66.25 v1(15.7,66.37) 15.75,66.42 R968.2 ; C74.1 v1(154.38,64.47) ; 14.16,63.19 C3991.2 14.16,64.77 C3990.2 15.06,65.67 v1(15.06,66.25) ; v1(35.35,80.21) 35.44,80.29 C1021.1 ; v1(73.1,137.23) 73.01,137.32 C940.1 ; v1(95.95,146.03) 96.31,146.4 C951.2 ; C57.2 132.54,130.94 v1(132.54,130.36) ; C3630.1 175.28,57.05 v1(175.34,57.1) ; C217.2 138.35,105.09 v1(137.75,105.69) ; C4093.2 v1(94.63,169.05) ; v1(182.7,54.56) 183.34,54.56 184,55.23 CN14.1 ; C3552.2 v1(37.03,39.12) ; v2(123.52,28.78) 123.6,28.78 123.98,28.4 C327.1 123.98,27.59 v2(123.88,27.49) ; v6(65.05,87.38) 65.05,87.22 C1309.1 65.78,86.35 v6(66.27,85.85) ; v1(117.75,66.63) 117.55,66.83 C3445.1 ; C42.2 131.01,130.41 v1(130.96,130.36) ; Q160.S v1(152.79,2.05) ; v1(97.1,6.18) 98.04,5.24 C2747.2 ; C1011.2 39.62,111.49 v1(39.75,111.36) ; C937.2 52.3,146.8 ; v1(91.3,145.23) 91.26,145.19 C957.1 ; C375.2 148.26,128.39 v1(148.28,128.41) ; C4094.2 v1(91.97,157.13) ; C135.2 140.16,82.74 v1(139.79,83.11) ; C878.1 R2731.2 ; v1(117.89,79.35) 118.06,79.52 C3421.1 ; C949.1 92.01,137.32 v1(92.1,137.23) ; v1(106.5,1.98) 105.85,2.63 Q71.S ; v1(179.27,160.99) 179.71,161.43 SW2.5 ; v1(53.42,70.06) 53.62,69.85 C416.2 ; C1069.2 42.99,104.26 42.99,103.39 v1(42.95,103.36) ; v1(150.65,127.76) 150.7,127.81 C94.2 ; SW6.3 167.8,171.57 v1(167.97,171.4) ; C215.2 C184.2 150.06,104.59 v1(150.3,104.35) ; v1(88.39,147.28) 88.58,147.46 C900.2 ; C1071.2 56.34,141.19 v1(56.3,141.23) ; v1(69.1,141.23) 69.16,141.16 C981.2 C972.2 ; C73.1 136.48,80.78 v1(137.45,79.81) ; v1(34.15,104.16) v1(34.15,103.36) ; v1(160.58,147.7) 161.09,148.22 CNFAN2.1 ; R906.2 62.05,136.28 61.4,135.63 v1(60.3,135.63) ; CNFAN2.S2 v1(170.46,145.67) ; v1(125.99,73.57) 125.25,74.32 C3416.2 ; v1(42.95,91.96) 43.44,91.47 43.44,90.9 C1055.2 ; v1(39.57,38.56) 39.95,38.94 C3549.2 ; C994.1 30.89,115.4 v1(30.89,115.39) ; C206.2 152.54,105.22 152.72,105.04 v1(152.84,105.04) ; C3417.2 140.92,69.58 v1(140.95,69.61) ; C3625.1 118.74,125.56 118.93,125.37 120.51,125.37 v1(120.74,125.14) ; C386.2 116.92,79.64 v1(116.8,79.53) ; v1(161.32,113.27) 161.32,113.61 C109.2 ; C1443.1 89.51,87.23 v1(90.07,86.67) ; C80.2 133.12,124.34 v1(133.17,124.29) 133.43,124.54 133.92,124.54 ; C188.2 121.6,127.98 v1(120.98,128.6) 121.09,128.72 C220.2 ; C1047.2 46.16,90.88 C1054.1 45.22,90.9 45.22,91.29 v1(44.55,91.96) ; C930.2 58.26,146.47 v1(58.7,146.03) ; CN4.S1 v1(185.07,29.08) ; 88.87,113.38 C1269.1 89.45,113.95 ; C877.1 38.94,120.75 v1(38.93,120.74) ; v1(52.02,115.27) 52.02,115.27 52.03,115.25 C959.2 ; C61.2 v1(144.35,130.36) ; v1(141.98,129.06) 142.01,129.09 C58.2 ; C153.2 119.06,133.44 118.52,133.99 118.52,134.52 v1(118.57,134.57) ; v1(125.15,78.96) 125.69,78.41 C3441.2 ; v2(120.11,20.47) 119.85,20.73 R67.1 ; v1(151.98,69.53) 151.84,69.39 C3425.2 ; v1(143.07,111.57) 143.06,111.59 C191.2 ; v6(90.95,105.58) 90.95,105.27 90.49,104.81 C785.1 90.21,104.32 v6(90.25,104.28) ; C64.2 138.89,125.87 v1(138.84,125.82) ; v1(38.95,85.91) 39.11,86.07 C879.1 ; C167.2 132.76,105.09 v1(132.72,105.05) ; v1(86.5,139.63) 87.04,139.63 C947.1 ; SW2.6 185.49,160.74 v1(185.88,160.35) ; C977.2 v1(33.35,83.57) ; R39.2 135.2,79.7 134.61,79.1 v1(133.94,79.1) ; C935.2 56.21,145.32 v1(56.3,145.23) ; C962.2 61,134.05 v1(60.29,134.05) ; v6(74.05,90.23) 74.05,90.18 73.58,89.72 C1189.1 ; v1(76.3,145.23) 76.36,145.16 C941.1 ; C391.2 116.66,66.89 v1(117.05,66.5) ; C896.2 65.9,146.97 v1(65.9,146.03) ; C198.2 121.41,169.93 120.85,169.37 v1(120.73,169.37) ; C1442.1 90.63,87.07 v1(90.63,86.69) ; v1(140.16,1.5) 140.13,1.5 139.58,2.05 Q159.S ; C1012.2 36.35,111.76 35.88,112.23 v1(35.75,112.23) ; R947.1 v1(15.29,68.28) ; v1(76.39,148.55) 76.38,148.54 C897.2 ; v1(158.52,125.81) 158.65,125.69 C133.2 ; C901.2 92.89,134.83 v1(92.9,134.83) ; C1045.2 41.68,104.28 41.68,103.69 v1(41.35,103.36) ; C8.2 15.24,155.02 12.38,157.88 SW3.2 12.38,160.78 SW3.5 11.73,162.84 v1(11.73,162.84) ; v1(150.19,134.29) 150.19,133.83 C585.2 149.17,133.8 v1(149.17,134.29) ; CNDEG1.3 v1(178.73,2.91) ; C100.2 153.69,130.47 v1(153.8,130.36) ; R174.2 v1(160.98,9.48) ; C334.1 144.8,52.45 v1(144.35,52.91) ; v6(90.95,101.38) 90.95,101.24 90.69,100.98 C1296.2 ; C3617.1 v1(173.99,62) ; v1(65.28,156.21) 65.28,155.6 65.94,154.94 R371.1 ; C1073.2 45.18,74.73 v1(45.15,74.76) ; C1320.1 85.94,110.11 v6(85.41,110.64) ; v1(68.3,137.23) 68.51,137.44 C1007.2 ; Y3.4 v1(101.68,28.2) ; v1(38.95,90.81) 38.95,90.06 C1042.1 ; v1(134.9,127.76) 134.95,127.81 C49.2 ; CNDEG1.2 v1(179.53,2.88) ; v1(146.72,130.38) 146.72,130.73 147.28,131.29 C577.2 ; CN14.S1 v1(182.7,56.09) ; v1(53.1,141.23) 53.11,141.22 C1000.1 ; v1(23.14,66.96) 23.37,67.19 R965.1 ; v6(72.65,90.23) 72.72,90.16 C881.1 C1409.1 71.73,89.59 71.25,90.07 v6(71.25,90.23) v6(71.25,90.93) ; C3420.2 147.01,70.58 v1(147.13,70.7) ; R3624.2 v1(17.17,158.37) ; C915.1 31.37,106.96 30.99,107.34 v1(30.99,107.93) ; v1(184.99,156.8) 184.84,156.94 SW2.4 ; C913.2 41.17,107.98 v1(41.35,108.16) ; v1(143.09,109.69) 143.09,109.82 143.38,110.11 C381.2 ; v1(41.86,41.1) 42.11,40.85 D43.3 ; v1(38.75,103.61) 38.75,104.58 R919.2 ; v1(48.9,134.43) 48.84,134.37 C931.1 ; C335.1 v1(152.37,51.03) ; C4084.2 v1(95.2,3.13) ; C2575.2 78.05,156.7 78.48,156.26 v1(78.51,156.26) 78.94,156.7 C667.2 ; C53.2 135.24,125.82 v1(135.69,125.82) ; v1(74.7,131.83) 75.13,131.4 C1065.2 ; R325.1 C410.2 v1(47.07,158.45) ; PJP11.2 176.61,17.61 v1(176.86,17.86) ; C783.1 90.95,103.25 v6(90.95,103.48) ; C918.1 43.97,115.94 v1(43.75,116.16) ; C886.2 73.09,133.23 v1(73.1,133.23) ; v1(21.67,61.42) 21.97,61.73 AB3.1 ; v1(83.94,134.25) 83.93,134.24 C990.1 ; v2(126.64,17.11) 127.41,16.35 R249.1 ; RT10.1 142.7,15.19 v1(142.32,14.81) ; Q158.S 146.89,1.41 v1(146.89,1.35) ; v1(51.44,115.34) 51.44,116.45 C961.2 ; C999.1 52.43,133.1 v1(52.3,133.23) ; R205.1 137.57,78.42 v1(137.47,78.51) ; v2(121.59,27.49) 121.59,27.17 122.39,26.37 C222.2 ; C122.2 v1(159.21,131.27) ; C3648.2 v1(175.08,57.74) ; SW1.6 v1(26,169.1) ; v1(110.11,124.67) 110.11,125.02 C3623.2 ; SW2.3 v1(184.84,166.32) ; R362.1 v1(88.8,10.85) ; C66.2 132.54,127.79 v1(132.51,127.77) 132.54,127.74 C366.2 ; D44.3 71.76,156.22 v1(71.7,156.16) ; C936.2 50.74,146.79 ; v1(142.82,24.97) 143.2,24.97 143.59,25.35 C142.2
  BOTTOM w0.4: v1(48.94,138.28) v1(47.75,138.28) 47.47,138 C878.1 ; C1252.1 78.51,89.69 78.95,90.13 ; v1(39.75,100.16) 39.78,100.14 C1060.2 ; v1(76.3,143.6) 76.32,143.57 v1(76.95,143.57) ; v1(69.1,145.23) 69.18,145.32 C982.1 ; C1056.2 35.58,90.4 35.98,90 R2732.2 36.57,91.68 v1(36.75,91.86) ; 76.88,140.51 v1(76.6,140.23) ; C1031.2 43.71,76.4 v1(43.75,76.36) ; v1(42.95,84.36) 43.2,84.61 C997.1 ; v1(29.65,91.46) 30.19,90.92 C1058.2 ; C987.1 87.39,136.53 v1(87.3,136.43) ; C1036.2 30.99,73.12 v1(30.95,73.16) 30.91,73.2 29.3,73.2 C1023.2 ; C1063.2 31.75,99.36 v1(31.75,99.36) ; v1(95.95,144.43) v1(95.3,144.43) ; 78.95,90.13 78.95,90.12 79.42,89.65 C1340.1 ; 78.95,90.13 v6(78.95,90.23) ; R917.2 38.73,72.98 v1(38.7,73.01) ; C905.1 83.66,140.47 v1(83.85,140.28) ; R895.2 93.6,138.65 v1(93.74,138.8) ; v1(31.75,119.36) v1(31.75,119.96) ; C1022.2 39.76,77.16 39.76,76.36 v1(39.75,76.36) ; v1(65.1,144.43) v1(64.5,144.43) 64.07,144.43 63.58,144.93 C929.2 ; v1(30.11,82.41) 29.88,82.64 C1029.2 ; v1(60.95,146.03) v1(60.3,146.03) ; v1(48.85,140.28) 48.66,140.47 C1004.1 ; C1032.1 36.45,76.88 36.05,77.28 v1(35.75,77.28) ; v1(64.5,146.03) v1(65.1,146.03) ; C1189.1 C1008.2 ; v1(31.75,77.16) 31.69,77.09 C1026.1 ; v1(41.35,73.16) 41.68,72.83 C1025.2 ; C1057.2 32.89,89.67 32.57,89.35 C1062.2 31.57,88.95 v1(30.94,88.32) ; v1(42.15,95.36) 42.16,95.37 C1059.2 ; v6(95,110.18) 95.19,110.18 ; v1(49.1,142.83) v1(48.45,142.83) ; v1(51.37,82.81) 51.37,83.51 C1030.2 50.74,83.37 v1(50.74,82.79) ; v1(49.1,146.03) v1(48.45,146.03) ; C980.1 42.8,73 v1(42.95,73.16) ; C1402.1 71.25,91.37 v6(71.25,90.93) ; C1018.2 29.94,76.15 v1(30.15,76.36) ; v1(95.95,146.03) v1(95.3,146.03) ; v6(88.15,113.38) 88.87,113.38 ; v1(44.55,119.36) 44.73,119.53 C992.1 ; v1(82.75,138.28) v1(83.9,138.28) ; 44.98,84.79 v1(44.55,84.36) ; 89.45,113.95 v6(89.45,114.08) ; 34.26,72.34 v1(34.26,73) ; 52.3,146.8 v1(52.3,146.08) ; C1024.2 40.79,80.77 40.47,81.09 v1(40.47,81.14) ; 57.06,137.27 v1(57.1,137.23) ; v1(60.3,144.43) v1(60.95,144.43) ; v1(34.15,108.16) v1(34.15,107.56) ; v1(83.91,132.83) v1(83.35,132.83) ; 50.74,146.79 v1(50.74,146.01) ; v1(38.95,92.01) v1(38.95,90.81) ; v1(32.55,104.16) v1(32.55,103.36)
  BOTTOM w0.406: C954.2 92.26,147.54 v1(92.28,147.53) ; 83.35,132.83 82.99,132.46 C898.2 ; R2806.1 91.01,82.76 v6(91.77,81.99)
  BOTTOM w0.508: v5(16.48,145.52) 16.33,145.37 16.33,144.4 15.75,144.4 15.06,143.72 C293.2 ; v1(187,86.74) 187.7,86.74 189.49,88.53 CNHDD1.S1 ; CNEDP1.S2 v1(78.4,166.42) ; C3644.2 118.37,126.44 v1(118.75,126.83) 118.75,127.02 118.44,127.33 C3646.2 ; SW1.4 v1(25.55,173.75) ; v6(87.35,111.98) 87.48,111.85 C969.2 ; v1(96.85,147.88) 96.82,147.91 C909.2 ; Q70.S v1(111.96,2.05) ; CN12.S1 v1(7.63,47.26) ; CN41.S2 v1(86.69,166.4) ; v1(19.51,146.51) C257.2
  vias: v1(0.63,114.66) v1(0.63,109.43) v1(0.63,104.42) v1(0.62,99.27) v1(0.63,94.19) v1(0.63,83.62) v1(0.71,47.7) v1(0.89,163.1) v1(1.47,139.27) v1(1.6,141.43) v1(1.85,135.97) v1(1.85,135.33) v1(1.85,134.7) v1(1.98,84.53) v1(2.23,141.43) v1(2.34,165.87) v1(2.64,158.93) v1(2.67,158.3) v1(2.69,157.41) v1(2.87,141.56) v1(3.38,141.81) v1(3.38,84.53) v1(4.14,129.75) v1(4.65,142.7) v1(4.65,128.73) v1(4.9,129.75) v1(5.03,154) v1(5.03,77.55) v1(5.28,153.37) v1(5.28,142.7) v1(5.41,67.52) v1(5.54,69.55) v1(5.54,68.53) v1(6.04,153.37) v1(6.04,102.7) v1(6.43,84.53) v1(6.43,69.55) v1(6.43,67.52) v1(6.46,68.56) v1(6.68,164.8) v1(6.68,164.04) v1(6.68,163.4) v1(6.93,102.7) v1(6.93,74.76) v1(7.21,165.87) v1(7.19,74.12) v1(7.31,164.8) v1(7.31,164.04) v1(7.44,69.55) v1(7.44,68.53) v1(7.44,67.52) v1(7.82,102.7) v1(7.95,84.53) v1(9.35,150.57) v1(9.93,150.57) v1(10.49,150.57) v1(11.07,150.57) v1(13.16,149.94) v1(13.16,149.3) v1(17.35,165.84) v1(17.98,116.79) v1(17.98,115.78) v1(17.98,114.76) v1(19,116.79) v1(19,115.78) v1(19,114.76) v1(19.51,69.93) v1(20.01,116.79) v1(20.01,115.78) v1(20.01,114.76) v1(20.01,70.44) v1(20.4,136.6) v1(20.4,136.02) v1(20.37,135.46) v1(20.4,134.85) v1(20.4,134.22) v1(20.4,133.66) v1(20.4,133.05) v1(20.52,69.93) v1(21.67,59.77) v1(22.07,148.42) v1(22.1,147.86) v1(22.43,165.84) v1(23.32,61.42) v1(23.32,59.77) v1(23.32,58.12) v1(23.82,136.6) v1(23.82,136.02) v1(23.8,135.46) v1(23.82,134.85) v1(23.82,134.22) v1(23.82,133.66) v1(23.82,133.05) v1(24.46,164.34) v1(24.45,138) v1(24.61,172.42) v1(24.61,168.1) v1(24.59,144.99) v1(24.59,144.35) v1(24.59,143.72) v1(24.84,77.85) v1(24.84,77.3) v1(24.97,61.42) v1(24.97,58.12) v1(25.09,138) v1(25.22,174.65) v1(25.22,32.13) v1(25.48,77.85) v1(25.48,77.3) v1(26.03,77.85) v1(26.03,77.3) v1(26.87,81.41) v1(26.87,80.85) v1(27.51,81.41) v1(27.51,80.85) v1(28.14,81.41) v1(28.14,80.85) v1(28.55,98.86) v1(28.52,83.52) v1(28.57,99.95) v1(30.15,95.36) v1(30.4,177.96) v1(30.58,176.8) v1(30.95,117.02) v1(30.91,110.49) v1(30.94,101.76) v1(30.94,92.13) v1(30.94,81.9) v1(30.99,82.75) v1(30.97,80.28) v1(30.96,75.49) v1(31.75,117.75) v1(31.7,108.97) v1(31.72,92.97) v1(31.72,73.94) v1(31.76,115.33) v1(31.8,96.35) v1(31.76,81.97) v1(31.79,80.33) v1(32.18,178.39) v1(32.54,116.15) v1(32.54,109.78) v1(32.54,100.13) v1(32.54,95.41) v1(32.52,81.13) v1(32.56,118.57) v1(32.62,116.98) v1(32.59,111.36) v1(32.64,108.05) v1(32.59,101.76) v1(32.61,100.97) v1(32.59,93.78) v1(32.55,92.16) v1(32.61,81.94) v1(32.55,74.75) v1(32.56,73.94) v1(32.61,73.1) v1(33.33,117.76) v1(33.32,108.94) v1(33.4,119.46) v1(33.37,116.13) v1(33.36,81.16) v1(33.39,74.76) v1(33.48,120.09) v1(33.65,182.07) v1(33.75,115.19) v1(34.14,101.81) v1(34.06,96.22) v1(34.14,81.15) v1(34.15,117.76) v1(34.15,110.56) v1(34.15,109.76) v1(34.19,100.97) v1(34.16,92.97) v1(34.15,91.98) v1(34.16,83.54) v1(34.15,82.76) v1(34.15,75.56) v1(34.16,73.97) v1(34.26,187.4) v1(34.39,126.47) v1(34.92,108.97) v1(34.95,126.47) v1(34.95,118.58) v1(34.95,117.74) v1(34.98,116.15) v1(35.03,99.32) v1(34.97,95.33) v1(34.98,81.15) v1(34.96,76.36) v1(35.51,126.42) v1(35.75,100.16) v1(37.31,126.47) v1(37.31,93.75) v1(37.97,126.44) v1(38.63,126.47) v1(38.95,92.96) v1(39.22,126.44) v1(40.55,117.76) v1(40.55,82.76) v1(41.27,128.5) v1(41.27,127.74) v1(41.35,119.36) v1(41.35,117.76) v1(41.35,93.76) v1(41.35,92.96) v1(41.35,91.98) v1(41.35,82.76) v1(41.96,128.5) v1(41.96,127.84) v1(42.15,117.76) v1(42.15,93.76) v1(42.59,128.5) v1(42.59,127.84) v1(42.95,118.56) v1(42.95,116.96) v1(42.95,94.56) v1(42.95,92.95) v1(43.35,147.84) v1(43.36,148.44) v1(43.41,146.15) v1(43.38,145.52) v1(43.38,143.84) v1(43.38,143.18) v1(43.38,141.86) v1(43.38,141.2) v1(43.38,139.58) v1(43.36,138.97) v1(43.41,136.63) v1(43.41,135.97) v1(44.55,117.76) v1(44.55,93.76) v1(45.15,117.76) v1(46.33,35.28) v1(46.33,34.67) v1(46.67,141.68) v1(46.96,35.28) v1(46.96,34.67) v1(47.07,69.04) v1(47.07,68.41) v1(47.6,35.28) v1(47.6,34.67) v1(49.02,185.37) v1(49.33,35.28) v1(49.33,34.67) v1(49.91,35.26) v1(49.91,34.65) v1(50.49,58.88) v1(50.47,35.28) v1(50.47,34.67) v1(50.74,145.25) v1(51.13,58.88) v1(51.76,58.88) v1(52.4,185.7) v1(53.42,34.62) v1(53.54,33.12) v1(54.17,187.16) v1(56.29,182.07) v1(62.23,62.56) v1(62.23,61.67) v1(62.23,60.79) v1(62.4,139.98) v1(62.72,144.43) v1(62.94,139.78) v1(63.07,166.7) v1(64.85,166.58) v1(65.1,132.43) v1(65.6,126.71) v1(65.86,165.81) v1(65.9,133.23) v1(65.99,159.9) v1(66.36,126.66) v1(66.62,159.9) v1(66.61,148.3) v1(66.88,161.34) v1(66.9,160.79) v1(67.16,165.94) v1(67.55,166.53) v1(68.15,32.13) v1(70.43,65.61) v1(70.99,165.59) v1(71.07,65.61) v1(71.47,180.29) v1(72.47,166.58) v1(73.79,183.7) v1(73.9,139.63) v1(73.86,32.16) v1(73.99,61.55) v1(75.01,61.55) v1(75.5,145.25) v1(75.56,184.46) v1(75.89,61.55) v1(77.84,137.78) v1(77.82,135.27) v1(78.13,180.77) v1(78.33,29.42) v1(78.43,24.39) v1(78.43,4.17) v1(78.46,9.02) v1(78.61,184.53) v1(80.16,5.51) v1(80.16,4.96) v1(81.08,161.19) v1(82.07,160.18) v1(82.75,68.89) v1(82.75,68.33) v1(82.75,67.77) v1(82.75,67.21) v1(82.75,66.65) v1(82.86,64.47) v1(82.88,63.83) v1(82.93,62.56) v1(83.06,161.37) v1(83.36,14.38) v1(83.9,136.03) v1(84.15,51.77) v1(84.4,57.86) v1(84.4,57.1) v1(84.78,51.77) v1(84.9,146.68) v1(84.9,135.63) v1(84.9,134.03) v1(85.29,57.48) v1(85.7,135.63) v1(85.7,131.83) v1(85.93,20.15) v1(86.05,17.86) v1(86.11,12.47) v1(86.18,57.86) v1(86.18,57.1) v1(86.44,39.98) v1(86.44,39.42) v1(86.49,14.43) v1(87.02,160.56) v1(87.04,39.98) v1(87.04,39.42) v1(87.3,137.23) v1(87.68,39.98) v1(87.71,39.42) v1(88.01,20.33) v1(88.34,160.58) v1(89.99,160.61) v1(90.63,20.4) v1(90.75,49.61) v1(91.24,160.61) v1(92.15,21.03) v1(92.28,55.32) v1(92.28,53.55) v1(93.42,52.66) v1(93.42,51.64) v1(93.42,50.63) v1(93.5,12.96) v1(93.93,156.67) v1(94.26,125.23) v1(94.44,55.17) v1(94.44,52.66) v1(94.44,51.64) v1(94.44,50.63) v1(94.56,156.67) v1(95.2,186.13) v1(95.2,156.67) v1(95.45,52.66) v1(95.45,51.64) v1(95.45,50.63) v1(95.45,13.54) v1(95.83,156.67) v1(96.14,180.72) v1(96.19,55.6) v1(96.47,156.67) v1(96.6,157.21) v1(96.85,10.62) v1(96.97,139.66) v1(97.1,156.67) v1(97.26,14.13) v1(97.43,141.25) v1(97.41,10.6) v1(97.61,186.13) v1(97.61,156.29) v1(98.45,42.36) v1(98.46,42.95) v1(98.75,93.22) v1(99.26,156.29) v1(99.39,32.97) v1(99.49,129.14) v1(99.52,127.89) v1(100.02,182.45) v1(100.02,177.88) v1(100.27,36.22) v1(100.28,34.62) v1(101.64,33.66) v1(101.65,185.88) v1(101.68,16.79) v1(102.31,18.37) v1(102.44,166.45) v1(103.07,37.54) v1(103.25,97.89) v1(103.38,96.07) v1(103.58,39.32) v1(103.83,34.14) v1(103.96,32.72) v1(104.47,11.51) v1(104.85,171.91) v1(104.85,171.28) v1(104.85,169.75) v1(104.85,169.12) v1(105,173.41) v1(104.98,172.8) v1(105.99,41.48) v1(105.99,39.58) v1(105.99,11.38) v1(107.14,12.14) v1(107.77,44.15) v1(107.77,41.1) v1(108.91,42.37) v1(109.17,45.16) v1(109.88,40.31) v1(110.06,47.2) v1(110.17,48.58) v1(110.44,41.99) v1(110.69,173.31) v1(110.82,166.83) v1(110.95,31.32) v1(111.33,169.12) v1(111.4,38.61) v1(111.58,40.59) v1(111.96,42.5) v1(112.47,146.64) v1(112.47,146) v1(112.47,145.37) v1(112.47,142.45) v1(112.47,141.81) v1(112.47,141.18) v1(112.5,75.44) v1(112.5,74.37) v1(112.6,168.61) v1(112.67,154.46) v1(112.72,153.19) v1(112.7,151.62) v1(112.72,150.73) v1(112.85,70.11) v1(112.88,69.55) v1(112.98,172.55) v1(112.98,166.45) v1(113.26,154.46) v1(113.33,153.19) v1(113.28,151.59) v1(113.31,150.73) v1(113.99,44.53) v1(113.99,42.62) v1(114.6,132.24) v1(114.78,124.79) v1(115.52,127.77) v1(116.79,11) v1(117.35,43.82) v1(117.51,84.16) v1(117.91,44.76) v1(118.07,74.38) v1(118.16,70.64) v1(118.35,106.09) v1(118.36,10.04) v1(118.57,40.95) v1(118.82,181.56) v1(119.06,108.05) v1(119.33,173.69) v1(119.51,177.6) v1(119.63,105.14) v1(119.96,173.69) v1(120.12,127.31) v1(120.24,128.98) v1(120.73,41.48) v1(120.79,108.08) v1(120.9,39.38) v1(121.11,47.2) v1(121.23,185.19) v1(121.36,21.31) v1(121.46,104.29) v1(122.5,174.73) v1(123.14,177.5) v1(123.15,71.96) v1(123.52,181.05) v1(123.72,158.68) v1(124.03,169.09) v1(124,40.97) v1(124.13,46.56) v1(124.33,158.68) v1(124.33,157.23) v1(124.33,156.57) v1(124.54,44.66) v1(124.59,169.09) v1(124.77,42.86) v1(124.89,157.25) v1(124.89,156.62) v1(125.14,169.09) v1(125.7,169.09) v1(125.95,86.33) v1(125.95,84.34) v1(126.18,101.91) v1(126.26,169.09) v1(126.44,46.51) v1(126.69,48.34) v1(126.82,169.09) v1(127.46,169.09) v1(127.58,114.76) v1(127.84,134.06) v1(128.9,82.48) v1(129.2,70.13) v1(129.48,99.62) v1(129.64,169.12) v1(129.91,72.12) v1(129.96,38.21) v1(131.01,115.14) v1(130.96,100.92) v1(131.09,160.02) v1(131.1,83.65) v1(131.2,85.75) v1(131.65,115.14) v1(131.72,160.02) v1(132.03,168.99) v1(131.95,124.29) v1(132.05,155.12) v1(132.31,72.16) v1(132.38,160.05) v1(132.51,155.48) v1(132.46,121.57) v1(132.49,121.01) v1(132.56,157.91) v1(132.56,157.33) v1(132.61,119.59) v1(132.56,118.27) v1(132.56,117.33) v1(132.56,116.39) v1(132.56,115.42) v1(132.59,98.76) v1(132.97,164.14) v1(132.97,163.58) v1(132.97,163.02) v1(132.97,162.46) v1(132.97,161.9) v1(132.97,161.34) v1(132.97,160.79) v1(132.97,160.23) v1(133.15,157.25) v1(133.2,72.16) v1(133.8,100.1) v1(134.19,169.24) v1(135.02,101.3) v1(135.46,71.83) v1(135.58,171.4) v1(135.84,86.31) v1(136.17,98.59) v1(137.13,113.69) v1(137.24,124.29) v1(137.28,101.65) v1(137.37,84.06) v1(137.42,71.65) v1(137.81,123.74) v1(137.82,113.67) v1(138,124.29) v1(138.53,181.21) v1(138.53,179.17) v1(138.45,113.67) v1(139.34,158.02) v1(139.37,154.71) v1(139.37,92.23) v1(139.41,69.52) v1(139.52,171.53) v1(139.65,175.34) v1(139.65,174.7) v1(139.93,156.39) v1(139.9,155.83) v1(139.95,158.02) v1(139.95,157.43) v1(140.16,171.53) v1(140.28,175.34) v1(140.28,174.7) v1(140.28,101.83) v1(140.54,158.02) v1(140.49,156.47) v1(140.83,92.32) v1(140.92,185.45) v1(141.31,84.13) v1(142.19,72.85) v1(142.44,113.73) v1(142.36,100.21) v1(142.44,71.84) v1(142.59,92.23) v1(142.57,36.76) v1(142.7,124.29) v1(142.87,185.91) v1(143.14,123.78) v1(143.13,113.67) v1(143.21,82.95) v1(143.24,74.63) v1(143.59,188.39) v1(143.76,113.67) v1(143.77,92.28) v1(144.12,176.76) v1(144.6,36.4) v1(144.73,184.18) v1(144.88,101.65) v1(144.88,100.99) v1(144.88,99.09) v1(145.11,186.24) v1(145.11,173.26) v1(145.13,72.6) v1(145.11,70.06) v1(145.38,92.31) v1(145.59,36.43) v1(146.01,85.07) v1(146.05,87.1) v1(146.11,82.95) v1(146.14,78.77) v1(146.51,174.32) v1(147.01,92.21) v1(147.14,35.77) v1(147.24,72.85) v1(147.42,158.32) v1(147.37,99.57) v1(147.65,173.41) v1(148.04,83.37) v1(148.08,156.72) v1(148.06,156.16) v1(148.13,155.58) v1(148.44,174.78) v1(148.46,92.25) v1(148.69,156.72) v1(148.67,70.95) v1(148.94,157.91) v1(148.85,69.47) v1(148.97,158.52) v1(148.97,157.28) v1(149.68,169.83) v1(149.65,92.26) v1(150.42,173.26) v1(150.41,69.5) v1(150.57,36.66) v1(150.95,170.51) v1(151.29,83.09) v1(151.54,92.21) v1(151.59,71.6) v1(151.79,35.69) v1(152.42,123.98) v1(152.48,172.24) v1(152.82,82.81) v1(153.01,123.98) v1(153.37,92.28) v1(153.49,113.69) v1(153.69,36.3) v1(154,115.73) v1(154.08,172.57) v1(154.13,123.73) v1(154.13,123.17) v1(154.18,121.97) v1(154.18,120.6) v1(154.18,119.18) v1(154.15,117.78) v1(154.18,113.69) v1(154.38,114.33) v1(154.53,71.82) v1(154.52,70.54) v1(154.58,115.73) v1(154.99,114.33) v1(155.01,101.07) v1(155.39,99.37) v1(155.78,172.16) v1(155.78,170.89) v1(156.03,153.37) v1(156.26,101.45) v1(156.59,153.37) v1(156.82,185.96) v1(156.87,183.59) v1(157.17,153.34) v1(157.76,153.34) v1(158.39,153.62) v1(158.39,153.06) v1(158.39,152.5) v1(158.39,151.95) v1(158.39,151.39) v1(158.51,127.78) v1(158.52,127.11) v1(158.6,100.56) v1(158.57,98.83) v1(158.67,124.31) v1(158.95,188.52) v1(158.98,153.62) v1(158.98,153.06) v1(158.98,152.5) v1(158.98,151.95) v1(158.98,151.39) v1(159.51,175.3) v1(160.38,71.16) v1(160.48,186.41) v1(160.45,184.18) v1(160.45,176.81) v1(160.68,128.25) v1(160.65,127.46) v1(160.95,83.62) v1(161.16,174.15) v1(161.23,71.44) v1(161.41,102.16) v1(162.93,127.09) v1(162.89,122.63) v1(162.99,85.04) v1(163.35,83.06) v1(163.93,173.51) v1(163.87,71.07) v1(163.91,33.73) v1(164.21,34.32) v1(164.26,110.09) v1(164.31,104.8) v1(164.41,108.94) v1(164.52,106.02) v1(164.57,33.73) v1(164.79,14.56) v1(164.87,34.32) v1(164.87,13.95) v1(165.18,127.33) v1(165.22,73.67) v1(165.23,33.73) v1(165.43,131.65) v1(165.53,34.32) v1(165.68,86.31) v1(165.68,39.96) v1(165.81,127.33) v1(165.79,104.66) v1(165.94,130.84) v1(165.89,33.73) v1(166.09,110.09) v1(166.19,132.27) v1(166.2,73.02) v1(166.15,70.9) v1(166.19,34.32) v1(166.55,33.73) v1(166.57,130.84) v1(166.57,41.48) v1(166.7,126.83) v1(166.83,132.27) v1(166.85,34.32) v1(167.17,87.98) v1(167.28,150.96) v1(167.26,150.4) v1(167.28,36.93) v1(167.59,173.43) v1(167.87,150.96) v1(167.87,150.4) v1(168.22,132.27) v1(168.38,152.48) v1(168.55,173.43) v1(168.6,57.48) v1(168.6,56.85) v1(168.81,36.81) v1(168.86,132.27) v1(168.86,70.96) v1(168.96,152.48) v1(169.24,57.48) v1(169.24,56.85) v1(169.37,123.78) v1(169.52,152.48) v1(169.87,57.48) v1(169.87,56.85) v1(170.1,152.48) v1(170.11,132.16) v1(170.23,36.83) v1(170.31,41.68) v1(170.46,170.79) v1(170.51,20.27) v1(170.51,16.59) v1(170.49,15.64) v1(170.51,14.81) v1(170.66,152.48) v1(170.67,132.16) v1(170.9,71.15) v1(171.14,20.27) v1(171.58,84.16) v1(171.74,86.24) v1(171.67,19.94) v1(171.79,70.84) v1(171.78,58.5) v1(172.67,58.5) v1(173.3,35.46) v1(173.56,58.5) v1(173.9,82.47) v1(174.19,168.76) v1(174.36,73.18) v1(174.39,70.83) v1(174.78,35.28) v1(175.97,57.74) v1(175.97,57.1) v1(176.36,70.85) v1(176.61,57.74) v1(176.61,57.1) v1(176.81,86.21) v1(176.9,84.1) v1(177.09,74.05) v1(177.24,57.74) v1(177.24,57.1) v1(178,97.74) v1(178.64,97.62) v1(179.32,168.86) v1(179.65,73.74) v1(179.78,92.54) v1(179.78,91.9) v1(180.95,35.87) v1(180.97,37.09) v1(180.97,36.45) v1(182.19,81.11) v1(182.19,80.47) v1(182.19,79.2) v1(183.08,100.66) v1(183.08,13.85) v1(183.08,13.29) v1(183.08,12.7) v1(183.64,100.66) v1(183.64,13.85) v1(183.64,13.29) v1(183.64,12.7) v1(183.84,168.86) v1(184.23,100.66) v1(187,80.26) v1(187.1,100.66) v1(188.54,110.95) v1(188.52,110.19) v1(188.9,168.86) v1(189.18,0.64) v1(189.99,110.37) v1(189.99,109.81) v1(190.07,110.95) v1(190.52,106.51) v1(190.52,105.74) v1(191.08,110.95) v1(192.1,106.51) v1(192.1,105.87) v1(193.47,74.78) v1(193.47,74.12) v1(193.47,73.46) v1(193.5,72.75) v1(193.5,72.09) v1(193.47,71.45) v1(193.47,70.84) v1(193.47,70.06) v1(193.47,69.4) v1(194.13,61.95) v1(194.18,88.04) v1(194.18,67.16) v1(194.16,46.66) v1(194.16,37.42) v1(194.16,32.16) v1(194.16,29.16) v1(194.18,16.36) v1(194.18,9.99) v1(194.39,92.08) v1(194.59,140.69) v1(195.2,168.53) v1(195.58,164.93) v1(195.55,159.92) v1(195.55,154.84) v1(195.58,134.7) v1(195.58,123.98) v1(195.58,119.84) v1(195.55,114.76) v1(195.55,109.48) v1(195.58,104.4) v1(195.55,94.24) v2(105.69,14.52) v2(106.32,14.53) v2(106.98,14.53) v2(110.54,30.18) v2(110.52,18.23) v2(111.12,23.7) v2(111.13,22.56) v2(111.11,20.38) v2(111.76,18.23) v2(112.34,24.72) v2(113.49,19.89) v2(116.42,20.54) v2(117.52,22.81) v2(118.71,28.3) v2(119.15,21.69) v2(121.36,20.45) v2(121.54,34.02) v2(129.36,38.19) v5(2.16,83.77) v5(2.16,82.76) v5(3.07,83.77) v5(3.07,82.76) v5(3.12,37.98) v5(3.12,37.01) v5(3.38,99.85) v5(3.38,98.89) v5(3.37,97.88) v5(3.38,96.85) v5(4.11,38) v5(4.11,37.04) v5(4.27,77.3) v5(4.27,76.3) v5(4.27,75.39) v5(5.1,37.98) v5(5.1,37.01) v5(5.28,82.76) v5(5.41,74.88) v5(5.51,73.93) v5(6.25,37.98) v5(6.25,37.01) v5(6.3,83.77) v5(6.3,82.76) v5(6.43,73.93) v5(7.31,83.77) v5(7.31,82.76) v5(8.33,83.77) v5(8.33,82.76) v5(8.58,150.45) v5(8.97,123.47) v5(8.97,122.56) v5(9.98,146.54) v5(9.98,145.52) v5(9.98,123.47) v5(9.98,122.56) v5(10.9,146.54) v5(10.9,145.52) v5(11,123.45) v5(11,122.53) v5(11.89,146.56) v5(11.89,145.55) v5(14.05,150.32) v5(14.05,149.3) v5(14.3,123.45) v5(14.3,122.53) v5(14.3,121.62) v5(15.06,150.32) v5(15.06,149.3) v5(15.42,123.47) v5(15.44,122.56) v5(15.44,121.62) v5(16.08,150.32) v5(16.08,149.3) v5(16.48,146.54) v5(16.46,123.45) v5(16.46,122.53) v5(16.46,121.62) v5(17.42,146.28) v5(17.47,145.37) v5(18.87,92.66) v5(18.87,82.25) v5(18.87,81.11) v5(18.87,80.09) v5(18.87,78.95) v5(18.87,77.68) v5(19.38,87.84) v5(19.38,86.82) v5(19.38,85.8) v5(19.38,84.79) v5(19.38,83.77) v5(19.89,93.04) v5(20.65,98) v5(20.65,93.75) v5(21.08,97.08) v5(21.16,94.9) v5(21.26,95.99) v5(22.94,160.73) v5(25.73,97.41) v5(25.73,96.4) v5(25.73,95.38) v5(26.75,97.41) v5(26.75,96.4) v5(26.75,95.38) v5(31.44,163.78) v5(31.44,162.87) v5(32.23,176.71) v5(34.24,173.82) v5(34.24,172.55) v5(35.76,163.78) v5(35.76,162.77) v5(40.21,163.78) v5(40.21,162.87) v5(40.21,161.88) v5(41.22,163.78) v5(42.62,69.6) v5(42.62,68.66) v5(42.62,63.96) v5(43.1,171.88) v5(43.08,170.89) v5(43.64,69.6) v5(43.64,68.66) v5(43.64,63.96) v5(44.02,170.89) v5(44.07,171.88) v5(44.65,63.96) v5(45.67,63.96) v5(45.67,50.02) v5(46.51,161.88) v5(46.63,160.73) v5(46.68,51.9) v5(46.68,50.96) v5(46.68,49.99) v5(46.91,162.99) v5(47.22,159.74) v5(48.16,159.13) v5(49.2,158.96) v5(50.44,159.31) v5(50.62,60.79) v5(50.62,59.77) v5(51.28,163.02) v5(51.36,160.25) v5(51.64,60.79) v5(51.64,59.77) v5(51.71,161.65) v5(70.18,73.36) v5(70.18,72.09) v5(70.18,70.82) v5(71.83,71.71) v5(71.98,70.51) v5(72.21,72.85) v5(73.23,73.99) v5(81.36,72.85) v5(81.36,71.58) v5(81.36,70.44) v5(81.48,74.12) v5(81.81,40.97) v5(81.81,40.06) v5(82.78,40.97) v5(82.78,40.06) v5(94.31,42.75) v5(95.33,42.75) v5(97.87,171.02) v5(98.25,172.55) v5(99.64,173.31) v5(101.55,172.93) v5(109.8,164.04) v5(109.8,163.05) v5(109.8,162.13) v5(116.23,147.88) v5(119.96,147.4) v5(120.93,147.4) v5(121.89,147.4) v5(122.86,147.4) v5(123.82,147.4) v5(123.9,163.4) v5(123.9,162.39) v5(123.9,161.37) v5(123.9,160.35) v5(124.51,155.78) v5(124.79,147.4) v5(124.92,163.4) v5(124.92,162.39) v5(124.92,161.37) v5(124.92,160.35) v5(125.75,147.4) v5(125.93,163.4) v5(125.93,162.39) v5(125.93,161.37) v5(125.93,160.35) v5(125.98,139.32) v5(125.96,138.23) v5(125.96,137.06) v5(126.72,147.4) v5(126.97,139.35) v5(127.02,138.23) v5(127,137.09) v5(127.68,147.4) v5(128.65,147.4) v5(129.62,147.4) v5(130.58,147.4) v5(131.09,163.86) v5(131.14,162.89) v5(131.14,161.88) v5(131.14,160.86) v5(131.55,147.4) v5(132.23,163.88) v5(132.18,162.92) v5(132.18,161.9) v5(132.18,160.89) v5(132.51,147.4) v5(132.76,156.59) v5(133.48,147.4) v5(134.44,147.4) v5(135.41,147.4) v5(136.37,147.4) v5(137.34,147.4) v5(137.72,164.47) v5(138.3,147.4) v5(138.43,160.86) v5(138.58,162.61) v5(138.96,160) v5(139.09,164.47) v5(139.09,163.53) v5(139.11,161.75) v5(139.27,147.4) v5(139.62,160.84) v5(139.78,162.56) v5(140.23,147.4) v5(140.28,164.49) v5(140.31,163.48) v5(140.33,161.57) v5(140.33,160.05) v5(141.04,177.66) v5(141.2,147.4) v5(142.16,147.4) v5(142.76,177.33) v5(143.13,147.4) v5(144.09,147.4) v5(144.31,177.91) v5(145.06,147.4) v5(145.28,179.28) v5(146.02,147.4) v5(146.61,159.34) v5(146.73,163.5) v5(146.68,162.46) v5(146.73,161.5) v5(146.79,160.45) v5(146.99,147.4) v5(147.73,162.56) v5(147.67,159.36) v5(147.78,161.57) v5(147.78,160.43) v5(147.95,147.4) v5(148.21,158.45) v5(148.23,157.48) v5(148.74,161.57) v5(148.72,159.31) v5(148.79,160.45) v5(148.92,147.4) v5(148.92,143.11) v5(148.92,137.95) v5(148.97,135.94) v5(149.99,143.11) v5(149.99,137.95) v5(149.99,135.92) v5(156.74,159.39) v5(156.74,158.4) v5(156.74,157.38) v5(156.74,156.39) v5(156.77,155.45) v5(157.76,159.39) v5(157.76,158.4) v5(157.76,157.38) v5(157.76,156.39) v5(157.78,155.45) v5(158.62,150.68) v5(158.72,159.36) v5(158.72,158.37) v5(158.72,157.36) v5(158.72,156.37) v5(158.75,155.43) v5(160.43,156.11) v5(160.43,155.12) v5(162.94,143.54) v5(163.7,137.37) v5(163.73,135.28) v5(163.78,136.35) v5(163.91,143.56) v5(164.9,143.56) v5(165.86,143.56) v5(166.83,143.59) v5(167.46,151.69) v5(167.59,158.27) v5(167.56,157.33) v5(167.56,156.31) v5(167.56,155.3) v5(167.82,143.59) v5(168.38,151.67) v5(168.6,158.27) v5(168.58,157.33) v5(168.58,156.31) v5(168.58,155.3) v5(169.32,151.64) v5(169.62,158.27) v5(169.59,157.33) v5(169.59,156.31) v5(169.59,155.3) v5(170.26,151.62) v5(172.8,141.81) v5(172.8,140.41) v5(172.8,139.02) v5(172.8,137.75) v5(179.65,103.2) v5(179.65,102.19) v5(180.8,104.35) v5(180.8,103.33) v5(180.8,102.31) v5(187.15,53.04) v5(187.15,50.42) v5(187.15,49.48) v5(187.27,91.14) v5(187.27,90.12) v5(187.27,89.11) v5(188.29,91.14) v5(188.29,90.12) v5(188.29,89.11) v5(189.31,91.14) v5(189.31,90.12) v5(192.23,50.52) v5(192.25,49.58) v5(193.24,20.65) v5(193.24,19.64) v5(193.24,18.62) v5(193.24,17.61) v5(193.24,16.59) v6(53.42,103.41) v6(56.51,102.42) v6(56.87,100.38) v6(57.55,103.32) v6(58.04,98.35) v6(58.35,102.43) v6(58.42,82.59) v6(58.59,103.22) v6(58.65,77.4) v6(58.8,100.36) v6(59.05,86.44) v6(59.39,103.22) v6(61.06,77.78) v6(63.12,76.46) v6(63.5,95.23) v6(64.42,119.14) v6(64.46,95.33) v6(64.6,80.28) v6(64.82,77.57) v6(64.97,89.49) v6(65.68,89.46) v6(66.33,120.04) v6(66.45,106.28) v6(66.45,89.48) v6(66.38,88.89) v6(67.27,110.73) v6(68.12,118.11) v6(68.5,84.58) v6(68.56,86.04) v6(68.7,85.13) v6(69.05,83.83) v6(69.85,107.03) v6(69.85,106.33) v6(69.85,104.93) v6(69.85,103.53) v6(69.85,102.13) v6(69.85,100.73) v6(69.85,100.03) v6(69.85,98.63) v6(69.85,97.23) v6(69.85,96.53) v6(69.79,95.13) v6(69.79,93.73) v6(69.85,92.33) v6(69.85,90.93) v6(69.85,90.23) v6(70.2,119.87) v6(70.65,84.68) v6(71.25,96.53) v6(71.19,85.11) v6(71.28,83.92) v6(72.35,119.98) v6(72.36,117.88) v6(72.65,97.23) v6(72.65,96.53) v6(72.65,92.33) v6(72.65,90.93) v6(74.05,100.03) v6(76.85,100.03) v6(76.85,97.23) v6(78.71,117.45) v6(83.15,85.98) v6(83.25,85.38) v6(83.43,82.46) v6(83.83,86.73) v6(83.95,100.73) v6(83.95,100.03) v6(84.2,118.74) v6(84.27,117.62) v6(85.35,107.03) v6(85.35,100.73) v6(85.35,86.08) v6(85.35,85.38) v6(85.53,82.46) v6(85.53,81.91) v6(85.95,84.58) v6(86.05,86.68) v6(86.75,107.03) v6(86.75,103.53) v6(86.75,102.13) v6(86.75,100.73) v6(86.75,100.03) v6(86.75,98.63) v6(86.75,97.23) v6(86.75,96.53) v6(86.75,95.13) v6(86.75,93.73) v6(86.75,92.33) v6(86.75,90.93) v6(86.75,90.23) v6(87.35,85.98) v6(87.35,83.23) v6(87.43,114.74) v6(87.45,85.38) v6(87.63,81.91) v6(88.05,84.58) v6(90.45,119.34) v6(90.95,97.18) v6(90.95,95.08) v6(90.95,92.98) v6(91.44,118.53) v6(91.55,107.78) v6(91.55,105.68) v6(91.55,103.58) v6(91.55,101.48) v6(91.55,99.38) v6(91.55,97.28) v6(91.55,95.18) v6(92.02,93.55) v6(92.09,119.45) v6(92.35,108.38) v6(92.35,106.28) v6(92.35,104.18) v6(92.35,102.08) v6(92.35,97.88) v6(92.28,97.23) v6(93.02,120.15) v6(93.06,97.26) v6(93.29,93.42) v6(94.32,95.84) v6(94.39,90.22) v6(94.5,89.44) v6(95.09,89.44) v6(98.7,94.47) v6(98.7,93.93)
