# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_D0+: length 2.5
  BOTTOM w0.114: C352.1 62.75,156.75 62.49,157 62.49,157.39 62.17,157.71 62.17,158.18 62.3,158.32 CNEDP1.12
DP_D0-: length 2.5
  BOTTOM w0.114: C354.1 61.99,156.75 62.25,157 62.25,157.29 61.92,157.61 61.92,158.19 61.8,158.32 CNEDP1.11
DP_D1+: length 2.4
  BOTTOM w0.114: CNEDP1.9 60.8,158.34 60.7,158.24 60.7,157.06 61.01,156.75 C349.1
DP_D1-: length 2.4
  BOTTOM w0.114: C351.1 60.46,157.06 60.46,158.27 60.3,158.42 CNEDP1.8
DP_D2+: length 2.5
  BOTTOM w0.114: C360.1 59.18,156.75 58.96,156.97 58.96,157.39 59.13,157.56 59.13,158.19 59.3,158.36 CNEDP1.6
DP_D2-: length 2.5
  BOTTOM w0.114: C361.1 58.44,156.75 58.72,157.03 58.72,157.49 58.89,157.66 58.89,158.19 58.91,158.21 58.91,158.29 58.8,158.4 CNEDP1.5
DP_D3+: length 2.5
  BOTTOM w0.114: CNEDP1.3 57.8,158.39 57.54,158.13 57.54,157.56 57.24,157.26 57.24,156.99 C363.1
DP_D3-: length 2.5
  BOTTOM w0.114: C362.1 56.66,156.75 57,157.08 57,157.36 57.3,157.66 CNEDP1.2
DSW_PWROK: length 12.7
  TOP w0.089: U28.AW41 v2(125.37,18.24)
  TOP w0.102: v1(132.41,15.19) 132.41,15.07 132.92,14.56 132.92,13.54 133.17,13.29 R311.2
  L6_IN2 w0.089: v2(125.37,18.24) 125.37,17.91 125.7,17.58 125.7,16.56 127.1,15.17 127.84,15.17 128.37,15.7 131.39,15.7 131.9,15.19 v1(132.41,15.19)
E-USB-N1: length 3.7
  TOP w0.114: L22.4 130.88,172.16 130.88,172.92 D37.2 130.69,172.99 130.5,173.18 130.5,174.78 130.23,175.05 CN23.2
E-USB-N2: length 4.9
  TOP w0.102: CN32.2 110.84,175.05 111.02,174.87 111.02,174.29 110.87,174.14 110.87,173.76 111.9,172.73 D61.2 111.9,172.23 111.56,171.89 111.56,171.81
  TOP w0.114: 111.56,171.81 L65.4
E-USB-P1: length 3.8
  TOP w0.114: L22.1 131.12,172.16 131.12,172.92 D37.1 131.31,172.99 131.52,173.2 131.52,174.44 CN23.3
E-USB-P2: length 4.9
  TOP w0.102: L65.1 112.28,171.7 D61.1 112.55,172.88 112.55,173.48 111.71,174.32 111.41,174.32 111.26,174.47 111.26,174.86 111.45,175.05 CN32.3
EC_3.3VA: length 42.2
  L3_IN1 w0.508: v1(155.4,11.92) 158.92,15.45 v1(161.62,15.45)
  L8_IN3 w0.508: v1(158.42,27.13) 156.76,28.78 146.89,28.78 144.86,26.75 142.57,26.75 141.17,25.35 v1(141.05,25.35)
  BOTTOM w0.203: v1(160.82,27.13) U5.127 ; C142.1 146.25,25.35 146.41,25.51 U5.92 ; U5.26 161.74,17.11 v1(161.62,17.22) ; U5.50 154.42,11.93 C177.1 ; v1(155.62,27.38) U5.114 ; v1(158.42,27.13) U5.121
  BOTTOM w0.381: v1(155.4,11.92) 155.19,11.71 C177.1
  BOTTOM w0.508: C142.1 144.68,25.66 144.22,26.11 142.32,26.11 141.55,25.35 v1(141.05,25.35)
EC_BL_ON: length 202.6
  L3_IN1 w0.089: v1(139.65,48.72) 139.65,46.69 139.24,46.28 139.24,35.51 140.51,34.24 140.51,28.24 142.76,25.99 144.86,25.99 146.63,24.21 146.63,22.05 145.74,21.16 145.74,19.28 v1(145.71,19.25)
  L8_IN3 w0.102: v1(86,157.13) 86,156.21 86.69,155.53 102.21,155.53 105.59,152.15 105.59,130.98 104.9,130.29 104.9,110.14 103.42,108.65 103.42,101.13 100.25,97.96 100.25,90.88 97.16,87.79 97.16,83.09 97.94,82.3 97.94,80.42 100.74,77.62 100.74,72.14 98.17,69.57 98.17,65.08 102.18,61.06 102.18,60.02 102.72,59.49 103.38,59.49 103.54,59.34 v1(103.83,59.34)
  BOTTOM w0.102: U5.76 145.85,19.11 v1(145.71,19.25) ; U29.1 84.93,156.05 v1(86,157.13) ; v1(103.83,59.34) 104.01,59.52 106.18,59.52 107.68,58.02 127.84,58.02 137.29,48.57 139.5,48.57 v1(139.65,48.72)
EC_EXTSMI#: length 46.3
  TOP w0.076: 131.14,23.7 131.13,23.71 130.52,23.71 130.12,23.32 129.27,23.32 129.13,23.18 128.44,23.18 U28.AL47
  TOP w0.102: R116.1 156.49,24.77 v1(156.92,24.34) ; 131.14,23.7 131.9,23.7 132.92,24.72 v1(133.68,24.72)
  L8_IN3 w0.089: v1(156.92,24.34) 156.41,24.84 156.41,27.38 155.65,28.15 147.14,28.15 144.98,25.99 142.7,25.99 140.92,24.21 134.19,24.21 v1(133.68,24.72)
  BOTTOM w0.102: U5.15 161.58,21.51 161.26,21.19 159.47,21.19 156.92,23.74 v1(156.92,24.34)
EC_LANWAKE: length 82
  TOP w0.102: R226.2 98.25,45.16 v1(98.45,45.37)
  L3_IN1 w0.089: v1(147.52,45.22) 147.52,45.16 147.99,44.7 147.99,35.81 150.82,32.97 v1(150.82,31.83)
  BOTTOM w0.102: v1(150.82,31.83) 151.08,31.58 151.08,30.18 151.62,29.64 U5.104 ; v1(98.45,45.37) 98.47,45.38 98.47,51.96 99.01,52.51 99.01,54.18 99.31,54.49 100.48,54.49 100.62,54.34 102.65,54.34 103.04,54.74 125.88,54.74 129.49,51.13 129.49,49.54 134.01,45.01 147.27,45.01 147.42,45.16 147.47,45.16 v1(147.52,45.22)
EC_OVERT_GPU#: length 149.2
  TOP w0.102: v1(77.67,31.66) 78.67,32.66 78.67,35.23 76.28,37.62 76.28,44.59 D51.2 ; Q63.D 166.7,22.18 167.59,21.29 v1(167.59,20.83)
  L8_IN3 w0.089: v1(161.37,20.65) 162.25,19.76 162.25,16.84 162.13,16.72 159.97,16.72 156.92,13.67 156.92,11.03 154.09,8.21 149.55,8.21 148.79,7.45 148.79,5.67 146.68,3.56 119.8,3.56 117.51,1.27 93.28,1.27 92.6,1.95 83.32,1.95 80.82,4.45 80.82,6.51 80.03,7.3 80.03,12.07 78.83,13.27 78.83,30.5 v1(77.67,31.66)
  BOTTOM w0.102: v1(167.59,20.83) 167.49,20.93 165.71,20.93 165.35,20.58 R236.1 164.77,21.11 U5.16 161.82,21.11 v1(161.37,20.65)
EC_PECI: length 147.8
  TOP w0.102: R3129.1 173.43,130 175.56,127.87 v1(177.37,127.87)
  L6_IN2 w0.089: v1(180.03,47.7) 180.03,47.49 181.27,46.25 181.27,45.88 180.97,45.58 180.57,45.58 180.33,45.34 180.33,44.56 179.2,43.43 179.2,33.62 176.79,31.21 157.72,31.21 156.08,32.85 155.53,32.85 155.15,32.47 v1(155.15,32.46)
  L8_IN3 w0.089: v1(177.37,127.87) 183.1,127.87 184.87,126.1 184.87,116.14 186.77,114.24 186.77,111.97 187.55,111.18 187.55,102.85 185.14,100.43 185.14,98.83 184.86,98.56 184.86,77.32 186.12,76.06 186.12,67.34 181.05,62.27 181.05,49.86 180.03,48.85 v1(180.03,47.7)
  BOTTOM w0.102: U5.117 156.82,29.52 155.9,30.43 155.9,31.45 155.15,32.2 v1(155.15,32.46)
EC_PROCHOT: length 155.5
  TOP w0.102: v1(192.53,135.51) R30.2 192.53,136.49 Q1.G
  L6_IN2 w0.089: v1(186.78,44.3) 186.77,44.29 186.77,44.2 186.07,43.5 186.07,41.96 185.86,41.75 185.86,32.22 182.71,29.06 182.1,29.06 181.01,27.97 179.72,27.97 177.39,25.63 172.76,25.63 171.73,24.6 162.17,24.6 161.32,23.75 159.12,23.75 158.5,23.12 153.15,23.12 152.34,22.32 150.81,22.32 149.05,20.56 v1(149.05,20.4)
  L8_IN3 w0.089: v1(192.53,135.51) 194.92,133.12 194.92,99.24 194.32,98.64 194.32,94.5 193.5,93.68 193.5,76.05 190.32,72.87 190.32,64.5 186.03,60.21 186.03,49.29 187.27,48.05 187.27,45.47 186.85,45.05 186.85,44.37 v1(186.78,44.3)
  BOTTOM w0.102: v1(149.05,20.4) 149.05,20.33 148.22,19.51 U5.77
ECSCI#: length 7.3
  BOTTOM w0.102: U5.23 165.36,18.31 165.56,18.11 D30.C 165.56,17.02 164.92,16.39 164.92,15.12 165.56,14.48 R114.1
EDP_AUXN: length 84.4
  TOP w0.076: 120.43,122.89 120.45,122.89 120.48,122.86 122.36,122.86 122.44,122.79 122.44,122.68 U26.B26
  TOP w0.114: 120.43,122.89 118.35,122.89 117.94,123.3 117.94,123.93 115.21,126.66 114.15,126.66 113.66,127.14 113.66,129.44 115.14,130.91 115.14,131.54 115.02,131.65 v2(114.88,131.65)
  BOTTOM w0.114: C345.1 63.77,155.83 64.03,155.58 64.03,154.39 64.81,153.6 99.98,153.6 107.75,145.83 107.75,137.23 112.25,132.72 114.84,132.72 115.14,132.43 115.14,131.77 115.02,131.65 v2(114.88,131.65)
EDP_AUXP: length 84.5
  TOP w0.076: 120.43,123.13 120.45,123.13 120.57,123.02 122.43,123.02 122.59,122.85 122.59,122.76 122.67,122.68 122.84,122.68 U26.C26
  TOP w0.114: 120.43,123.13 118.45,123.13 118.19,123.4 118.19,124.03 115.31,126.9 114.25,126.9 113.91,127.24 113.91,129.34 115.38,130.81 115.38,131.26 v2(115.77,131.65)
  BOTTOM w0.114: C346.1 64.45,155.83 64.27,155.65 64.27,154.49 64.92,153.84 100.08,153.84 107.99,145.93 107.99,137.33 112.35,132.97 114.94,132.97 115.38,132.53 115.38,132.04 v2(115.77,131.65)
EDP_HPD: length 194
  TOP w0.089: U28.AN6 v2(108.25,21.6)
  L8_IN3 w0.102: v2(108.25,21.6) 108.07,21.6 106.35,23.32 101.12,23.32 97.1,27.33 97.1,35.07 98.63,36.6 98.63,40.01 100.44,41.82 100.44,48 100.05,48.38 100.05,50.74 98.75,52.04 98.75,57.4 99.86,58.51 99.86,62.3 97.64,64.51 97.64,69.79 100.21,72.36 100.21,77.41 97.34,80.28 97.34,82.17 96.64,82.87 96.64,88.01 99.73,91.1 99.73,98.18 102.82,101.27 102.82,108.79 104.38,110.35 104.38,130.51 105.07,131.19 105.07,151.93 102.96,154.04 68.75,154.04 67.13,155.65 v1(67.13,156.21)
  BOTTOM w0.114: v3(67.41,154.54) 67.41,155.93 v1(67.13,156.21) 66.78,155.86 R371.2 66.5,156.75 C466.1 66.45,157.25 66.8,157.61 CNEDP1.21
EDP_TXN0: length 83.4
  TOP w0.076: 120.43,125.94 120.53,125.94 120.63,125.84 121.07,125.84 121.54,125.38 123.73,125.38 123.93,125.18 123.93,124.8 124,124.73 124.19,124.73 124.27,124.8 U26.E29
  TOP w0.114: v2(119.71,128.73) 119.63,128.81 119.47,128.81 119.35,128.7 119.35,128.07 119.61,127.82 119.61,126.28 119.95,125.94 120.43,125.94
  BOTTOM w0.114: v2(119.71,128.73) 119.58,128.73 119.33,128.98 119.2,128.98 119.18,129.01 119.18,129.01 118.83,129.35 117.43,130.76 113.28,130.76 107.09,136.95 107.09,145.55 99.7,152.94 63.63,152.94 62.14,154.42 62.14,155.62 C354.2
EDP_TXN1: length 84.8
  TOP w0.076: U26.E28 124.27,123.96 124.03,123.73 v1(123.95,123.73)
  BOTTOM w0.114: v1(123.95,123.73) 124.03,123.8 124.03,124.02 123.87,124.17 123.87,124.35 123.08,125.15 121.68,125.15 120.9,125.92 119.89,125.92 119.38,126.43 119.38,127.87 118.05,129.2 118.05,129.21 117.23,130.03 113.08,130.03 106.42,136.68 106.42,145.28 99.43,152.28 62.51,152.28 60.5,154.29 60.5,155.69 60.35,155.83 C351.2
EDP_TXN2: length 84.5
  TOP w0.076: 120.43,124.57 120.45,124.57 120.5,124.62 121.15,124.62 121.33,124.44 121.97,124.44 122.17,124.63 122.17,124.77 U26.B29
  TOP w0.114: 120.43,124.57 120.12,124.57 119.9,124.79 119.39,124.79 117.8,126.38 117.8,127.63 117.55,127.88 117.55,128.12 v2(117.32,128.35)
  BOTTOM w0.114: v2(117.32,128.35) 117.44,128.46 117.44,128.88 116.95,129.37 112.81,129.37 105.76,136.41 105.76,145.01 99.15,151.62 61.18,151.62 58.62,154.17 58.62,155.58 C361.2
EDP_TXN3: length 86.7
  TOP w0.076: 120.43,123.85 120.53,123.85 120.68,123.7 121.26,123.7 121.36,123.8 122.38,123.8 122.45,123.88 122.45,124.04 122.36,124.13 U26.B28
  TOP w0.114: v2(115.26,128.32) 115.65,128.71 115.66,128.71 115.69,128.74 116.4,128.74 116.79,128.35 116.79,127.97 117.28,127.47 117.28,126.28 119.19,124.37 119.63,124.37 120.16,123.85 120.43,123.85
  BOTTOM w0.114: v2(115.26,128.32) 115.26,128.35 115.01,128.6 112.63,128.6 105.1,136.13 105.1,144.73 98.88,150.96 60.4,150.96 57.05,154.31 57.05,155.69 56.91,155.83 C362.2
EDP_TXP0: length 83.3
  TOP w0.076: 120.43,125.69 120.56,125.69 120.56,125.69 121.01,125.69 121.47,125.23 123.67,125.23 123.78,125.12 123.78,125 123.7,124.92 U26.D29
  TOP w0.114: v2(119.71,129.37) 119.58,129.37 119.11,128.9 119.11,127.97 119.37,127.72 119.37,126.18 119.85,125.69 120.43,125.69
  BOTTOM w0.114: C352.2 62.8,155.84 62.5,155.84 62.38,155.73 62.38,154.52 63.73,153.18 99.8,153.18 107.33,145.65 107.33,137.05 113.38,131 117.53,131 119.28,129.25 119.6,129.25 v2(119.71,129.37)
EDP_TXP1: length 84.8
  TOP w0.076: U26.F28 124.79,124.13 124.61,123.96 v1(124.61,123.75)
  BOTTOM w0.114: C349.2 60.97,155.83 60.74,155.6 60.74,154.39 62.61,152.52 99.53,152.52 106.67,145.38 106.67,136.78 113.18,130.27 117.33,130.27 118.29,129.31 118.29,129.3 119.62,127.97 119.62,126.53 119.99,126.16 121,126.16 121.78,125.39 123.18,125.39 124.12,124.45 124.12,124.27 124.61,123.78 v1(124.61,123.75)
EDP_TXP2: length 84.5
  TOP w0.076: 120.43,124.82 120.45,124.82 120.5,124.77 121.22,124.77 121.4,124.59 121.91,124.59 122.01,124.69 122.01,124.96 121.94,125.04 121.78,125.04 U26.A29
  TOP w0.114: 120.43,124.82 120.22,124.82 120,125.03 119.49,125.03 118.05,126.48 118.05,127.73 117.79,127.98 117.79,128.13 118.01,128.35 v2(118.06,128.35)
  BOTTOM w0.114: v2(118.06,128.35) 117.68,128.73 117.68,128.98 117.05,129.61 112.91,129.61 106.01,136.51 106.01,145.11 99.26,151.86 61.28,151.86 58.86,154.27 58.86,155.46 59.23,155.83 C360.2
EDP_TXP3: length 86.7
  TOP w0.076: U26.C28 122.71,124.13 122.6,124.03 122.6,123.82 122.44,123.65 121.49,123.65 121.37,123.53 120.53,123.53 120.45,123.61 120.43,123.61
  TOP w0.114: 120.43,123.61 120.06,123.61 119.53,124.13 119.09,124.13 117.04,126.18 117.04,127.37 116.55,127.87 116.55,128.25 116.32,128.48 116.01,128.48 115.9,128.36 v2(115.9,128.22)
  BOTTOM w0.114: C363.2 57.29,155.64 57.29,154.41 60.5,151.2 98.98,151.2 105.35,144.83 105.35,136.23 112.73,128.84 115.48,128.84 115.9,128.43 v2(115.9,128.22)
EN1_1.2VS: length 20.5
  TOP w0.254: v1(188.92,115.52) 190.45,115.52 190.91,115.98 R3198.1 191.34,116.28 Q146.D ; R172.1 C113.1 189.71,105.26 v1(189.28,105.26) 189.05,105.49 189.05,106.12 188.29,106.89 187.91,106.89 187.54,107.26 U25.16
  L8_IN3 w0.254: v1(188.92,115.52) 188.92,114.76 187.27,113.11 187.27,112.22 188.04,111.46 188.04,108.41 188.67,107.78 188.67,105.87 v1(189.28,105.26)
EN2_1.2VS: length 7
  TOP w0.254: U25.15 187.04,107.02 187.68,106.38 188.16,106.38 188.54,106 188.54,105.16 189.2,104.5 189.2,103.56 C145.1 R156.2
EN3_NVD: length 3.1
  BOTTOM w0.254: R278.2 19.78,148.6 U32.7
  BOTTOM w0.381: C282.2 19.68,149.74 19.33,149.38 R278.2
EN_+1.0VA: length 3.8
  TOP w0.254: R64.1 90.25,47.6 89.59,46.94 89.58,46.94 C85.2 89.23,46.59 89.23,46.05 88.58,45.41 88.33,45.15 U17.2
EN_+3.3VA: length 2.8
  TOP w0.305: U12.2 176.45,14.45 C84.2 176.44,13.55 R63.1
EN_+5VA: length 244.9
  TOP w0.089: R220.2 R221.1 189.23,99.57 189.69,100.03 v1(191.59,100.03) ; v1(191.18,96.85) 191.18,97.11 C286.1
  TOP w0.102: Q163.D 55.07,62.69 57.61,62.69 v1(58.24,63.33) ; R902.2 94.23,29.49 v1(93.19,28.45)
  TOP w0.254: U9.2 190.18,96.77 C286.1
  L6_IN2 w0.089: v1(175.64,45.46) 172.57,42.39 172.57,40.26 170.38,38.07 161.48,38.07 158.61,35.19 153.17,35.19 144.73,26.75 143.42,26.75 138.6,21.92 135.25,21.92 132.97,19.64 131.14,19.64 130.44,20.33 129.63,20.33 127.37,22.59 125.69,22.59 125.27,23.01 119.02,23.01 118.16,22.15 116.99,22.15 116.89,22.25 112.47,22.25 112.11,21.9 110.2,21.9 107.87,19.57 98.93,19.57 98.18,20.32 97.54,20.32 95.07,22.79 95.07,23.64 95.09,23.66 95.09,23.99 95.07,24.01 95.07,25.1 93.01,27.16 93.01,28.27 v1(93.19,28.45)
  L8_IN3 w0.089: v1(191.59,100.03) 191.59,97.26 v1(191.18,96.85) 190.96,96.63 190.96,85.96 188.72,83.73 188.72,65.82 184.53,61.63 184.53,53.01 183.94,52.43 183.94,48.24 v1(184.23,47.96) ; v1(58.24,63.33) 58.11,63.2 58.11,61.67 60.8,58.99 68.93,58.99 71.14,56.78 71.14,55.96 77.36,49.74 83.64,49.74 85.64,47.73 85.64,31.19 87.16,29.67 92.15,29.67 93.19,28.63 v1(93.19,28.45)
  BOTTOM w0.102: v1(184.23,47.96) 183.72,47.96 183.08,47.32 180.39,47.32 178.52,45.46 v1(175.64,45.46)
EN_VCCIO: length 2.2
  TOP w0.254: R3494.1 C3742.2 100.01,162.04 U18.2
EN_VRA: length 4
  TOP w0.203: U3.37 186.68,150.23 186.89,150.45 187.4,150.45 187.83,150.88 C588.2 R505.2
EXT_Q_KEY0: length 4.7
  TOP w0.102: v4(168.27,10.34) 167.77,9.83 167.77,8.51 167.38,8.13 R313.1 167.33,6.11 CN9.8
EXT_Q_KEY1: length 4.8
  TOP w0.102: v4(165.51,10.34) 165.91,9.93 165.91,8.66 R3702.1 166.6,7.97 CN9.7
FAN0_DETECT: length 210.9
  L3_IN1 w0.089: v1(188.29,41.61) 187.78,41.61 184.23,45.16 184.23,47 185.37,48.14 185.37,58.09 192.05,64.78 192.05,76.13 192.74,76.81 192.74,92.77 193.49,93.52 193.49,102.15 194.14,102.79 194.14,135.84 192.26,137.72 192.26,138.51 193.06,139.31 193.06,155.46 v1(192.7,155.82)
  L6_IN2 w0.089: v1(159.84,17.22) 159.84,17.86 162.76,20.78 165.53,20.78 166.19,20.12 167.44,20.12 168.1,20.78 171.91,20.78 173.05,19.64 176.22,19.64 177.04,20.46 177.04,23.56 179.17,25.69 183.1,25.69 188.58,31.17 188.58,41.32 v1(188.29,41.61)
  BOTTOM w0.102: v1(192.7,155.82) 192.15,155.27 187.65,155.27 v3(187.63,155.25) 187.6,155.27 185.75,155.27 184.86,154.38 177.37,154.38 171.27,148.29 165.78,148.29 164.6,149.47 CNFAN2.2 162.17,149.47 R250.1 ; v1(159.84,17.22) 156.79,14.18 156.01,14.18 155.62,13.79 U5.47
FAN1_DETECT: length 494.6
  TOP w0.102: R254.1 193.06,149.36 192.56,149.86 v1(192.35,149.86)
  L3_IN1 w0.089: v1(188.18,40.7) 188.18,40.86 183.97,45.07 183.97,47.03 185.16,48.23 185.16,58.26 191.85,64.95 191.85,76.21 192.54,76.9 192.54,92.92 193.29,93.67 193.29,102.24 193.93,102.88 193.93,135.66 192.05,137.54 192.05,138.59 192.86,139.4 192.86,149.69 192.68,149.86 v1(192.35,149.86)
  L6_IN2 w0.089: v1(188.18,40.7) 188.04,40.55 188.04,30.91 183.01,25.89 179.08,25.89 176.84,23.65 176.84,20.63 176.12,19.91 173.45,19.91 172.34,21.02 168.48,21.02 168.08,21.42 167.48,21.42 167.08,21.02 162.58,21.02 159.21,17.64 v1(159.21,17.22)
  L8_IN3 w0.089: v1(159.21,17.22) 157.64,18.79 157.56,18.88 156.79,18.88 155.65,17.73 155.65,15.95 155.4,15.7 v1(155.4,14.23) 153.19,12.02 149.17,12.02 147.02,9.86 147.02,5.67 145.72,4.37 119.46,4.37 118.19,3.1 110.79,3.1 110.17,2.47 99.5,2.47 98.75,1.73 93.93,1.73 93.3,2.36 83.49,2.36 81.23,4.62 81.23,6.68 80.44,7.47 80.44,12.24 79.24,13.44 79.24,31.02 77.06,33.2 58.92,33.2 53.58,38.54 44.42,38.54 43.2,37.32 31.95,37.32 30.31,38.96 27.53,38.96 25.73,37.16 13.16,37.16 11.41,38.91 3.16,38.91 2.11,39.97 2.11,45.8 3.38,47.07 3.38,48.21 3,48.59 3,57.86 2.23,58.63 1.47,58.63 1.03,59.06 1.03,117.75 4.65,121.36 4.65,124.79 2.49,126.95 2.49,140.03 4.27,141.81 5.28,141.81 5.79,142.32 5.79,150.32 v1(5.21,150.9)
  BOTTOM w0.102: v1(155.4,14.23) 155.22,14.05 U5.48 ; CNFAN1.2 11.1,149.02 10.36,148.29 8.81,148.29 v3(6.15,150.96) 6.09,150.9 v1(5.21,150.9)
FAN_CTRL0: length 186.3
  TOP w0.102: R248.1 189.18,156.8 190.07,155.91 191.72,155.91 v1(191.87,155.76) 191.87,156.01 193.24,157.39 U16.4
  L3_IN1 w0.089: v1(191.87,155.76) 191.87,154.9 192.35,154.42 192.35,150.72 191.55,149.91 191.55,148.08 192.1,147.53 192.1,139.65 191.03,138.58 191.03,136.08 193.32,133.78 193.32,103.41 192.68,102.77 192.68,99.82 190.58,97.72 190.58,93.9 191.93,92.55 191.93,77.15 191.24,76.47 191.24,65.48 184.56,58.8 184.56,49.55 183,47.99 183,44.3 185.09,42.21 185.57,42.21 v1(185.66,42.12)
  L6_IN2 w0.089: v1(148.41,20.27) 148.41,20.33 150.6,22.52 152.26,22.52 153.07,23.33 158.42,23.33 159.05,23.96 161.24,23.96 162.09,24.81 171.65,24.81 172.68,25.83 177.3,25.83 179.64,28.17 180.92,28.17 182.01,29.26 182.62,29.26 185.66,32.3 v1(185.66,42.12)
  BOTTOM w0.102: v1(148.41,20.27) 148.05,19.91 U5.78
FAN_CTRL1: length 322.6
  L8_IN3 w0.089: v1(6.68,143.08) 6.68,142.7 5.54,141.56 4.3,141.56 2.69,139.95 2.69,127.04 4.85,124.88 4.85,121.19 1.24,117.57 1.24,59.24 1.6,58.88 2.36,58.88 3.2,58.04 3.2,48.68 3.58,48.3 3.58,46.98 2.36,45.77 2.36,40.11 3.24,39.23 11.38,39.23 13.19,37.42 25.7,37.42 27.44,39.16 30.39,39.16 32.03,37.53 42.98,37.53 44.2,38.74 53.66,38.74 59,33.4 77.15,33.4 79.44,31.11 79.44,13.52 80.64,12.32 80.64,9.48 82.01,8.12 82.01,4.12 83.57,2.56 93.48,2.56 94.11,1.93 97.56,1.93 98.3,2.68 110.08,2.68 110.71,3.31 118.11,3.31 119.38,4.58 138,4.58 141.66,8.23 141.66,10.6 145.36,14.3 147.78,14.3 150.18,16.7 150.3,16.7 v1(150.32,16.69)
  BOTTOM w0.102: U14.4 20.04,142.55 20.52,142.07 20.52,140.8 20.4,140.67 17.32,140.67 16.53,139.88 R247.1 15.34,139.88 12.14,143.08 v1(6.68,143.08) ; v1(150.32,16.69) 150.32,16.84 149.68,17.48 149.68,20.53 149.3,20.91 148.48,20.91 148.28,20.71 U5.80
FAN_SPEED: length 12
  BOTTOM w0.508: CNFAN1.3 12.35,147.78 12.67,147.46 12.67,143.79 14.1,142.37 C293.1 16.14,142.37 R230.1 17.3,143.35 v3(17.3,144)
FAN_SPEED1: length 34.7
  TOP w0.508: R214.1 191.97,157.18 v1(191.59,156.8)
  BOTTOM w0.508: v1(191.59,156.8) 190.83,156.04 189.66,156.04 v3(189.64,156.06) 189.61,156.04 184.23,156.04 183.08,154.89 176.99,154.89 170.89,148.8 166.62,148.8 164.7,150.72 CNFAN2.3 162.35,150.72 C305.1
FB_1.2VS: length 5.3
  TOP w0.254: U25.13 186.04,106.85 186.61,106.28 186.61,105.18 186.18,104.75 R134.1 186.21,104.35 R3201.1 187.07,103.46 187.02,103.41 R163.2
FB_+1.0VA: length 4.1
  TOP w0.254: U17.5 86.83,45.28 86.42,45.68 86.42,46.85 R3385.2 C3604.2 R3365.1
FB_+1.8VA: length 11.1
  TOP w0.305: U19.6 60.5,62.67 60.2,62.98 v1(60.2,63.2)
  TOP w0.381: C134.2 R193.1 R219.2 64.21,59.69 v1(64.01,59.9)
  L8_IN3 w0.381: v1(60.2,63.2) 60.2,60.79 60.96,60.02 63.88,60.02 v1(64.01,59.9)
FB_+3.3VA: length 16.5
  TOP w0.305: C1508.2 176.95,12.69 v1(177.11,12.53) 177.49,12.53 177.91,12.95 178.29,12.95 U12.5 ; v1(188.16,9.1) 188.62,8.64 R886.2
  TOP w0.508: R880.1 R886.2
  L3_IN1 w0.305: v1(177.11,12.53) 180.16,9.48 187.78,9.48 v1(188.16,9.1)
FB_+5VA: length 10.8
  TOP w0.254: U9.5 188.68,97.68 188.37,98 R3381.1 188.8,98.38 v1(188.92,98.25) ; C3650.2 R3382.2 192.81,95.68 v1(192.61,95.68)
  BOTTOM w0.254: v1(188.92,98.25) 188.92,98 189.56,97.36 192.35,97.36 192.86,96.85 192.86,95.94 v1(192.61,95.68)
FB_EN_GC6_PCH: length 217.4
  TOP w0.102: v1(93.17,58.83) 93.17,58.75 93.67,58.25 95.02,58.25 R3540.2 95.96,58.75 96.21,58.5 98.04,58.5 98.63,59.08 99.08,59.08 99.37,59.37 Q92.3 ; v1(15.44,102.44) 15.44,103.65 16.13,104.34 16.13,105.47 15.88,105.72 13.85,105.72 13.23,106.34 13.23,107.31 12.64,107.9 10.74,107.9 10.36,108.28 10.36,110.19 9.79,110.76 D16.2 9.47,111.2 10.36,112.09 10.36,112.73 9.98,113.11 Q165.2 ; U28.V48 129.04,29.1 v1(129.11,29.16)
  L3_IN1 w0.089: v1(129.11,29.16) 128.93,29.34 128.93,35.21 130.4,36.68 130.4,46.83 v1(133.04,49.48)
  L8_IN3 w0.089: v1(15.44,102.44) 15.09,102.44 14.5,101.84 14.5,79.13 13.06,77.7 13.06,72.64 14.15,71.55 20.94,71.55 22.7,69.8 27.44,69.8 28.11,69.13 28.11,68.19 28.28,68.02 29.28,68.02 30.53,66.78 52.19,66.78 52.81,66.16 64.05,66.16 64.65,65.56 68.99,65.56 69.16,65.56 71.98,62.74 71.98,61.58 72.75,60.81 72.75,60.65 72.75,59.74 73.74,58.75 73.74,56.31 75.51,54.53 76.36,54.53 77.64,53.25 81.25,53.25 82.06,54.05 86.69,54.05 88.31,55.68 88.31,56.53 89.45,57.67 90.86,57.67 92.02,58.83 v1(93.17,58.83)
  BOTTOM w0.102: v1(93.17,58.83) 93.65,58.35 98.65,58.35 100.43,56.57 102.16,56.57 102.79,57.2 106.19,57.2 107.01,56.39 127,56.39 132.28,51.11 132.28,50.24 v1(133.04,49.48)
FB_REFPLL_AVDD_GPU: length 72.6
  TOP w0.25: v6(67.85,91.82) 67.69,91.98 G1.L17
  TOP w0.3: G1.V11 72.6,88.03 v6(72.6,88.13) ; G1.L38 67.7,106.43 v6(67.8,106.43) ; v6(67.8,100.13) 67.7,100.13 G1.L29 ; G1.AF42 77.7,109.23 v6(77.7,109.13) ; G1.AN42 82.85,109.38 v6(83.1,109.13)
  TOP w0.381: B27.2 C871.1 78.18,76.01 75.48,76.01 74.07,77.42 v1(74.07,79.43)
  L6_IN2 w0.35: v6(77.7,109.13) 77.12,108.56 69.67,108.56 68.35,107.23 68.35,106.98 v6(67.8,106.43) 68.35,105.88 68.35,100.68 v6(67.8,100.13)
  L6_IN2 w0.381: v6(77.7,109.13) 78.41,108.42 82.38,108.42 v6(83.1,109.13)
  L8_IN3 w0.381: v1(74.07,79.43) 74.09,79.45 74.09,84.43 73.91,84.61 72.54,84.61 71.98,85.17 71.98,87.73 72.38,88.13 v6(72.6,88.13) 72.6,88.14 72.06,88.67 69.59,88.67 68.02,90.25 68.02,91.66 v6(67.85,91.82) 67.85,92.04 68.32,92.51 68.32,94.16 68.07,94.41 68.07,95.48 68.43,95.84 68.43,100.59 68.2,100.82 68.2,102.95 68.32,103.08 68.32,105.9 v6(67.8,106.43)
  BOTTOM w0.3: C883.2 68.28,99.65 v6(67.8,100.13) ; v6(83.1,109.13) 83.23,108.99 C849.2
  BOTTOM w0.381: v6(67.8,106.43) 68,106.64 C882.2
  BOTTOM w0.4: C881.2 72.72,88.25 v6(72.6,88.13) ; C819.2 68.32,92.3 v6(67.85,91.82)
FB_VCCIO: length 4
  TOP w0.254: R3375.2 C3669.2 R3366.1 97.13,162.11 97.46,161.78 98.14,161.78 98.51,161.41 U18.5
FB_VREF_PROBE: length 4.3
  TOP w0.1: v6(69.25,111.28) 69.25,111.28 69.55,111.58 G1.P45
  BOTTOM w0.1: TP3.1 69.65,114.28 69.65,111.68 69.25,111.28 v6(69.25,111.28)
FBA_CLK0_N: length 36.7
  TOP w0.127: M41.J11 v1(73.9,138.83) ; G1.AG46 v6(78.95,111.98)
  L3_IN1 w0.109: v6(78.95,111.98) 78.87,111.98 78.45,112.41 78.45,114.97 79.44,115.96 79.44,128.14 78.35,129.23 78.35,129.75 78.12,129.97 77.54,129.97 77.41,130.1 77.41,130.28 77.54,130.41 78.12,130.41 78.35,130.64 78.35,131.03 78.02,131.36 78.02,131.59 78.35,131.92 78.35,134.78 78.68,135.11 78.68,136.31 78.31,136.68 78.07,136.68 77.84,136.92 v1(77.84,137.18) 77.59,136.93 77.31,136.93 76.98,137.27 76.98,138.32 75.87,139.42 75.11,139.42 74.91,139.23 74.51,139.23 v1(73.9,138.83)
  BOTTOM w0.127: v1(77.84,137.18) 78.32,136.69 78.57,136.69 R2735.2
FBA_CLK0_P: length 37.2
  TOP w0.127: M41.J12 v1(74.7,138.83) ; G1.AG45 v6(78.95,111.28)
  L3_IN1 w0.109: v6(78.95,111.28) 78.66,111.28 78.55,111.39 78.55,112.02 78.25,112.32 78.25,115.06 79.24,116.05 79.24,128.05 78.15,129.14 78.15,129.66 78.04,129.77 77.45,129.77 77.21,130.02 77.21,130.37 77.45,130.61 78.04,130.61 78.15,130.72 78.15,130.94 77.82,131.27 77.82,131.67 78.15,132 78.15,134.86 78.48,135.19 78.48,136.13 78.18,136.43 78.06,136.43 77.84,136.2 v1(77.84,135.88) 77.42,136.3 77.42,136.54 76.77,137.18 76.77,138.23 75.79,139.22 75.21,139.22 74.83,138.83 v1(74.7,138.83)
  BOTTOM w0.127: v1(77.84,135.88) 77.84,136.06 78.22,136.45 78.41,136.45 78.74,136.12 R2733.2
FBA_CLK1_N: length 40.5
  TOP w0.127: v6(81.05,111.28) 81.03,111.28 80.75,111.57 G1.AK45 ; v1(86.5,138.83) M42.J11
  L8_IN3 w0.109: v1(86.5,138.83) 86.48,138.88 86.48,138.92 85.97,139.22 85.52,139.22 85.29,139.44 84.1,139.44 83.26,138.61 83.26,137.61 83.09,137.43 v1(82.75,137.43) 82.75,137.41 82.14,136.8 82.14,135.49 82.54,135.08 82.54,131.19 82.77,130.96 83.38,130.96 83.5,130.84 83.5,130.66 83.38,130.53 82.77,130.53 82.54,130.3 82.54,129.91 82.77,129.68 83.62,129.68 83.75,129.56 83.75,129.37 83.62,129.25 82.77,129.25 82.54,129.02 82.54,128.63 82.77,128.4 83.38,128.4 83.5,128.28 83.5,128.09 83.38,127.97 82.77,127.97 82.54,127.74 82.54,123.86 81.39,122.71 81.39,116.44 80.45,115.5 80.45,112.03 81.05,111.43 v6(81.05,111.28)
  BOTTOM w0.127: v1(82.75,137.43) 82.75,137.12 82.51,136.88 82.24,136.88 81.94,137.18 R2736.2
FBA_CLK1_P: length 40.4
  TOP w0.127: v6(81.04,111.98) 80.99,111.92 80.77,111.92 80.69,112 80.69,112.22 G1.AK46 ; M42.J12 86.1,138.95 85.98,138.83 v1(85.71,138.83)
  L8_IN3 w0.109: v1(85.71,138.83) 85.66,138.89 85.56,138.89 85.21,139.24 84.18,139.24 83.47,138.53 83.47,137.52 83.06,137.11 83.06,136.44 v1(82.75,136.13) 82.75,136.79 82.69,136.85 82.48,136.85 82.34,136.72 82.34,135.57 82.75,135.16 82.75,131.28 82.86,131.17 83.46,131.17 83.71,130.92 83.71,130.57 83.46,130.32 82.86,130.32 82.75,130.22 82.75,130 82.86,129.89 83.7,129.89 83.95,129.64 83.95,129.29 83.7,129.04 82.86,129.04 82.75,128.94 82.75,128.72 82.86,128.61 83.46,128.61 83.71,128.36 83.71,128.01 83.46,127.76 82.86,127.76 82.75,127.66 82.75,123.78 81.59,122.62 81.59,116.35 80.65,115.41 80.65,112.15 80.81,111.98 v6(81.04,111.98)
  BOTTOM w0.127: v1(82.75,136.13) 82.75,136.43 82.53,136.64 82.23,136.64 R2734.2
FBA_CMD0: length 33.7
  TOP w0.127: G1.Y51 73.75,115.93 73.42,116.26 73.42,116.61 73.58,116.77 73.58,120.08 73.7,120.2 73.7,121.24 72.37,122.57 71.17,122.57 62.91,130.83 62.91,138.99 64.5,140.58 65.1,140.58 65.25,140.43 66.7,140.43 M41.G3
FBA_CMD1: length 35.4
  TOP w0.127: v1(66.7,139.63) 65.14,139.63 65.09,139.68 64.43,139.68 63.5,138.75 63.5,131.1 71.62,122.97 72.4,122.97 74.04,121.33 74.04,119.97 73.83,119.75 73.83,116.56 G1.Y52
  TOP w0.136: M41.J3 66.75,139.58 v1(66.7,139.63)
  BOTTOM w0.127: v1(66.7,139.63) 66.67,139.66 64.46,139.66 63.7,140.41 R890.2
FBA_CMD2: length 36.6
  TOP w0.127: v1(65.9,138.83) 65.06,138.83 64.8,138.83 64.08,138.12 64.08,131.35 72.03,123.4 72.44,123.4 74.35,121.49 74.35,119.74 74.1,119.49 74.1,114.73 G1.Y49
  TOP w0.136: v1(65.9,138.83) M41.J2
  BOTTOM w0.127: R894.1 63.63,136.55 63.07,137.11 63.07,138.55 63.54,139.03 64.33,139.03 64.52,138.83 65.06,138.83 v1(65.9,138.83)
FBA_CMD3: length 28
  TOP w0.127: G1.AA52 74.45,119.3 74.67,119.52 74.67,121.6 64.67,131.6 64.67,137.4 65.3,138.03 66.7,138.03 M41.L3
FBA_CMD4: length 26.9
  TOP w0.127: M41.K5 69.09,138.04 69.09,132.62 67.52,131.05 67.52,129.67 72.75,124.45 72.75,124.03 75.06,121.72 75.06,119.39 74.72,119.05 74.72,116.69 74.77,116.64 74.77,116.3 74.45,115.98 G1.AA51
FBA_CMD5: length 29
  TOP w0.127: M41.K4 68.3,138.83 68.85,138.83 69.36,138.32 69.36,132.39 68.1,131.14 68.1,129.92 73.38,124.64 73.38,123.91 75.38,121.92 75.38,119.17 75.02,118.82 75.02,116.21 74.8,115.98 74.8,115.58 74.45,115.23 G1.AA50
FBA_CMD6: length 28.5
  TOP w0.127: G1.AC50 75.5,115.43 75.5,115.93 75.28,116.15 75.28,118.57 75.74,119.03 75.74,122.18 74.07,123.85 74.07,124.78 68.7,130.15 68.7,131.23 69.63,132.16 69.63,138.65 69.05,139.23 M41.J5
FBA_CMD7: length 29.1
  TOP w0.127: M41.J4 68.3,139.63 69.35,139.63 69.9,139.08 69.9,131.93 69.3,131.33 69.3,130.38 74.62,125.05 74.62,123.83 76.04,122.41 76.04,118.79 75.5,118.26 75.5,116.27 75.85,115.93 G1.AC51
FBA_CMD8: length 27.6
  TOP w0.127: G1.AC52 75.85,118.1 76.35,118.6 76.35,122.92 75.26,124.02 75.26,125.24 69.88,130.62 69.88,131.42 70.2,131.73 70.2,139.23 69.4,140.03 M41.H5
FBA_CMD9: length 31.1
  TOP w0.127: G1.AC49 76.2,114.73 76.2,118.03 76.66,118.49 76.66,123.44 75.84,124.26 75.84,125.49 70.5,130.83 70.5,139.43 69.5,140.43 68.3,140.43 M41.H4
FBA_CMD10: length 29.9
  TOP w0.127: M41.G12 73.9,140.43 71.6,140.43 70.8,139.63 70.8,131.36 76.42,125.73 76.42,124.59 77.02,124 77.02,118.36 76.55,117.89 G1.AD52
FBA_CMD11: length 28.3
  TOP w0.127: M41.H10 71.85,140.03 71.1,139.28 71.1,131.88 77.03,125.95 77.03,124.62 77.27,124.39 77.27,118.18 76.84,117.75 76.84,116.71 76.88,116.67 76.88,116.31 76.55,115.98 G1.AD51
FBA_CMD12: length 29.7
  TOP w0.127: G1.AD50 76.55,115.23 76.9,115.58 76.9,115.98 77.13,116.21 77.13,117.66 77.56,118.1 77.56,124.55 77.61,124.61 77.61,126.19 72.56,131.24 72.3,131.24 71.4,132.14 71.4,139.08 71.95,139.63 73.1,139.63 M41.H11
FBA_CMD13: length 29.2
  TOP w0.127: M41.K11 73.1,138.83 72.45,138.83 72.35,138.73 71.95,138.73 71.7,138.48 71.7,132.35 72.41,131.64 72.76,131.64 73.92,130.48 74.21,130.48 78.2,126.5 78.2,124.62 77.93,124.35 77.93,118.09 77.38,117.54 77.38,116.14 77.6,115.93 77.6,115.43 G1.AF50
FBA_CMD14: length 27.2
  TOP w0.127: M41.K10 72.3,138.43 72,138.13 72,132.51 72.54,131.97 72.99,131.97 74.02,130.94 74.61,130.94 78.78,126.76 78.78,124.6 78.26,124.08 78.26,118.02 77.61,117.37 77.61,116.27 77.95,115.93 G1.AF51
FBA_CMD15: length 27.9
  TOP w0.127: G1.AF52 77.95,117.24 78.62,117.92 78.62,123.87 79.37,124.62 79.37,127.05 74.99,131.43 74.12,131.43 73.15,132.4 72.62,132.4 72.3,132.73 72.3,137.78 72.55,138.03 73.9,138.03 M41.L12
FBA_CMD16: length 36.4
  TOP w0.127: M42.L3 93.7,140.43 95.1,140.43 95.2,140.53 95.75,140.53 96.08,140.2 96.08,139.91 96.77,139.22 96.77,130.6 95.08,128.91 95.08,127.31 88.73,120.95 85.66,120.95 84.42,119.71 84,119.71 83.35,119.05 83.35,116.81 83.4,116.75 83.4,116.19 83.2,115.98 83.2,115.58 82.85,115.23 G1.AN50
FBA_CMD17: length 35.1
  TOP w0.127: G1.AN51 82.85,115.98 83.17,116.31 83.17,116.65 83.1,116.73 83.1,119.2 83.92,120.03 84.14,120.03 85.53,121.43 88.38,121.43 94.5,127.55 94.5,129.15 96.44,131.1 96.44,138.93 95.75,139.63 v1(93.7,139.63)
  TOP w0.136: M42.J3 v1(93.7,139.63)
  BOTTOM w0.127: R893.2 93.6,139.73 v1(93.7,139.63)
FBA_CMD18: length 32
  TOP w0.127: G1.AN52 82.85,119.32 85.44,121.91 88.04,121.91 93.92,127.79 93.92,129.49 96.13,131.7 96.13,138.3 95.7,138.73 95.49,138.73 95.39,138.83 v1(94.5,138.83)
  TOP w0.136: M42.J2 v1(94.5,138.83)
  BOTTOM w0.127: v1(94.5,138.83) 94.5,138.14 R895.1
FBA_CMD19: length 32.9
  TOP w0.127: M42.G3 93.7,138.03 95.1,138.03 95.8,137.33 95.8,132.3 93.33,129.83 93.33,128.03 87.7,122.4 85.45,122.4 82.5,119.44 82.5,114.73 G1.AM49
FBA_CMD20: length 28.2
  TOP w0.127: G1.AM52 82.15,119.64 85.39,122.88 87.35,122.88 92.75,128.27 92.75,130.85 91.32,132.28 91.32,138.05 M42.H5
FBA_CMD21: length 30.1
  TOP w0.127: M42.H4 92.1,138.83 91.55,138.83 91.05,138.33 91.05,131.97 92.15,130.86 92.15,128.51 87.01,123.36 85.47,123.36 81.82,119.7 81.82,116.26 82.15,115.93 G1.AM51
FBA_CMD22: length 30.1
  TOP w0.127: M42.J5 91.3,139.23 90.75,138.68 90.75,131.48 91.56,130.67 91.56,128.73 86.66,123.84 85.56,123.84 81.58,119.86 81.58,116.15 81.8,115.93 81.8,115.65 82.15,115.3 G1.AM50
FBA_CMD23: length 31.4
  TOP w0.127: M42.J4 92.1,139.63 91,139.63 90.45,139.08 90.45,131.07 90.97,130.54 90.97,128.97 86.19,124.2 85.31,124.2 81.34,120.22 81.34,116.22 81.1,115.98 81.1,115.58 80.75,115.23 G1.AK50
FBA_CMD24: length 29.7
  TOP w0.127: M42.K5 90.9,140.03 90.15,139.28 90.15,130.69 90.38,130.45 90.38,129.22 85.67,124.5 85.23,124.5 81.1,120.37 81.1,116.33 80.75,115.98 G1.AK51
FBA_CMD25: length 30
  TOP w0.127: G1.AK52 80.75,120.4 89.85,129.5 89.85,139.53 90.75,140.43 92.1,140.43 M42.K4
FBA_CMD26: length 33
  TOP w0.127: G1.AJ49 80.4,114.73 80.4,120.88 89.55,130.03 89.55,139.48 88.6,140.43 86.5,140.43 M42.L12
FBA_CMD27: length 28.5
  TOP w0.127: G1.AJ52 80.15,116.59 80.15,121.46 89.25,130.56 89.25,139.28 88.5,140.03 87.7,140.03 M42.K10
FBA_CMD28: length 29.8
  TOP w0.127: M42.K11 87.3,139.63 88.45,139.63 88.95,139.13 88.95,131.08 79.84,121.98 79.84,118.5 79.87,118.48 79.87,116.77 79.72,116.62 79.72,116.26 80.05,115.93 G1.AJ51
FBA_CMD29: length 29.5
  TOP w0.127: M42.H11 87.3,138.83 87.9,138.83 88,138.73 88.4,138.73 88.65,138.48 88.65,131.61 79.59,122.56 79.59,116.86 79.47,116.74 79.47,116.16 79.7,115.93 79.7,115.66 80.05,115.31 G1.AJ50
FBA_CMD30: length 28
  TOP w0.127: M42.H10 88.04,138.43 88.37,138.1 88.37,132.15 79.2,122.98 79.2,118.37 79.36,118.2 79.36,117.05 79.21,116.9 79.21,116.2 79,115.98 79,115.67 78.65,115.32 G1.AG50
FBA_CMD31: length 28.3
  TOP w0.127: G1.AG51 78.65,115.98 78.98,116.32 78.98,117.05 79.11,117.18 79.11,118.06 78.92,118.26 78.92,123.53 88.1,132.71 88.1,137.78 87.85,138.03 86.5,138.03 M42.G12
FBA_D0: length 20.5
  TOP w0.11: G1.U51 71.65,115.93 71.31,116.27 71.31,118.45 71.7,118.83 72.3,118.83 v6(72.35,118.78)
  TOP w0.165: M41.V4 v1(67.5,132.43)
  L3_IN1 w0.135: v1(67.5,132.43) 67.22,132.15 67.22,130.29 67.26,130.25 67.26,129.24 71.9,124.6 71.9,119.23 v6(72.35,118.78)
FBA_D1: length 21.7
  TOP w0.1: v6(71.25,114.78) 71.3,114.73 71.3,114.26 71.65,113.91 G1.U48
  TOP w0.165: M41.V2 v1(65.9,132.43)
  L3_IN1 w0.135: v6(71.25,114.78) 71.25,116.43 71,116.68 71,124.06 65.9,129.16 v1(65.9,132.43)
FBA_D2: length 22.5
  TOP w0.11: v6(72.35,119.38) 71.85,119.38 71.08,118.61 71.08,116.15 71.3,115.93 71.3,115.64 71.65,115.29 G1.U50
  TOP w0.165: v1(67.5,133.23) M41.T4
  L3_IN1 w0.135: v1(67.5,133.23) 67.5,133.03 67.91,132.62 67.91,129.38 73.2,124.09 73.2,121.46 73.03,121.29 73.03,120.06 v6(72.35,119.38)
FBA_D3: length 25.4
  TOP w0.11: G1.U49 72,114.73 72,116.68 71.91,116.77 71.91,117.34 v6(72,117.43)
  TOP w0.165: v1(66.7,133.23) M41.T2
  L3_IN1 w0.135: v6(72,117.43) 72.01,117.44 72.52,117.44 73.05,117.98 73.05,119.2 73.76,119.9 73.76,124.19 68.54,129.41 68.54,132.12 68.72,132.3 68.72,133.45 68.54,133.63 67.09,133.63 v1(66.7,133.23)
FBA_D4: length 27.9
  TOP w0.11: v6(70.17,120.46) 70.63,120 70.63,116.36 70.25,115.98 G1.R51
  TOP w0.165: M41.N4 67.9,136.04 v1(67.5,136.43)
  L3_IN1 w0.135: v6(70.17,120.46) 69.66,120.97 69.66,124.04 63.75,129.95 63.75,135.78 64.8,136.83 67.11,136.83 v1(67.5,136.43)
FBA_D5: length 25.5
  TOP w0.11: v6(70.17,121.09) 70.42,121.09 70.86,120.66 70.86,116.24 70.6,115.98 70.6,115.58 70.25,115.23 G1.R50
  TOP w0.165: M41.N2 66.3,136.04 65.9,135.64 v1(65.9,135.63)
  L3_IN1 w0.135: v6(70.17,121.09) 70.63,121.55 70.63,123.84 64.44,130.03 64.44,134.78 64.89,135.23 65.5,135.23 v1(65.9,135.63)
FBA_D6: length 34.1
  TOP w0.102: G1.R47 v6(70.55,112.67)
  TOP w0.165: M41.M4 v1(67.5,137.23)
  L3_IN1 w0.135: v6(70.55,112.67) 70.14,113.09 70.14,116.34 69.78,116.7 69.78,119.61 69.21,120.18 69.21,121.85 62.06,129 62.06,135.85 63.9,137.69 67.04,137.69 v1(67.5,137.23)
FBA_D7: length 27.5
  TOP w0.102: G1.U46 v6(71.35,112.58)
  TOP w0.165: M41.M2 v1(65.9,136.43)
  L3_IN1 w0.135: v6(71.35,112.58) 71.8,113.03 71.8,116.45 71.43,116.82 71.43,124.3 66.58,129.15 66.58,131.12 66.3,131.4 66.3,136.03 v1(65.9,136.43)
FBA_D8: length 24.6
  TOP w0.165: M41.V11 73.5,132.83 v1(74.14,132.18) ; v6(72.65,111.99) 72.37,112.28 G1.V46
  L8_IN3 w0.135: v1(74.15,132.18) 74.15,130.64 75.69,129.1 75.69,120.53 74.73,119.58 74.73,116.3 73.96,115.53 73.96,111.89 73.7,111.62 73.03,111.62 v6(72.65,111.99)
FBA_D9: length 24.2
  TOP w0.165: v1(75.5,132.43) 75.1,132.83 M41.V13 ; G1.Y45 v6(73.34,111.18)
  L8_IN3 w0.135: v1(75.5,132.43) 75.5,131.02 76.27,130.25 76.32,130.2 76.32,120.28 75.36,119.32 75.36,116.32 74.3,115.26 74.3,111.66 73.82,111.18 v6(73.34,111.18)
FBA_D10: length 22.4
  TOP w0.165: M41.T11 73.5,133.62 73.88,133.23 v1(73.9,133.23)
  TOP w0.17: G1.Y47 73.75,113 v6(73.37,113.37)
  L8_IN3 w0.135: v1(73.9,133.23) 73.9,132.68 73.49,132.27 73.49,130.1 74.99,128.59 74.99,120.62 74.09,119.71 74.09,116.42 73.65,115.98 73.65,113.69 73.37,113.42 v6(73.37,113.37)
FBA_D11: length 27.3
  TOP w0.165: M41.T13 75.1,133.62 75.48,133.23 v1(75.5,133.23)
  TOP w0.17: v6(73.38,112.61) 73.71,112.28 G1.Y46
  L8_IN3 w0.135: v1(75.5,133.23) M41.T13 72.84,133.63 72.69,133.48 72.69,129.7 74.36,128.03 74.36,120.86 73.51,120 73.51,116.56 72.23,115.29 72.23,113.23 72.5,112.96 73.03,112.96 v6(73.38,112.61)
FBA_D12: length 24.2
  TOP w0.11: v6(72.4,121.14) 73.01,120.54 73.01,116.79 72.92,116.71 72.92,116.21 72.7,115.98 72.7,115.69 72.35,115.34 G1.V50
  TOP w0.165: M41.N11 73.5,136.03 v1(73.9,135.63)
  L8_IN3 w0.135: v6(72.4,121.14) 72.74,121.14 73.07,121.47 73.07,126.96 71.48,128.55 71.48,133.91 71.76,134.19 72.8,135.23 73.3,135.23 73.7,135.63 v1(73.9,135.63)
FBA_D13: length 28.1
  TOP w0.165: v6(72.75,112.58) G1.V47 ; v1(74.7,135.63) 74.7,135.63 75.1,136.03 M41.N13
  L8_IN3 w0.135: v1(74.7,135.63) 74.3,135.23 73.7,135.23 73.5,135.03 73.5,134.63 73.3,134.43 72.78,134.43 72.09,133.74 72.09,129.11 73.7,127.49 73.7,121.02 72.81,120.13 72.81,116.64 71.77,115.61 71.77,113 72.08,112.68 72.64,112.68 v6(72.75,112.58)
FBA_D14: length 24.3
  TOP w0.11: G1.U52 71.58,116.55 71.58,117.91 v6(71.95,118.28)
  TOP w0.165: M41.M11 73.83,136.5 v1(73.9,136.43)
  L8_IN3 w0.135: v6(71.95,118.28) 71.95,120.26 71.59,120.61 71.59,122.44 71.18,122.85 71.18,126.32 70.04,127.46 70.04,134.07 72.8,136.83 M41.M11 v1(73.9,136.43)
FBA_D15: length 25.6
  TOP w0.11: v6(72.4,120.58) 72.76,120.22 72.76,116.84 72.7,116.79 72.7,116.34 72.35,115.98 G1.V51
  TOP w0.165: v1(75.5,136.43) M41.M13
  L8_IN3 w0.135: v1(75.5,136.43) 75.1,136.03 72.8,136.03 70.68,133.91 70.68,128.18 71.97,126.89 71.97,121.01 v6(72.4,120.58)
FBA_D16: length 46.5
  TOP w0.165: M41.A11 73.5,146.45 73.25,146.7 v1(73.22,146.7)
  TOP w0.17: G1.AJ44 79.75,110.58 v6(79.7,110.58)
  L8_IN3 w0.135: v1(73.22,146.7) 73.22,146.86 73.95,147.58 78.56,147.58 81.56,144.59 81.56,124.56 80.86,123.86 80.86,116.88 80.14,116.16 80.14,110.97 79.75,110.58 v6(79.7,110.58)
FBA_D17: length 36.1
  TOP w0.1: v6(78.4,116.99) 78.3,116.89 78.3,114.02 G1.AG48
  TOP w0.165: M41.A13 v1(75.45,145.98)
  L8_IN3 w0.135: v6(78.4,116.99) 78.27,117.11 78.27,117.62 79.25,118.59 79.25,125.21 79.77,125.73 79.77,142.86 76.97,145.66 75.77,145.66 v1(75.45,145.98)
FBA_D18: length 46.5
  TOP w0.165: M41.B11 v1(73.1,145.23)
  TOP w0.17: G1.AJ45 v6(79.75,111.28)
  L8_IN3 w0.135: v6(79.75,111.28) 79.35,110.89 78.74,110.89 78.52,111.11 78.52,113.44 78.81,113.73 78.81,113.97 79.66,114.82 79.66,116.57 80.29,117.2 80.29,124.46 80.99,125.16 80.99,144.02 78.25,146.76 77.9,147.1 74.71,147.1 73.87,146.27 73.87,146.13 73.87,146.13 73.87,146 v1(73.1,145.23)
FBA_D19: length 38.4
  TOP w0.165: M41.B13 v1(74.7,145.23)
  TOP w0.17: v6(78.95,114.68) G1.AG49
  L8_IN3 w0.135: v6(78.95,114.68) 78.95,114.73 78.85,114.83 78.85,116.64 79.77,117.56 79.77,125.08 80.37,125.68 80.37,143.66 77.52,146.51 75.31,146.51 74.95,146.15 74.95,145.48 v1(74.7,145.23)
FBA_D20: length 35.3
  TOP w0.165: G1.AF46 77.25,112.28 v6(76.95,111.98) ; M41.E11 v1(73.9,142.83)
  L8_IN3 w0.135: v6(76.95,111.98) 75.94,112.98 75.94,118.97 76.91,119.93 76.91,130.6 76.76,130.75 76.76,138.36 74.47,140.66 73.88,140.66 73.5,141.04 73.5,142.42 73.9,142.81 v1(73.9,142.83)
FBA_D21: length 34.7
  TOP w0.165: M41.E13 75.12,142.43 v1(75.5,142.05)
  TOP w0.17: v6(77.65,112.68) G1.AF47
  L8_IN3 w0.135: v1(75.5,142.05) 75.5,142.04 75.95,142.48 77.36,142.48 79.17,140.68 79.17,126.11 78.63,125.58 78.63,119.16 77.71,118.24 77.71,116.26 78.3,115.67 78.3,114.17 78.05,113.92 78.05,113.08 v6(77.65,112.68)
FBA_D22: length 33.2
  TOP w0.165: M41.F11 v1(73.9,142.03)
  TOP w0.17: v6(77.57,113.87) G1.AF48
  L8_IN3 w0.135: v6(77.57,113.87) 77.65,113.95 77.65,115.53 77.13,116.05 77.13,118.42 78.03,119.33 78.03,125.77 78.57,126.31 78.57,139.56 76.7,141.44 76.51,141.63 74.3,141.63 v1(73.9,142.03)
FBA_D23: length 31.5
  TOP w0.165: M41.F13 75.1,141.59 75.5,141.19 v1(75.5,141.18)
  TOP w0.17: v6(76.84,112.68) G1.AD47
  L8_IN3 w0.135: v6(76.84,112.68) 76.42,113.11 76.42,115.03 76.53,115.14 76.53,118.59 77.37,119.44 77.37,138.25 77.58,138.46 77.58,139.89 76.67,140.8 75.87,140.8 75.5,141.17 v1(75.5,141.18)
FBA_D24: length 37.2
  TOP w0.165: v1(68.3,146.03) 68.25,145.98 M41.A4
  TOP w0.17: G1.AD49 v6(76.85,114.68)
  L3_IN1 w0.135: v1(68.3,146.03) 69.08,146.03 71.72,143.39 71.72,140.39 72.65,139.46 72.65,131.7 77.77,126.57 77.77,118.88 77.48,118.59 77.48,116.19 76.69,115.39 76.69,114.84 v6(76.85,114.68)
FBA_D25: length 40.9
  TOP w0.165: v1(66.7,146.03) 66.7,146.02 66.31,145.63 M41.A2
  TOP w0.17: v6(76.92,113.88) G1.AD48
  L3_IN1 w0.135: v6(76.92,113.88) 76.95,113.9 76.95,114.09 77.7,114.84 77.7,115.43 77.97,115.69 77.97,117.95 78.39,118.37 78.39,127.21 73.5,132.1 73.5,140.18 72.65,141.03 72.65,143.43 69.6,146.48 67.15,146.48 v1(66.7,146.03)
FBA_D26: length 38.2
  TOP w0.165: M41.B4 v1(68.3,145.23)
  TOP w0.17: v6(75.55,112.58) G1.AC46
  L3_IN1 w0.135: v1(68.3,145.23) 68.7,144.83 69.31,144.83 71.12,143.02 71.12,139.61 72.07,138.66 72.07,131.35 77.02,126.4 77.02,116.54 76.31,115.83 76.31,113.46 75.55,112.7 v6(75.55,112.58)
FBA_D27: length 38.1
  TOP w0.165: v1(66.7,145.23) M41.B2
  TOP w0.17: v6(75.55,113.28) G1.AC47
  L3_IN1 w0.135: v6(75.55,113.28) 75.96,113.69 75.96,116.24 76.46,116.75 76.46,126.05 71.53,130.98 71.53,138.12 70.56,139.09 70.56,142.23 68.91,143.88 68.27,143.88 67.9,144.25 67.9,144.63 67.7,144.83 67.1,144.83 v1(66.7,145.23)
FBA_D28: length 36.2
  TOP w0.165: M41.E4 v1(67.5,142.03)
  TOP w0.17: v6(74.75,112.68) G1.AA47
  L3_IN1 w0.135: v1(67.5,142.03) 67.79,142.32 67.79,142.33 67.89,142.43 69.4,142.43 70.05,141.78 70.05,138.65 70.98,137.72 70.98,130.59 75.85,125.72 75.85,116.97 74.38,115.5 74.38,113.05 v6(74.75,112.68)
FBA_D29: length 36.8
  TOP w0.165: M41.E2 v1(66.7,142.03)
  TOP w0.17: v6(74.75,111.98) G1.AA46
  L3_IN1 w0.135: v6(74.75,111.98) 74.57,111.98 74.08,112.47 74.08,116.29 75.31,117.51 75.31,125.31 70.38,130.24 70.38,137.45 69.52,138.31 69.52,141.46 69.35,141.63 67.1,141.63 v1(66.7,142.03)
FBA_D30: length 34.7
  TOP w0.165: M41.F4 v1(68.3,141.23)
  TOP w0.17: v6(74.75,111.28) G1.AA45
  L3_IN1 w0.135: v6(74.75,111.28) 74.39,111.28 73.81,111.87 73.81,113.52 73.65,113.67 73.65,116.69 74.72,117.75 74.72,125.13 69.77,130.08 69.77,137.26 68.76,138.27 68.76,140.77 v1(68.3,141.23)
FBA_D31: length 36.8
  TOP w0.165: M41.F2 v1(66.7,141.23)
  TOP w0.17: G1.Y44 v6(73.45,110.58)
  L3_IN1 w0.135: v1(66.7,141.23) 67.1,140.83 67.7,140.83 68.15,140.38 68.15,138.07 69.15,137.07 69.15,129.79 74.23,124.71 74.23,118.15 72.18,116.1 72.18,111.23 72.53,110.88 73.08,110.88 73.37,110.58 v6(73.45,110.58)
FBA_D32: length 20.5
  TOP w0.165: v1(92.9,132.43) M42.A4 ; G1.AW51 v6(87.35,116.08)
  L8_IN3 w0.135: v1(92.9,132.43) 92.9,122.51 89.97,119.58 89.97,119.09 89.23,118.35 88.35,118.35 86.96,116.96 86.96,116.47 v6(87.35,116.08)
FBA_D33: length 20.8
  TOP w0.165: G1.BA52 v6(88.75,116.78) ; M42.A2 v1(94.5,132.43)
  L8_IN3 w0.129: v1(94.5,132.43) 94.5,130.24 95.27,129.47
  L8_IN3 w0.135: v6(88.75,116.78) 88.75,116.98 89.16,117.4 89.18,117.4 89.2,117.41 91.12,117.41 95.27,121.56 95.27,129.47
FBA_D34: length 21.9
  TOP w0.165: v1(92.9,133.23) 92.85,133.27 M42.B4 ; G1.AW50 v6(87.35,115.38)
  L8_IN3 w0.135: v6(87.35,115.38) 87.24,115.38 87.09,115.54 86.53,116.09 86.53,117.26 88.17,118.9 88.17,119.23 92.27,123.33 92.27,132.6 v1(92.9,133.23)
FBA_D35: length 21.6
  TOP w0.165: v1(94.44,133.29) 94.43,133.29 M42.B2 ; v6(88.15,116.08) G1.BA51
  L8_IN3 w0.135: v1(94.44,133.29) 94.41,133.29 94.1,132.98 94.1,132.14 93.69,131.74 93.69,121.79 90.99,119.08 90.99,118.64 90.57,118.22 89.79,118.22 89.41,117.84 88.67,117.84 88.34,117.51 88.34,116.27 v6(88.15,116.08)
FBA_D36: length 30.7
  TOP w0.165: G1.BA50 v6(88.75,115.38) ; v1(92.9,136.43) 92.9,136.43 92.5,136.03 M42.E4
  L8_IN3 w0.135: v1(92.9,136.43) 92.91,136.43 93.31,136.03 95.6,136.03 96.26,135.37 96.26,130.59 97.37,129.47 97.37,121.47 91.33,115.43 90.18,115.43 89.68,114.93 89.2,114.93 v6(88.75,115.38)
FBA_D37: length 25.5
  TOP w0.165: G1.BB50 v6(89.45,115.38) ; M42.E2 v1(94.5,135.63)
  L8_IN3 w0.135: v6(89.45,115.38) 90.28,116.21 90.97,116.21 96.2,121.45 96.2,129.7 95.76,130.15 95.76,134.98 95.52,135.23 94.9,135.23 v1(94.5,135.63)
FBA_D38: length 35.4
  TOP w0.165: M42.F4 v1(92.9,137.23) ; G1.BA49 v6(88.75,114.08)
  L8_IN3 w0.135: v6(88.75,114.08) 89.15,113.68 90.6,113.68 90.76,113.84 91.8,113.84 98.85,120.88 98.85,129.68 97.25,131.28 97.25,136.24 95.76,137.73 93.4,137.73 v1(92.9,137.23)
FBA_D39: length 32.7
  TOP w0.165: v1(94.45,136.51) 94.13,136.83 M42.F2 ; G1.AW49 v6(87.35,114.08)
  L8_IN3 w0.135: v6(87.35,114.08) 88.1,114.08 88.56,114.54 90.88,114.54 91.04,114.71 91.7,114.71 98.14,121.14 98.14,129.45 96.76,130.82 96.76,135.76 96.35,136.18 95.69,136.84 94.78,136.84 v1(94.45,136.51)
FBA_D40: length 20.7
  TOP w0.165: G1.AV48 v6(86.05,113.98) ; M42.A11 v1(86.5,132.43)
  L3_IN1 w0.135: v1(86.5,132.43) 87.75,131.18 87.75,118.14 86.9,117.29 86.9,114.84 v6(86.05,113.98)
FBA_D41: length 19.6
  TOP w0.165: M42.A13 v1(84.9,132.43) ; G1.AT49 v6(85.25,114.68)
  L3_IN1 w0.135: v1(84.9,132.43) 84.9,132.02 86.07,130.85 86.07,116.27 85.16,115.36 85.16,114.76 v6(85.25,114.68)
FBA_D42: length 25.2
  TOP w0.165: v6(85.25,112.68) G1.AT47 ; v1(86.5,133.23) M42.B11
  L3_IN1 w0.135: v6(85.25,112.68) 84.76,113.17 84.76,116.19 85.63,117.06 85.63,119.66 85.45,119.85 85.45,130.8 84.39,131.86 84.39,133.42 84.59,133.63 86.1,133.63 v1(86.5,133.23)
FBA_D43: length 22
  TOP w0.165: v1(84.9,133.23) M42.B13 ; G1.AT48 v6(85.25,113.98)
  L3_IN1 w0.135: v6(85.25,113.98) 86.5,115.24 86.5,117.65 86.74,117.88 86.74,131.49 86.09,132.14 86.09,132.62 85.89,132.83 85.3,132.83 v1(84.9,133.23)
FBA_D44: length 29
  TOP w0.165: M42.E11 v1(86.5,135.63) ; G1.AT46 v6(85.25,111.98)
  L3_IN1 w0.135: v6(85.25,111.98) 84.4,112.83 84.4,117.12 84.74,117.46 84.74,130.89 83.28,132.35 83.02,132.35 82.9,132.48 82.9,134.55 83.14,134.8 84.17,134.8 84.6,135.23 86.09,135.23 v1(86.5,135.63)
FBA_D45: length 30.1
  TOP w0.11: v6(91.82,118.95) 91.17,118.95 90.28,118.07 88.53,118.07 88.19,117.73 87.05,117.73 86,116.68 86,116.28 86.35,115.93 G1.AV51
  TOP w0.165: M42.E13 84.96,136.36 v1(84.9,136.43)
  L3_IN1 w0.135: v6(91.82,118.95) 91.16,119.61 88.79,121.98 88.79,134.89 87.65,136.03 M42.E13 v1(84.9,136.43)
FBA_D46: length 29.2
  TOP w0.11: G1.AV52 86.35,116.68 87.1,117.43 88.31,117.43 88.68,117.8 91.46,117.8 92.58,118.91 v6(92.58,119.73)
  TOP w0.165: M42.F11 v1(86.5,136.43)
  L3_IN1 w0.135: v1(86.5,136.43) M42.F11 87.65,136.83 89.45,135.03 89.45,122.86 91.93,120.38 v6(92.58,119.73)
FBA_D47: length 34.4
  TOP w0.11: v6(93.42,120.57) 93.42,119.3 91.56,117.44 89.05,117.44 88.79,117.18 87.2,117.18 86.7,116.68 86.7,114.73 G1.AV49
  TOP w0.165: M42.F13 v1(84.9,137.23)
  L3_IN1 w0.135: v1(84.9,137.23) 85.3,137.63 87.65,137.63 90.36,134.92 90.36,123.63 v6(93.42,120.57)
FBA_D48: length 42
  TOP w0.165: v6(79.75,113.98) G1.AJ48 ; M42.V11 v1(86.5,146.03)
  L3_IN1 w0.135: v1(86.5,146.03) 86.5,146.48 85.35,147.62 81.67,147.62 79.09,145.04 79.09,136.62 79.24,136.46 79.24,135.01 79.09,134.86 79.09,129.47 79.9,128.65 79.9,114.14 v6(79.75,113.98)
FBA_D49: length 38.8
  TOP w0.165: M42.V13 85.04,145.89 v1(84.9,146.03)
  TOP w0.17: v6(79.75,112.58) G1.AJ46
  L3_IN1 w0.135: v6(79.75,112.58) 80.67,113.5 80.67,116.13 80.93,116.4 80.93,129.39 80.13,130.19 80.13,142.53 82.83,145.23 82.83,146.04 83.27,146.48 84.45,146.48 v1(84.9,146.03)
FBA_D50: length 41.8
  TOP w0.165: M42.T11 v1(86.5,145.23)
  TOP w0.17: v6(79.75,113.28) G1.AJ47
  L3_IN1 w0.135: v6(79.75,113.28) 80.3,113.83 80.3,129.18 79.61,129.87 79.61,134.76 79.68,134.83 79.68,136.64 79.61,136.72 79.61,142.96 81,144.35 81,145.73 82.39,147.12 85.24,147.12 86.1,146.26 86.1,145.63 v1(86.5,145.23)
FBA_D51: length 34.4
  TOP w0.165: v1(84.9,145.23) M42.T13 ; G1.AK49 v6(81.2,114.83)
  L3_IN1 w0.135: v6(81.2,114.83) 81.2,114.91 81.16,114.94 81.16,115.96 81.4,116.19 81.4,129.76 80.65,130.5 80.65,142.09 83.4,144.83 84.5,144.83 v1(84.9,145.23)
FBA_D52: length 35.8
  TOP w0.165: M42.N11 v1(86.5,142.83)
  TOP w0.17: G1.AM47 v6(81.85,113.28)
  L3_IN1 w0.135: v1(86.5,142.83) 86.1,143.23 83.11,143.23 81.17,141.3 81.17,130.99 81.82,130.34 81.82,116.1 82.15,115.77 82.15,113.58 v6(81.85,113.28)
FBA_D53: length 34.2
  TOP w0.165: M42.N13 v1(84.9,142.03)
  TOP w0.17: v6(81.75,112.53) 81.9,112.53 G1.AM46
  L3_IN1 w0.135: v6(81.75,112.53) 81.8,112.53 82.12,112.86 82.46,113.19 82.46,130.59 81.7,131.35 81.7,141.08 83.05,142.43 84.5,142.43 v1(84.9,142.03)
FBA_D54: length 33.1
  TOP w0.165: M42.M11 v1(86.5,142.03)
  TOP w0.17: v6(83.15,113.98) G1.AN48
  L3_IN1 w0.135: v6(83.15,113.98) 82.75,114.37 82.75,114.84 82.81,114.9 82.81,115.69 82.94,115.82 82.94,131 82.22,131.72 82.22,140.78 83.07,141.63 86.1,141.63 v1(86.5,142.03)
FBA_D55: length 29.5
  TOP w0.165: M42.M13 v1(84.9,141.23)
  TOP w0.17: v6(83.14,114.68) G1.AN49
  L3_IN1 w0.135: v6(83.14,114.68) 83.15,115.53 83.4,115.79 83.4,131.39 82.81,131.99 82.62,132.18 82.62,132.43 82.61,132.44 82.61,132.62 82.62,132.63 82.62,135.19 83.2,135.77 83.2,140.33 83.65,140.78 84.69,140.78 84.9,140.99 v1(84.9,141.23)
FBA_D56: length 42.2
  TOP w0.165: M42.V4 v1(92.9,145.23)
  TOP w0.17: G1.AM44 v6(81.85,110.58)
  L8_IN3 w0.102: v6(81.85,110.58) 82.43,111.16 82.43,113.54 82.35,113.62 82.35,115.63
  L8_IN3 w0.135: v1(92.9,145.23) 92.34,145.79 90.89,145.79 89.1,143.99 89.1,140.66 87.84,139.4 87.84,125.57 82.62,120.35 82.62,116.1 82.36,115.85 82.36,115.65 82.35,115.63
FBA_D57: length 44
  TOP w0.165: M42.V2 v1(94.5,145.23)
  TOP w0.17: G1.AM45 v6(81.85,111.28)
  L8_IN3 w0.102: 82.13,120.72 82.13,113.54 82.22,113.44 82.22,112.98 82.13,112.88 82.13,111.56 v6(81.85,111.28)
  L8_IN3 w0.135: 82.13,120.72 86.28,124.87 86.9,125.49 86.9,137.48 87,137.58 87,139.41 88.55,140.96 88.55,144.33 90.44,146.23 92.85,146.23 93.45,145.63 M42.V2 v1(94.5,145.23)
FBA_D58: length 39.6
  TOP w0.165: M42.T4 v1(92.1,145.23)
  TOP w0.17: v6(83.15,111.28) 82.99,111.44 G1.AN45
  L8_IN3 w0.102: 82.63,115.47 82.63,115.35 82.56,115.29 82.56,113.71 82.65,113.63 82.65,112.74 82.75,112.64 82.75,111.68 v6(83.15,111.28)
  L8_IN3 w0.135: v1(92.1,145.23) 92.1,145.2 91.72,144.83 91,144.83 89.69,143.52 89.69,139.69 88.54,138.54 88.54,125.38 83.06,119.9 83.06,115.9 82.63,115.47
FBA_D59: length 41.9
  TOP w0.165: M42.T2 v1(94.5,144.43)
  TOP w0.17: v6(83.15,111.98) G1.AN46
  L8_IN3 w0.135: v1(94.5,144.43) 94.9,144.03 94.9,141.48 94.93,141.44 94.93,140.13 94.03,139.23 92.68,139.23 92.4,138.95 92.4,138.33 91.58,137.51 91.58,123.67 87.44,119.53 87.44,118.89 86.17,117.61 86.17,114.67 86.46,114.37 86.46,111.8 86.26,111.59 85,111.59 84.92,111.67 83.45,111.67 83.34,111.79 v6(83.15,111.98)
