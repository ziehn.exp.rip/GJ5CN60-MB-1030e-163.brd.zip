# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_PN2: length 119.3
  TOP w0.076: v2(112.2,31.35) 111.87,31.68 U28.N13
  BOTTOM w0.114: R3710.2 12.6,47.07 12.92,47.39 13.03,47.39 13.85,46.57 19.53,46.57 29.24,36.87 44.24,36.87 44.8,37.43 55.82,37.43 58.75,34.5 68.66,34.5 69.67,35.51 69.67,37.04 71.07,38.43 75.51,38.43 76.85,37.09 77.79,37.09 83.76,31.12 93.86,31.12 99.45,36.71 100.48,36.71 100.9,36.29 100.9,33.41 100.9,33.03 101.56,32.36 101.8,32.36 102.42,32.36 102.71,32.65 103.13,32.65 103.73,33.25 107.98,33.25 107.98,33.25 108.46,33.25 109.89,31.82 111.21,31.82 111.4,31.63 111.92,31.63 v2(112.2,31.35)
USB_PN3: length 143.4
  TOP w0.076: 103.96,33.16 106.17,33.16 106.46,32.87 107.29,32.87 U28.K4
  TOP w0.114: 103.96,33.16 103.85,33.16 102.27,34.74 101.8,34.74 100.77,33.71 100,33.71 99.9,33.61 v2(99.77,33.61)
  BOTTOM w0.114: v2(99.77,33.61) 99.74,33.63 98.45,33.63 94.47,29.65 83.15,29.65 77.2,35.6 76.19,35.6 74.88,36.91 72.72,36.91 72.21,36.4 72.21,35.55 69.39,32.73 56.87,32.73 53.65,35.96 45.41,35.96 44.86,35.4 25.69,35.4 22.14,38.94 14.81,38.94 7.39,46.36 4.72,46.36 3.14,47.95 3.14,58.22 4.79,59.87 4.79,66.39 5.27,66.87 7.6,66.87 7.85,67.13 7.85,67.42 8.11,67.68 8.36,67.68 8.55,67.86 CN12.38
USB_PN4: length 157.3
  TOP w0.076: U28.M10 110.37,32.22 110.77,32.62 v2(110.87,32.62)
  TOP w0.114: v2(130.38,168.99) 130.48,168.99 130.88,169.39 130.88,169.6 130.6,169.88 L22.3
  L8_IN3 w0.102: v2(110.87,32.62) 110.79,32.62 110.49,32.31 110.49,32.16 110.62,32.03 111.27,32.03 111.45,32.22 111.45,32.49 112.34,33.38 112.34,35.67 113.59,36.92 113.59,41.64 115.47,43.52 115.47,63.42 114.04,64.85 114.04,70.13 114.76,70.84 114.76,73.1 113.03,74.83 113.03,75.48 111.88,76.63 111.88,86.12 112.78,87.01 112.78,104.6 113.21,105.02 113.21,124.9 113.49,125.18 113.49,130.63 113.38,130.73 113.38,137.45 118.29,142.35 118.29,152.46 121.92,156.09 121.92,164.63 122.6,165.31 129.49,165.31 131.22,167.03 131.22,168.46 130.63,169.04 130.43,169.04 v2(130.38,168.99)
USB_PN5: length 194.4
  TOP w0.076: v1(104.6,32.72) 104.98,32.34 105.48,32.34 105.61,32.47 U28.M1
  TOP w0.114: v2(150.6,172.7) 150.88,172.7 150.89,172.7 151.2,173.01 151.2,173.31 150.88,173.63 L36.3
  L8_IN3 w0.102: v1(104.6,32.72) 104.72,32.85 104.72,33.14 104.59,33.28 103.61,33.28 101.52,35.37 101.52,40.46 102.63,41.57 102.63,42.6 105.31,45.27 105.31,46.36 106.07,47.12 106.07,60.69 105.05,61.7 105.05,68.6 103.99,69.66 103.99,73.43 103.88,73.53 103.88,93.22 104.26,93.59 104.26,108.31 105.74,109.79 105.74,129.94 106.42,130.63 106.42,149.71 109.8,153.09 109.8,159.19 110.44,159.83 110.44,164.64 109.53,165.54 109.53,170.24 111.02,171.73 115.43,171.73 116.58,172.88 121.18,172.88 121.94,173.64 133.82,173.64 134.38,174.2 140.89,174.2 142.29,175.59 148.54,175.59 149.57,174.56 149.57,172.96 150.24,172.29 150.49,172.29 150.6,172.39 v2(150.6,172.7)
USB_PN6: length 35
  TOP w0.089: v2(109.8,33.35) 109.5,33.35 109.28,33.13 U28.K7
  TOP w0.114: v2(117.85,10.37) 117.78,10.37 117.56,10.15 117.56,7.72 117.88,7.39 R139.1
  L8_IN3 w0.102: v2(109.8,33.35) 109.63,33.35 109.52,33.25 109.52,31.85 110.46,30.91 111.35,30.91 111.84,30.43 111.84,29.42 110.77,28.35 110.77,24.78 111.06,24.49 111.56,24.49 113.11,22.94 114.03,22.94 115.78,21.19 116.79,21.19 117.88,20.09 117.88,16.89 116.84,15.84 116.84,12.12 117.41,11.55 117.41,10.73 117.78,10.37 v2(117.85,10.37)
USB_PN7: length 133.9
  TOP w0.076: 103.96,32.06 103.98,32.06 104.06,31.98 105.99,31.98 106.17,32.16 106.72,32.16 107.14,32.58 U28.L4
  TOP w0.114: 103.96,32.06 103.73,32.06 102.51,33.28 102.11,33.28 v2(102.06,33.23)
  BOTTOM w0.114: CN14.3 185.6,47.71 187.47,45.84 189.78,45.84 190.37,45.25 190.37,39.35 189.45,38.43 176.23,38.43 171.02,43.64 133.59,43.64 127.24,50 108.83,50 107.95,49.11 107.95,46.49 101.49,40.04 101.49,37.26 102.02,36.73 102.02,35.6 103.1,34.52 103.1,33.84 102.77,33.51 102.34,33.51 102.28,33.45 v2(102.06,33.23)
USB_PN8: length 130.9
  TOP w0.076: U28.G4 107.36,34.72 107.36,34.57 107.29,34.5 107.12,34.5 107,34.62 106.12,34.62 105.89,34.39 105.64,34.39 105.05,34.98 104.42,34.98 v1(104.03,35.37)
  BOTTOM w0.114: v1(104.03,35.37) 103.91,35.25 103.59,35.25 102.88,35.96 102.88,37.09 102.36,37.61 102.36,39.68 108.81,46.13 108.81,48.75 109.19,49.13 126.88,49.13 133.28,42.73 170.65,42.73 175.81,37.57 189.81,37.57 191.59,39.36 191.59,45.44 190.26,46.78 187.76,46.78 186.49,48.05 186.49,53.81 187.55,54.88 187.75,54.88 188,55.14 CN14.6
USB_PN9: length 146.3
  TOP w0.114: v2(108.15,32.57) 108.15,32.13 U28.M6 ; R3695.2 111.56,170.2 L65.3 111.56,169.64 111.87,169.33 111.87,167.12 111.58,166.83 v2(111.56,166.83)
  L8_IN3 w0.102: v2(111.56,166.83) 111.66,166.83 112.09,166.4 112.09,165.17 111.86,164.94 111.86,159.24 111.23,158.6 111.23,147.53 107.85,144.15 107.85,130.04 107.16,129.35 107.16,109.17 106.88,108.89 106.88,88.95 105.31,87.37 105.31,74.3 105.41,74.2 105.41,70.25 106.48,69.19 106.48,62.29 107.49,61.28 107.49,53.24 107.59,53.13 107.59,49.69 107.52,49.62 107.52,46.56 106.73,45.77 106.73,44.68 104.42,42.37 104.42,39.09 105.15,38.36 105.15,37.33 105.76,36.72 105.76,34.67 107.21,33.23 108.12,33.23 108.41,32.94 108.41,32.72 108.25,32.57 v2(108.15,32.57)
USB_PN12: length 137.1
  TOP w0.076: U28.G1 105.87,34.82 105.87,34.97 105.7,35.13 105.27,35.13 104.29,36.11 104.18,36.11 104.11,36.04 103.98,36.04 103.97,36.03 103.96,36.03
  TOP w0.114: v2(99.87,35.16) 99.87,35.32 100.11,35.57 101.06,35.57 101.52,36.03 103.96,36.03
  BOTTOM w0.114: v2(99.87,35.16) 98.94,35.16 94.16,30.39 83.46,30.39 77.51,36.34 77.1,36.34 76.56,36.34 75.22,37.67 72.04,37.67 71.45,37.08 71.45,36.06 69,33.61 57.86,33.61 54.77,36.69 45.11,36.69 44.55,36.13 25.99,36.13 22.45,39.68 15.11,39.68 10.83,43.96 10.83,44.87 7.48,48.21 5.03,48.21 4.14,49.1 4.14,57.75 5.55,59.16 5.55,63.49 7.92,65.86 CN12.34
USB_PN13: length 178.6
  TOP w0.076: 103.96,31.2 103.97,31.2 103.98,31.21 103.98,31.22 104.05,31.29 105.91,31.29 106.17,31.55 106.46,31.55 U28.N3
  TOP w0.114: v2(100.46,32.31) 101.45,32.31 101.63,32.13 102.43,32.13 103.36,31.2 103.96,31.2
  L3_IN1 w0.102: v2(100.46,32.31) 102.23,32.31 102.97,33.05 102.97,36.35 101.12,38.2 101.12,42.68 100.15,43.64 92.44,43.64 87.69,48.39 87.69,53.62 91.44,57.37 91.44,59.42 93.37,61.35 93.37,65.06 93.88,65.57 93.88,69.37 95.45,70.95 95.96,70.95 96.98,71.96 96.98,78.95 95.31,80.61 95.31,81.57 95.78,82.04 95.78,88.54 100,92.76 100,106.86 106.15,113.01 106.15,128.55 107.18,129.58 107.18,142.37 102.98,146.56 102.98,147.73 98.26,152.45 96.02,152.45 95.79,152.68 88.08,152.68 86.32,154.44 85.37,154.44 81.96,157.84 80.24,157.84 79.48,157.08 79.48,156.34 v2(79.32,156.19)
  BOTTOM w0.114: L16.3 78.8,155.67 79.35,155.11 79.54,155.11 79.81,155.38 79.81,155.7 v2(79.32,156.19)
USB_PN14: length 47.7
  TOP w0.076: U28.E5 107.92,35.5 108.05,35.36 108.25,35.36 108.42,35.53 v2(108.42,35.62)
  TOP w0.114: CNWLAN1.5 80.95,17.94 80.69,18.2 80.69,24.84 86.41,30.56 95.54,30.56 99,34.02 99,36.05 101.78,38.83 102.55,38.83 102.95,38.43 v2(102.95,38.22)
  BOTTOM w0.114: v2(108.42,35.62) 108.36,35.55 108.36,34.65 107.92,34.22 105.93,34.22 103.52,36.63 103.52,38.27 103.41,38.38 103.1,38.38 v2(102.95,38.22)
USB_PP1: length 189.3
  TOP w0.076: U28.J2 106.33,33.61 105.05,33.61 104.91,33.75 104.83,33.75 104.55,34.03 v1(104.38,34.03)
  L8_IN3 w0.102: v1(104.38,34.03) 104.43,34.08 104.43,34.79 104.55,34.9 104.55,35.56 104.16,35.94 103.02,35.94 102.13,36.83 102.13,40.21 103.01,41.08 103.24,41.32 103.24,42.35 105.92,45.02 105.92,46.11 106.68,46.87 106.68,60.94 105.66,61.95 105.66,68.85 104.6,69.92 104.6,73.69 104.49,73.79 104.49,92.86 104.8,93.16 104.8,93.27 104.87,93.34 104.87,108.03 106.35,109.51 106.35,129.69 107.03,130.38 107.03,144.49 110.41,147.87 110.41,158.94 111.05,159.58 111.05,164.89 110.14,165.8 110.14,169.96 111.12,170.95 120.14,170.95 122.2,173 134.23,173 134.66,173.43 140.99,173.43 142.49,174.93 146.82,174.93 147.56,174.2 v2(148.28,174.2)
  BOTTOM w0.114: L34.2 148.95,175.05 149.3,174.7 149.42,174.7 149.51,174.61 149.51,174.14 149.3,173.93 148.65,173.93 148.39,174.2 v2(148.28,174.2)
USB_PP2: length 119.3
  TOP w0.089: v2(112.2,32.22) 112.22,32.22 U28.N15
  BOTTOM w0.114: R3711.2 12.6,47.96 12.92,47.63 13.13,47.63 13.95,46.82 19.63,46.82 29.34,37.11 44.14,37.11 44.7,37.67 55.92,37.67 58.85,34.74 68.56,34.74 69.43,35.61 69.43,37.14 70.97,38.67 75.61,38.67 76.95,37.33 77.89,37.33 83.86,31.37 93.76,31.37 99.35,36.95 100.58,36.95 101.14,36.39 101.14,33.13 101.66,32.6 101.8,32.6 102.32,32.6 102.61,32.89 103.03,32.89 103.63,33.49 108.08,33.49 108.08,33.49 108.56,33.49 109.99,32.06 111.31,32.06 111.5,31.87 111.85,31.87 v2(112.2,32.22)
USB_PP3: length 143.4
  TOP w0.076: U28.K3 106.83,33.02 106.53,33.02 106.23,33.32 104.05,33.32 103.96,33.4
  TOP w0.114: 103.96,33.4 103.92,33.45 103.9,33.45 102.37,34.98 101.7,34.98 101.46,34.74 101.28,34.74 101.04,34.49 101.04,34.32 100.67,33.95 100.15,33.95 99.98,34.12 99.84,34.12 99.72,34.24 99.72,34.46 v2(99.71,34.47)
  BOTTOM w0.114: CN12.37 8.49,67.36 8.41,67.44 8.21,67.44 8.1,67.32 8.1,67.03 7.7,66.63 7.35,66.63 7.23,66.5 6.88,66.5 6.76,66.63 6.42,66.63 6.29,66.5 5.95,66.5 5.83,66.63 5.37,66.63 5.03,66.29 5.03,65.94 5.15,65.82 5.15,65.48 5.03,65.35 5.03,65.01 5.15,64.88 5.15,64.54 5.03,64.42 5.03,59.77 3.38,58.12 3.38,57.65 3.5,57.53 3.5,57.18 3.38,57.06 3.38,56.72 3.5,56.59 3.5,56.25 3.38,56.13 3.38,48.05 4.82,46.6 7.49,46.6 14.91,39.18 22.24,39.18 25.79,35.64 44.76,35.64 45.31,36.2 53.75,36.2 56.97,32.97 69.29,32.97 71.97,35.65 71.97,36.5 72.62,37.15 74.98,37.15 76.29,35.84 77.3,35.84 83.25,29.89 94.37,29.89 98.35,33.87 99.27,33.87 99.72,34.32 99.72,34.46 v2(99.71,34.47)
USB_PP4: length 157.3
  TOP w0.076: U28.L9 110.22,32.78 v2(110.29,32.85)
  TOP w0.114: L22.2 131.4,169.89 131.12,169.61 131.12,169.18 131.32,168.99 v2(131.42,168.99)
  L8_IN3 w0.102: v2(131.42,168.99) 131.42,166.95 129.57,165.1 122.68,165.1 122.12,164.54 122.12,156.01 118.49,152.38 118.49,142.27 113.59,137.37 113.59,130.81 113.69,130.71 113.69,125.1 113.41,124.82 113.41,104.94 112.98,104.51 112.98,86.93 112.09,86.03 112.09,76.71 113.23,75.57 113.23,74.92 114.96,73.19 114.96,70.75 114.25,70.04 114.25,64.93 115.67,63.51 115.67,43.44 113.79,41.56 113.79,36.83 112.55,35.59 112.55,33.29 111.66,32.41 111.66,32.13 111.35,31.83 110.53,31.83 110.29,32.08 v2(110.29,32.85)
USB_PP5: length 194.5
  TOP w0.076: U28.L2 106.23,32.76 106.12,32.87 105.79,32.87 105.64,32.72 v1(105.26,32.72)
  TOP w0.114: v2(151.21,172.29) 151.21,172.67 151.44,172.91 151.44,173.42 151.68,173.66 L36.2
  L8_IN3 w0.102: v2(151.21,172.29) 150.91,172.29 150.7,172.09 150.15,172.09 149.37,172.87 149.37,174.48 148.45,175.39 142.37,175.39 140.98,173.99 134.47,173.99 133.91,173.43 122.03,173.43 121.27,172.67 116.66,172.67 115.52,171.53 111.11,171.53 109.74,170.16 109.74,165.63 110.64,164.72 110.64,159.74 110.01,159.11 110.01,153 106.63,149.63 106.63,130.55 105.94,129.86 105.94,109.7 104.46,108.22 104.46,93.51 104.09,93.14 104.09,73.62 104.19,73.52 104.19,69.75 105.26,68.68 105.26,61.79 106.27,60.77 106.27,47.04 105.51,46.28 105.51,45.19 102.84,42.52 102.84,41.49 101.73,40.38 101.73,35.45 103.7,33.48 104.67,33.48 105.1,33.05 105.1,32.87 v1(105.26,32.72)
USB_PP6: length 35
  TOP w0.076: v2(109.14,33.66) 109.14,33.58 109.02,33.46 U28.K6
  TOP w0.114: v2(117.04,10.37) 117.32,10.09 117.32,7.72 117,7.39 R153.1
  L8_IN3 w0.102: v2(109.14,33.66) 109.14,33.35 109.32,33.18 109.32,31.77 110.38,30.71 111.27,30.71 111.63,30.35 111.63,29.5 110.57,28.43 110.57,24.69 110.97,24.29 111.47,24.29 113.02,22.74 113.94,22.74 115.7,20.98 116.7,20.98 117.68,20.01 117.68,16.97 116.64,15.93 116.64,12.03 117.21,11.46 117.21,10.53 v2(117.04,10.37)
USB_PP7: length 133.9
  TOP w0.076: U28.L3 106.82,32.58 106.82,32.47 106.66,32.31 106.11,32.31 105.93,32.13 104.23,32.13 104.06,32.31 103.96,32.31
  TOP w0.114: 103.96,32.31 103.83,32.31 102.61,33.52 102.49,33.52 102.06,33.95 v2(102.06,34.12)
  BOTTOM w0.114: v2(102.06,34.12) 102.06,33.91 102.21,33.75 102.67,33.75 102.86,33.94 102.86,34.42 101.78,35.5 101.78,36.63 101.25,37.16 101.25,40.14 107.71,46.59 107.71,49.21 108.73,50.24 127.34,50.24 133.69,43.88 171.12,43.88 176.33,38.68 189.35,38.68 190.12,39.45 190.12,45.15 189.68,45.6 187.37,45.6 185.36,47.61 185.36,54.59 184.8,55.15 CN14.2
USB_PP8: length 130.9
  TOP w0.076: U28.G5 107.58,34.56 107.36,34.34 107.06,34.34 106.93,34.47 106.18,34.47 105.95,34.24 105.57,34.24 104.99,34.83 104.03,34.83 103.96,34.76
  TOP w0.114: v1(103.95,34.76) 103.96,34.76
  BOTTOM w0.114: CN14.5 187.2,54.87 186.24,53.91 186.24,47.95 187.66,46.54 190.16,46.54 191.35,45.34 191.35,39.46 189.71,37.81 175.91,37.81 170.75,42.97 133.38,42.97 126.98,49.37 109.09,49.37 108.57,48.85 108.57,46.23 102.12,39.78 102.12,37.51 102.64,36.99 102.64,35.86 103.49,35 103.7,35 v1(103.95,34.76)
USB_PP9: length 146.3
  TOP w0.114: R3694.2 112.36,170.2 L65.2 112.36,169.64 112.11,169.4 112.11,167.06 112.34,166.83 v2(112.42,166.83) ; v2(108.71,32.26) 108.71,32.09 108.97,31.84 U28.N8
  L8_IN3 w0.102: v2(108.71,32.26) 108.71,32.69 108.61,32.79 108.61,33.02 108.2,33.43 107.3,33.43 105.97,34.76 105.97,36.81 105.36,37.42 105.36,38.44 104.62,39.18 104.62,42.29 106.93,44.6 106.93,45.69 107.72,46.47 107.72,49.53 107.8,49.61 107.8,53.22 107.69,53.32 107.69,61.36 106.68,62.38 106.68,69.27 105.61,70.34 105.61,74.29 105.51,74.39 105.51,87.29 107.09,88.86 107.09,108.81 107.36,109.09 107.36,129.27 108.05,129.96 108.05,144.07 111.43,147.45 111.43,158.52 112.06,159.15 112.06,164.85 112.29,165.08 112.29,166.7 v2(112.42,166.83)
USB_PP12: length 137.1
  TOP w0.076: 103.96,36.27 104.34,36.27 105.33,35.28 105.76,35.28 106.15,34.89 U28.G2
  TOP w0.114: 103.96,36.27 101.42,36.27 100.96,35.81 99.85,35.81 v2(99.74,35.92)
  BOTTOM w0.114: CN12.33 8.58,65.36 8.32,65.62 8.02,65.62 7.78,65.38 7.78,65.2 7.53,64.96 7.36,64.96 7.12,64.72 7.12,64.54 6.87,64.3 6.7,64.3 6.45,64.05 6.45,63.88 6.21,63.64 6.04,63.64 5.79,63.39 5.79,59.06 4.38,57.65 4.38,53.69 4.5,53.57 4.5,53.22 4.38,53.1 4.38,52.76 4.5,52.63 4.5,52.29 4.38,52.16 4.38,49.2 5.13,48.45 7.58,48.45 11.07,44.97 11.07,44.06 15.21,39.92 22.55,39.92 26.09,36.38 44.45,36.38 45.01,36.93 54.87,36.93 57.96,33.85 68.9,33.85 71.21,36.16 71.21,37.18 71.94,37.91 75.32,37.91 76.66,36.58 77,36.58 77,36.58 77.61,36.58 83.56,30.63 94.06,30.63 98.84,35.4 99.38,35.4 99.74,35.76 v2(99.74,35.92)
USB_PP13: length 178.6
  TOP w0.076: 103.96,31.44 105.85,31.44 106.11,31.7 106.39,31.7 106.45,31.76 106.45,31.87 U28.N2
  TOP w0.114: v2(100.38,33.2) 100.38,33.12 100.95,32.55 101.55,32.55 101.73,32.37 102.53,32.37 103.46,31.44 103.96,31.44
  L3_IN1 w0.102: v2(80.06,156.21) 79.68,156.59 79.68,156.99 80.32,157.64 81.88,157.64 82.1,157.42 82.1,157.13 82.31,156.92 82.6,156.92 82.81,156.7 82.81,156.41 83.03,156.2 83.32,156.2 83.53,155.98 83.53,155.7 83.75,155.48 84.04,155.48 85.28,154.23 86.24,154.23 87.99,152.48 95.71,152.48 95.94,152.25 98.18,152.25 102.78,147.65 102.78,146.48 106.97,142.29 106.97,129.66 105.94,128.63 105.94,113.09 99.8,106.95 99.8,92.84 95.58,88.62 95.58,82.12 95.11,81.65 95.11,80.53 96.77,78.86 96.77,72.05 95.88,71.15 95.37,71.15 93.67,69.45 93.67,65.65 93.17,65.14 93.17,61.44 91.24,59.51 91.24,57.46 87.49,53.71 87.49,48.3 92.35,43.44 100.07,43.44 100.91,42.59 100.91,38.12 102.77,36.27 102.77,33.13 102.15,32.52 100.97,32.52 100.38,33.1 v2(100.38,33.2)
  BOTTOM w0.114: L16.2 79.64,154.87 80.05,155.28 80.05,155.85 80.06,155.86 v2(80.06,156.21)
USB_PP14: length 47.7
  TOP w0.076: v2(107.65,35.18) 108.35,35.18 U28.F6
  TOP w0.114: CNWLAN1.3 80.45,24.94 86.31,30.8 95.44,30.8 98.75,34.12 98.75,36.15 101.68,39.07 102.85,39.07 v2(102.95,39.16)
  BOTTOM w0.114: v2(102.95,39.16) 102.95,38.99 103.31,38.62 103.51,38.62 103.76,38.37 103.76,36.73 106.03,34.46 107.82,34.46 108.11,34.75 108.11,35.2 107.99,35.33 107.79,35.33 v2(107.65,35.18)
V_DDR_CA_VREF: length 100.4
  TOP w0.254: v1(160.02,111.7) 160.34,112.02 U26.BN13
  L3_IN1 w0.508: v1(170.13,109.93) 171.4,108.66 171.4,104.35 175.34,100.41 175.34,98 178.51,94.82 179.02,94.82 180.73,93.11 180.73,88.98 179.91,88.16 179.91,84.6 180.67,83.84 180.67,81.71 179.59,80.63 v1(179.59,79.83)
  L6_IN2 w0.254: v1(170.13,109.93) 165.75,114.31 161.68,114.31 160.79,113.42 160.79,112.46 v1(160.02,111.7)
  L8_IN3 w0.508: v1(179.59,79.83) 178.98,80.45 132.74,80.45 131.99,79.69 v1(131.99,79.69)
  BOTTOM w0.508: v1(131.99,79.69) 131.99,79.69 132.02,79.72 132.02,79.82 132.49,80.29 C72.2 R37.2
VAD_BATT: length 67.7
  TOP w0.203: R3322.1 64.82,36.86 C3556.2 64.82,35.84 v1(64.67,35.69)
  L8_IN3 w0.203: v1(12.78,48.59) 12.01,47.83 12.01,42.06 13.92,40.15 24.71,40.15 25.6,41.04 30.78,41.04 33.13,43.39 33.32,43.58 48.85,43.58 50.37,42.05 55.95,42.05 56.21,42.05 59.19,39.07 59.19,37.35 60.86,35.69 v1(64.67,35.69)
VB: length 301.1
  TOP w0.102: v1(55.14,63.33) 55.14,63.31 55.53,62.92 55.87,62.92 56.21,63.26 56.21,63.83 54.94,65.1 54.94,68.53 54.56,68.91 53.42,68.91 53.21,69.12 R901.1 52.94,69.69 Q88.3 51.53,69.69 50.22,68.39 Q88.6 49.92,67.13 Q163.G 48.98,66.2 R899.2 ; v1(188.42,159.59) 188.16,159.59 187.8,159.23 Q116.6
  L3_IN1 w0.089: v1(188.42,159.59) 189.9,158.11 191.56,158.11 193.67,156 193.67,138.34 193.53,138.19 193.53,137.43 194.75,136.21 194.75,102.35 194.1,101.71 194.1,93.27 193.35,92.52 193.35,76.56 192.66,75.88 192.66,64.52 185.98,57.84 185.98,46.62 187.78,44.82 v1(187.78,44.18)
  L6_IN2 w0.089: v1(82.24,52.91) 81.61,52.28 81.61,51.64 80.09,50.12 76.15,50.12 75.27,49.23 73.61,49.23 v1(73.35,48.97)
  L8_IN3 w0.089: v1(73.35,48.97) 70.02,52.31 56.42,52.31 55.14,53.58 v1(55.14,63.33) ; v1(82.24,52.91) 82.37,52.78 84.15,52.78 84.61,53.24 87.03,53.24 89.72,55.93 90.27,55.93 92.16,57.82 94.22,57.82 95.06,58.66 95.06,60.65 95.71,61.29 v1(95.83,61.29)
  BOTTOM w0.102: v1(95.83,61.29) 96.09,61.29 96.46,61.67 103.14,61.67 103.4,61.93 105.49,61.93 108.16,59.26 128.85,59.26 132.18,55.93 153.42,55.93 163.34,46.02 171.87,46.02 174.83,43.06 185.67,43.06 186.43,43.82 187.41,43.82 v1(187.78,44.18)
VCHG: length 60.5
  TOP w0.203: C3559.2 62.43,46.82 63.12,46.13 R3318.2 62.61,45.93 v1(62.53,46) ; D28.2 v1(61.35,36.66)
  TOP w0.254: v1(19.38,43.01) 19.76,42.62 R3311.2
  L8_IN3 w0.203: v1(19.38,43.01) 19.51,42.88 27.63,42.88 29.79,45.04 49.22,45.04 50.56,43.7 57.16,43.7 59.51,46.05 62.48,46.05 v1(62.53,46) 62.94,45.6 62.94,38.81 61.35,37.23 v1(61.35,36.66)
VCHG_OUT: length 55.9
  TOP w0.203: v1(59.77,45.55) 59.97,45.55 60.35,45.93 R3307.2 ; v1(67.39,46.56) 67.31,46.64 C3560.2 R3336.2
  TOP w0.254: v1(19.38,42.24) 19,42.62 R3311.1
  L6_IN2 w0.203: v1(59.77,45.55) 61.54,47.32 66.62,47.32 v1(67.39,46.56)
  L8_IN3 w0.203: v1(59.77,45.55) 57.48,43.26 50.49,43.26 49.22,44.53 29.92,44.53 27.76,42.37 19.51,42.37 v1(19.38,42.24)
  vias: v5(15.06,43.13) v5(15.06,42.12) v5(15.06,41.1) v5(15.19,44.15) v5(16.08,43.77) v5(16.08,42.75) v5(16.08,41.74) v5(16.84,41.1) v5(38.94,52.91) v5(38.94,51.9) v5(40.08,52.91) v5(40.08,51.9) v5(41.22,52.91) v5(41.22,51.9) v5(42.37,54.05) v5(42.37,53.04) v5(42.37,51.9)
VCORE_VCCSENSE: length 49.1
  TOP w0.203: U26.AG37 141.16,130.39 v1(141.18,130.39) ; v1(177.62,143.97) 178,143.97 178.13,144.1 R550.1
  L6_IN2 w0.203: v1(147.52,133.68) 147.69,133.52 163.78,133.52 165.03,134.76 172.8,134.76 178.13,140.09 178.13,143.46 v1(177.62,143.97)
  BOTTOM w0.203: v1(147.52,133.68) 147.32,133.68 146.81,134.19 142.29,134.19 141.83,133.73 141.83,132.44 R49.1 142.07,131.66 141.82,131.66 141.45,131.3 141.45,130.66 v1(141.18,130.39)
VCORE_VSSSENSE: length 47.1
  TOP w0.203: R551.1 v1(177.49,143.21) ; v1(140.99,131.17) 140.99,130.91 140.8,130.72 U26.AG38
  L6_IN2 w0.203: v1(147.4,134.27) 147.6,134.27 148.03,133.84 163.65,133.84 164.9,135.08 172.67,135.08 177.81,140.22 177.81,142.89 v1(177.49,143.21)
  BOTTOM w0.203: v1(147.4,134.27) 147.32,134.27 147.01,134.57 142.21,134.57 141.53,133.89 141.53,132.29 R48.2 141.05,131.22 v1(140.99,131.17)
VIDALERT#: length 11.1
  TOP w0.102: v1(164.03,125.81) 164.67,126.44 166.88,126.44 R8.2 ; U26.BH31 157.43,126.14 157.68,126.39 157.68,126.41 v1(157.73,126.46)
  L6_IN2 w0.089: v1(164.03,125.81) 161.62,125.81 161.14,126.29 157.85,126.29 157.73,126.41 v1(157.73,126.46)
VR_READY: length 177.6
  TOP w0.102: v1(189.69,148.67) 189.61,148.59 R794.2 189.18,147.6 189.18,147.15 188.6,146.56 U3.30
  L6_IN2 w0.089: v1(146,16.08) 146.39,16.48 146.39,17.08 147.72,18.4 147.72,18.99 148.59,19.87 149.25,19.87 151.42,22.04 152.36,22.04 153.24,22.92 158.65,22.92 159.27,23.54 161.4,23.54 162.26,24.4 171.82,24.4 172.85,25.43 177.47,25.43 179.81,27.77 181.09,27.77 182.18,28.86 182.79,28.86 186.07,32.13 186.07,41.29 186.77,42 v1(186.77,43.39)
  L8_IN3 w0.089: v1(186.77,43.39) 186.48,43.39 185.51,44.36 185.03,44.36 184.43,44.96 184.43,45.85 183.74,46.54 183.74,52.51 184.12,52.89 184.12,61.81 188.52,66.21 188.52,84.03 190.75,86.26 190.75,97.44 189.81,98.38 189.81,99.16 193.72,103.08 193.72,132.41 190.96,135.17 190.96,139.14 190.37,139.73 190.37,147.98 v1(189.69,148.67)
  BOTTOM w0.102: v1(146,16.08) 146.17,15.91 U5.68
VR_VIDALERT#: length 40.3
  TOP w0.102: R8.1 168.9,126.61 v1(169.49,126.61) ; R691.2 v1(191.46,147.15) R951.2
  BOTTOM w0.102: v1(169.49,126.61) 169.79,126.32 172.29,126.32 181.28,135.31 186.23,135.31 188.73,137.81 191.53,137.81 192.89,139.17 192.89,145.6 191.46,147.02 v1(191.46,147.15)
VR_VIDSCK: length 48.6
  TOP w0.102: v1(157.73,127.11) 157.41,126.79 U26.BH32 ; R785.2 v1(191.46,145.24) R780.2
  L6_IN2 w0.089: v1(157.73,127.11) 157.9,127.11 158.32,126.7 161.49,126.7 161.87,126.32 163.52,126.32 165.3,128.1 v1(171.27,128.1)
  BOTTOM w0.102: v1(191.46,145.24) 191.51,145.24 192.07,144.68 192.07,139.63 191.34,138.89 188.04,138.89 185.37,136.22 180.98,136.22 174.25,129.49 172.03,129.49 171.27,128.73 v1(171.27,128.1)
VR_VIDSOUT: length 51.8
  TOP w0.076: U26.BH29 157.17,124.79 156.89,124.51 v1(156.89,124.37)
  TOP w0.102: R750.2 v1(191.46,146.13) R953.2
  L6_IN2 w0.089: v1(170.26,126.87) 170.04,127.09 168.74,127.09 165.81,124.16 162.89,124.16 162.33,124.72 157.35,124.72 157.01,124.37 v1(156.89,124.37)
  BOTTOM w0.102: v1(191.46,146.13) 192.48,145.11 192.48,139.4 191.46,138.38 188.54,138.38 185.88,135.72 181.05,135.72 172.8,127.46 170.84,127.46 v1(170.26,126.87)
VRA_ADDRP: length 3.5
  TOP w0.203: U3.25 187.95,144.56 189.05,143.46 189.48,143.46 R511.2 R512.1
VRA_GND: length 21
  TOP w0.305: v1(189.81,151.08) 190.14,151.08 190.45,151.39 PJP3210.1
  TOP w0.381: C165.2 176.53,144.17 v1(176.1,144.61) 176.53,145.04 C166.2 ; C156.1 v1(186.89,140.06) R530.2 ; C155.1 v1(185.88,140.13) R529.2 ; v1(187.15,152.35) 186.89,152.1 186.33,152.1 ; C216.2 184.21,152.17 v1(184.48,152.44) 184.48,152.78 C1170.2 R532.2 ; R514.2 190.45,150.45 190.09,150.8 v1(189.81,151.08) 189.56,150.83 C602.1 ; v1(191.46,144.61) 191.21,144.61 190.96,144.35 C656.2 ; v1(176.35,151.84) 178.13,153.62 R559.2 ; C615.1 181.91,152.17 v1(181.58,152.5) 181.35,152.73 C592.1 R803.2 ; R512.2 190.96,142.45 v1(191.46,141.94) 191.08,141.56 R521.2 ; v1(183.84,139.02) 183.72,139.14 C158.2 ; R531.2 v1(187.91,140.13) C157.1
  vias: v1(182.7,148.67) v1(182.7,146.89) v1(182.7,145.11) v1(184.48,148.67) v1(184.48,146.89) v1(184.48,145.11) v1(186.26,148.67) v1(186.26,146.89) v1(186.26,145.11)
VRA_IREF: length 4.1
  TOP w0.203: R521.1 188.92,141.56 188.29,142.19 187.78,142.19 186.68,143.29 U3.24
VRA_PE: length 181.8
  TOP w0.203: v1(192.35,149.3) 192.3,149.36 R515.2 R514.1 C602.2 189.41,149.51 188.37,149.51 187.82,148.96 U3.36
  L3_IN1 w0.089: v1(192.35,149.3) 192.66,149 192.66,139.58 191.85,138.76 191.85,137.37 193.73,135.48 193.73,103.06 193.09,102.41 193.09,99.65 191.78,98.34 191.78,93.37 192.33,92.81 192.33,76.98 191.65,76.3 191.65,65.13 184.96,58.44 184.96,49.26 183.77,48.07 183.77,44.77 v1(183.6,44.61)
  L6_IN2 w0.089: v1(183.6,44.61) 183.61,44.59 183.61,31.69 182.2,30.28 177.98,30.28 175.87,28.17 162.42,28.17 161.61,28.98 149.66,28.98 143.73,23.05 143.73,22.01 143.12,21.4 141.92,21.4 v1(141.81,21.29)
  BOTTOM w0.102: U5.82 145.3,21.51 144.96,21.16 141.93,21.16 v1(141.81,21.29)
VRA_PSYS: length 5.5
  TOP w0.203: R513.1 R803.1 C592.2 182.83,152.56 182.83,150.45 183.08,150.2 U3.46
VRA_STB: length 89.2
  TOP w0.203: v1(142.7,157.91) 142.7,157.71 142.94,157.47 U10.16 ; v1(134.57,157.74) 134.57,157.47 134.9,157.14 U6.16 ; v1(118.92,157.79) 119,157.79 119.24,157.55 U11.16 ; U13.16 152.96,152.01 152.75,152.21 v1(152.75,152.25) ; v1(188.29,148.29) 188.17,148.16 U3.34 ; U4.16 127.32,157.62 v1(127.18,157.76) ; U15.16 162.32,152.03 161.95,152.4 v1(161.95,152.56)
  L3_IN1 w0.254: v1(118.92,157.79) 119.3,158.17 126.77,158.17 v1(127.18,157.76) 130.28,157.76 131.11,158.6 132.74,158.6 133.07,158.27 134.03,158.27 v1(134.57,157.74)
  L8_IN3 w0.254: v1(134.57,157.74) 135.71,158.88 141.73,158.88 v1(142.7,157.91) 145.03,157.91 149.06,153.89 150.99,153.89 152.63,152.25 v1(152.75,152.25) 155.14,154.64 159.87,154.64 v1(161.95,152.56) 162.03,152.48 163.57,152.48 165.48,154.38 187.43,154.38 188.04,153.77 188.04,148.54 v1(188.29,148.29)
VRA_VDD18: length 13.8
  TOP w0.203: R515.1 v1(191.34,151.08) ; U3.26 188.18,144.96 188.8,144.35 C656.1 190.52,143.44 R511.1 190.6,143.41 v1(191.44,143.41)
  BOTTOM w0.203: v1(191.44,143.41) 191.41,143.44 191.24,143.44 190.83,143.84 190.83,150.57 v1(191.34,151.08)
VRA_VIDALERT#: length 2.7
  TOP w0.203: U3.29 188.85,146.16 189.61,146.92 R951.1
VRA_VIDSCLK: length 2.2
  TOP w0.203: U3.27 189.49,145.36 R780.1
VRA_VIDSOUT: length 2.3
  TOP w0.203: U3.28 189.24,145.76 R953.1
VRA_VINSEN: length 6.5
  TOP w0.203: U3.47 182.68,150.16 182.48,150.36 182.48,151.1 C615.2 181.76,151.26 179.4,153.62 R559.1
  TOP w0.254: R558.2 R559.1
VRA_VTEMP: length 83.7
  TOP w0.203: R574.2 133.6,158.04 133.37,157.81 133.35,157.81 v1(133.32,157.79) ; R577.2 151.03,152.3 150.32,152.3 v1(150.29,152.28) ; v1(125.45,156.95) 125.45,157.1 125.6,157.25 R573.2 ; v1(140.56,157.43) 140.61,157.38 R575.2
  TOP w0.254: v1(116.81,157.38) 116.86,157.43 R576.2 ; v1(185.62,153.88) 184.61,154.89 R533.2 ; R578.2 159.87,152.1 v1(159.82,152.15)
  L3_IN1 w0.254: v1(125.45,156.95) 125.45,157.38 125.09,157.74 120.47,157.74 120.01,157.28 116.92,157.28 v1(116.81,157.38)
  L8_IN3 w0.254: v1(125.45,156.95) 125.45,157 127.18,158.73 132.59,158.73 133.32,157.99 v1(133.32,157.79) 134.24,156.87 140.11,156.87 140.56,157.33 v1(140.56,157.43) 144.88,157.43 150.04,152.28 v1(150.29,152.28) 150.32,152.3 151.87,152.3 152.4,151.77 153.03,151.77 155.52,154.26 159.05,154.26 159.82,153.5 v1(159.82,152.15) 159.9,152.06 164.12,152.06 165.81,153.75 185.5,153.75 v1(185.62,153.88)
VRACPU_CS1: length 61.1
  TOP w0.203: v1(179.91,146.64) 179.65,146.64 179.35,146.94 R522.2 179.45,147.12 180.27,147.12 180.51,147.36 U3.5 ; v1(127.15,156.75) 127.23,156.82 U4.18
  L8_IN3 w0.254: v1(179.91,146.64) 179.63,146.64 178.28,147.98 178.28,148.36 178.03,148.62 151.61,148.62 146.91,153.32 130.58,153.32 v1(127.15,156.75)
VRACPU_CS2: length 53.2
  TOP w0.203: v1(180.03,147.58) 179.67,147.58 R523.2 179.49,148.05 180.34,148.05 180.63,147.76 U3.4 ; v1(134.49,156.37) 134.57,156.37 134.59,156.34 U6.18
  L8_IN3 w0.254: v1(134.49,156.37) 137.06,153.8 147.09,153.8 151.84,149.05 178.64,149.05 180.03,147.65 v1(180.03,147.58)
VRACPU_CS3: length 45
  TOP w0.203: v1(142.44,156.57) 142.54,156.67 U10.18 ; U3.3 180.67,148.16 180.44,148.39 179.75,148.39 R524.2 179.48,148.92 v1(180.03,148.92)
  L8_IN3 w0.254: v1(142.44,156.57) 144.65,154.36 147.24,154.36 152.09,149.51 179.45,149.51 v1(180.03,148.92)
VRACPU_CS4: length 71
  TOP w0.203: U3.2 181.03,148.56 180.47,149.13 180.47,149.61 180.26,149.81 R525.2 ; U11.18 119.25,156.75 119.06,156.94 118.63,156.94 v1(118.49,156.8)
  TOP w0.254: R525.2 178.84,150.32 178,150.32 177.58,149.9 177.58,148.17 v1(177.47,148.06)
  L3_IN1 w0.254: v1(118.49,156.8) 122.35,152.94 v1(125.12,152.94)
  L8_IN3 w0.254: v1(177.47,148.06) 177.34,148.19 151.38,148.19 146.63,152.94 v1(125.12,152.94)
VRACPU_CSUMA: length 13.2
  TOP w0.203: v1(184.35,142.7) 184.28,142.77 U3.18
  TOP w0.508: R525.1 R524.1 R523.1 R522.1 v1(177.62,147.02)
  L3_IN1 w0.254: v1(184.35,142.7) 181.94,142.7 v1(177.62,147.02)
VRACPU_IMON: length 5.9
  TOP w0.203: U3.21 185.48,143.08 185.88,142.69 C155.2 186.05,141.63 186.38,141.3 186.38,139.07 R529.1
VRACPU_PWM1: length 67.3
  TOP w0.203: v1(184.2,150.6) 184.28,150.52 U3.43
  TOP w0.254: v1(124.94,158.65) 125.07,158.78 R566.2
  L3_IN1 w0.254: v1(124.94,158.65) 130.48,158.65 130.9,159.07 132.9,159.07 133.32,158.65 134.34,158.65 136.4,156.59 136.4,155.22 137.96,153.66 146.33,153.66 151.8,148.19 175.54,148.19 177.42,150.07 183.69,150.07 184.05,150.42 184.05,150.45 v1(184.2,150.6)
VRACPU_PWM1_R: length 1.8
  TOP w0.203: 127.46,158.25 127.68,158.02 U4.15
  TOP w0.254: R566.1 127.02,158.25 127.46,158.25
VRACPU_PWM2: length 59.8
  TOP w0.203: v1(184.99,151.21) 184.68,150.9 U3.42
  TOP w0.254: v1(133.76,159.52) 134.06,159.21 R567.2
  L3_IN1 w0.254: v1(133.76,159.52) 135.03,159.52 135.41,159.13 142.32,159.13 152.42,149.02 172.85,149.02 176.27,152.45 180.57,152.45 181.56,151.46 184.73,151.46 v1(184.99,151.21)
VRACPU_PWM2_R: length 1.7
  TOP w0.203: 135.05,157.99 135.05,157.66 135.17,157.54 U6.15
  TOP w0.254: R567.1 134.97,158.07 135.05,157.99
VRACPU_PWM3: length 54.6
  TOP w0.203: v1(185.5,151.46) 185.5,150.96 185.08,150.54 U3.41
  TOP w0.254: R568.2 v1(141.17,159.64)
  L3_IN1 w0.254: v1(185.5,151.46) 185,151.96 183.48,151.96 182.32,153.11 176.1,153.11 172.39,149.41 153.03,149.41 152.25,150.19 152.25,151.26 151.41,152.1 151.15,152.1 150.44,152.81 149.33,152.81 142.49,159.64 v1(141.17,159.64)
VRACPU_PWM3_R: length 1.9
  TOP w0.203: 143.08,158.3 143.15,158.22 143.15,157.99 143.27,157.87 U10.15
  TOP w0.254: 143.08,158.3 142.87,158.5 142.37,158.5 142.16,158.3 R568.1
VRACPU_PWM4: length 78.6
  TOP w0.203: U3.40 185.48,150.4 186,150.93 v1(186,151.21)
  TOP w0.254: R569.2 117.4,158.35 117.68,158.07 v1(117.93,158.07)
  L3_IN1 w0.254: v1(117.93,158.07) 119.05,159.18 130.32,159.18 130.68,159.54 133.02,159.54 133.53,159.03 134.77,159.03 136.93,156.87 136.93,155.5 138.33,154.1 146.4,154.1 151.92,148.59 175.18,148.59 177.37,150.78 177.62,150.78 178.33,151.49 180.57,151.49 180.97,151.08 184.43,151.08 184.94,150.57 185.5,150.57 186,151.08 v1(186,151.21)
VRACPU_PWM4_R: length 1.8
  TOP w0.203: U11.15 119.45,157.95 119.07,158.32
  TOP w0.254: 119.07,158.32 118.72,158.32 R569.1
VRACPU_VDIFF: length 3.4
  TOP w0.203: U3.6 180.88,146.96 179.87,145.95 C438.2 R553.2
VRACPU_VFB: length 4.5
  TOP w0.203: U3.7 180.91,146.56 179.53,145.18 179.53,145.16 C438.1 R553.1 R554.2
VRACPU_VORTN: length 3.7
  TOP w0.203: U3.9 181.02,145.76 180.16,144.91 180.16,144.02 R551.2
VRACPU_VOSEN: length 3.3
  TOP w0.203: R550.2 179.86,144.61 179.86,145.08 180.94,146.16 U3.8
VRACPU_VTEMP1: length 1.6
  TOP w0.203: U4.17 126.85,157.22 R573.1
VRACPU_VTEMP2: length 1.6
  TOP w0.203: R574.1 134.21,156.85 134.77,156.85 134.88,156.74 U6.17
VRACPU_VTEMP3: length 1.5
  TOP w0.203: R575.1 142.37,157.38 142.68,157.07 U10.17
VRACPU_VTEMP4: length 1.6
  TOP w0.203: R576.1 118.59,157.43 118.78,157.24 119.24,157.24 119.33,157.15 U11.17
VRAGT_CS2: length 32.9
  TOP w0.203: v1(153.11,151.2) 153.12,151.21 U13.18 ; R526.2 179.55,151.16 179.96,151.16 180.8,150.32 180.8,149.3 181.14,148.96 U3.1
  TOP w0.254: R526.2 179.35,150.88 179.65,150.57 v1(179.91,150.57)
  L8_IN3 w0.254: v1(153.11,151.2) 154.42,149.89 177.7,149.89 178.38,150.57 v1(179.91,150.57)
VRAGT_CSUMB: length 17.1
  TOP w0.203: v1(184.86,142.45) 184.86,142.84 184.68,143.02 U3.19
  TOP w0.254: v1(177.24,151.84) 177.24,151.46 177.75,150.96 R526.1
  BOTTOM w0.254: v1(177.24,151.84) 177.24,151.59 178.38,150.45 178.38,146.98 182.15,143.21 184.53,143.21 184.86,142.88 v1(184.86,142.45)
VRAGT_IMON: length 6.1
  TOP w0.203: U3.22 185.88,143.11 186.89,142.1 C156.2 186.94,141.63 187.4,141.18 187.4,139.07 R530.1
VRAGT_PWM2: length 43.1
  TOP w0.203: U3.39 185.88,150.37 186.64,151.13 v1(186.64,151.34)
  TOP w0.254: v1(150.68,153.29) 150.99,152.99 R570.2
  L3_IN1 w0.254: v1(186.64,151.34) 183.84,154.13 165.81,154.13 163.68,152 161.82,152 159.18,154.64 154.61,154.64 152.7,152.73 151.24,152.73 v1(150.68,153.29)
VRAGT_PWM2_R: length 1.6
  TOP w0.203: U13.15 153.31,152.41 153.19,152.53
  TOP w0.254: R570.1 152.73,152.99 153.19,152.53
VRAGT_VDIFF: length 5.3
  TOP w0.203: U3.10 181.05,145.36 180.49,144.81 180.49,143.18 179.58,142.27 C289.2 R548.2
VRAGT_VFB: length 7.3
  TOP w0.203: U3.11 181.08,144.96 180.8,144.68 180.8,142.88 C289.1 R548.1 R549.2
VRAGT_VORTN: length 2.4
  TOP w0.203: R547.2 181.43,142.32 182.28,143.17 U3.13
VRAGT_VOSEN: length 3.2
  TOP w0.203: U3.12 181.38,144.56 181.18,144.36 181.18,142.7 180.54,142.07 R539.2
VRAGT_VTEMP2: length 2
  TOP w0.203: U13.17 153.35,151.61 153.26,151.69 152.55,151.69 R577.1
VRASA_CS1: length 25.6
  TOP w0.203: v1(180.16,151.97) 179.48,151.97 R527.2 179.35,151.67 179.55,151.46 180.11,151.46 181.13,150.45 181.94,150.45 182.28,150.11 U3.48 ; v1(161.8,151.46) 162.03,151.46 162.25,151.23 U15.18
  L8_IN3 w0.254: v1(180.16,151.97) 178.92,153.22 166.14,153.22 164.39,151.46 v1(161.8,151.46)
VRASA_CSUMC: length 16
  TOP w0.203: v1(185.42,142.45) 185.42,142.71 185.08,143.05 U3.20
  TOP w0.254: R527.1 v1(177.85,151.84)
  BOTTOM w0.254: v1(185.42,142.45) 185.42,142.82 184.65,143.59 182.27,143.59 178.76,147.1 178.76,150.93 v1(177.85,151.84)
VRASA_IMON: length 6.4
  TOP w0.203: U3.23 186.28,143.19 187.83,141.63 C157.2 187.96,141.63 188.42,141.18 188.42,139.07 R531.1
VRASA_PWM1: length 31.5
  TOP w0.203: U3.38 186.28,150.34 186.83,150.89 v1(187.15,150.89)
  TOP w0.254: v1(161.95,153.83) 161.19,153.83 R571.2
  L3_IN1 w0.254: v1(187.15,150.89) 187.15,151.59 184.1,154.64 165.43,154.64 163.8,153.01 162.79,153.01 161.97,153.83 v1(161.95,153.83)
VRASA_PWM1_R: length 1.8
  TOP w0.203: 162.36,152.89 162.41,152.83 162.41,152.5 162.48,152.43 U15.15
  TOP w0.254: R571.1 162.08,153.17 162.36,152.89
VRASA_VDIFF: length 3
  TOP w0.203: U3.14 182.68,143.06 182.24,142.62 C288.1 R534.2
VRASA_VFB: length 3.8
  TOP w0.203: U3.15 183.08,141.89 C288.2 R534.1 R535.2
VRASA_VORTN: length 2.8
  TOP w0.203: R538.2 184.56,142.07 184.23,142.07 183.88,142.41 U3.17
VRASA_VOSEN: length 2.4
  TOP w0.203: R536.2 184.1,141.68 183.48,142.3 U3.16
VRASA_VTEMP1: length 1.5
  TOP w0.203: U15.17 162.29,151.63 162,151.92 161.59,151.92 R578.1
VREF_CODEC: length 2.5
  TOP w0.203: C163.1 C161.1 18.67,61.17 19.38,61.17 19.38,61.17 U7.27
VTTREF_1.2VS: length 1.7
  TOP w0.254: U25.7 185.54,110.78 v1(185.37,110.95)
  BOTTOM w0.254: C119.1 185.67,111.51 185.37,111.2 v1(185.37,110.95)
WEBCAM_+5V: length 3.2
  TOP w0.254: B14.1 77.29,157.69 v1(77.16,157.56)
  BOTTOM w0.254: CNEDP1.39 75.8,158.16 76.4,157.56 v1(76.53,157.56)
  BOTTOM w0.508: v1(76.53,157.56) v1(77.16,157.56)
WEBCAM_ON: length 371.1
  L6_IN2 w0.089: v1(161.49,29.8) 161.7,29.59 167.97,29.59 168.78,28.78 175.62,28.78 180,33.17 180,39.38 v1(180.58,39.96)
  L8_IN3 w0.089: v1(81.33,156.75) 81.23,156.85 77.87,156.85 75.58,154.55 69.46,154.55 68.37,155.64 68.37,156.45 67.99,156.82 56.19,156.82 55.85,156.49 37.74,156.49 31.06,149.81 31.06,125.55 27.75,122.25 27.75,115.29 28.2,114.84 28.2,111.19 25.96,108.95 23.98,108.95 22.75,107.72 22.75,106.83 20.35,104.42 15.9,104.42 13.89,102.41 13.89,79.38 11.27,76.77 11.27,73.04 11.73,72.59 11.73,71.38 12.29,70.82 15.87,70.82 17.17,69.52 18.58,69.52 18.92,69.19 25.97,69.19 27.94,67.21 28.95,67.21 30.2,65.96 51.86,65.96 52.47,65.35 63.71,65.35 64.31,64.75 68.82,64.75 71.17,62.4 71.17,61.16 71.94,60.39 71.94,56.96 77.63,51.26 84.91,51.26 86.1,52.45 87.35,52.45 90.05,55.15 90.6,55.15 92.49,57.03 94.55,57.03 96.6,59.08 v1(96.6,59.13)
  BOTTOM w0.102: U5.124 159.62,29.44 160.22,30.05 R251.2 R192.1 161.49,30.23 v1(161.49,29.8) ; v1(81.33,156.75) 81.23,156.85 R989.1 ; v1(96.6,59.13) 96.98,58.75 98.37,58.75 98.46,58.84 101.08,58.84 102.11,57.81 106.45,57.81 107.26,57 127.42,57 137.04,47.37 142.3,47.37 142.78,46.89 156.08,46.89 158.27,44.7 171.46,44.7 176.21,39.96 v1(180.58,39.96)
WEBCAM_USB+: length 7.6
  BOTTOM w0.102: CNEDP1.37 74.81,158.9 S15.1 74.89,157.48 74.89,156.92 D45.2 74.16,156.87 73.84,156.54 73.84,155.43 74.39,154.87 L16.1
WEBCAM_USB-: length 4.5
  BOTTOM w0.102: L16.4 76,155.67 75.73,155.95 75.73,156.36 D45.1 75.13,156.95 75.13,157.37 S16.1 75.3,157.58 CNEDP1.38
WLAN_3.3VDD: length 0.7
  BOTTOM w0.381: v1(82.88,7.7) 82.83,7.75 R281.2
  vias: v1(81.61,7.7) v1(81.61,7.06) v1(98.35,7.85) v1(98.35,7.29) v1(98.91,7.85) v1(98.91,7.29) v4(79.45,7.85)
WLAN_LED_MD#: length 2.9
  TOP w0.102: v1(81.23,8.33) 81.2,8.36 CNWLAN1.6
  BOTTOM w0.102: v1(81.23,8.33) R281.1 82.04,8.46 v3(82.04,9.32)
WLAN_ON: length 89.8
  TOP w0.102: v1(164.67,20.38) 164.69,20.38 164.72,20.35 R140.2 ; CNWLAN1.56 93.7,10.62 v1(94.06,10.98)
  L6_IN2 w0.089: v1(94.06,10.98) 94.25,10.78 95.67,10.78 98.01,13.12 113.82,13.12 115.28,11.66 117.51,11.66 119.51,9.65 120.46,9.65 121.75,8.36 121.75,7.41 122.35,6.81 140.63,6.81 141.29,7.46 142.97,7.46 144.14,8.64 146.34,8.64 148.19,10.49 158.32,10.49 160.35,12.53 161.49,12.53 162,12.02 v1(162.13,12.02)
  L8_IN3 w0.089: v1(164.67,20.38) 164.87,20.17 164.87,17.05 164.31,16.48 164.31,15.72 162.13,13.54 v1(162.13,12.02)
  BOTTOM w0.102: R141.1 165.35,19.69 v1(164.67,20.38) 164.34,20.71 U5.17
WP#_DGPU: length 2.9
  TOP w0.102: R2877.1 105.69,82.07 105.23,81.61 104.52,81.61 104.19,81.28 U83.3
XDP_PRDY#: length 7.1
  TOP w0.076: U26.BP27 161.27,123.4 165.81,123.4 166.83,124.41 R25.1
XDP_PREQ#: length 1.2
  TOP w0.076: U26.BL30 159.23,125.81 v1(159.33,125.81)
  BOTTOM w0.102: TP16.1 159.43,125.71 v1(159.33,125.81)
XDP_TCK: length 6.8
  TOP w0.076: U26.BR28 161.74,123.9 162.02,124.18 163.85,124.18 164.72,125.05
  TOP w0.102: R27.1 165.86,126.19 164.72,125.05
XDP_TDI: length 9.8
  TOP w0.076: U26.BL32 159.01,126.7 162.13,126.7 162.25,126.57 163.02,126.57 163.32,126.88 163.32,128.17 163.59,128.44
  TOP w0.102: 163.59,128.44 165.15,130 TP9.1
XDP_TDO: length 5.8
  TOP w0.076: U26.BT28 164.46,123.9 164.63,124.07
  TOP w0.102: R198.1 165.86,125.3 164.63,124.07
XDP_TMS: length 5.6
  TOP w0.076: TP11.1 165.02,123.62 161.27,123.62 160.99,123.9 U26.BP28
XDP_TRST#: length 6.9
  TOP w0.076: 165.45,128 165.28,127.83 164.91,127.83 164.03,126.95 164.03,126.65 162.58,125.2 161.34,125.2 161.06,125.48 U26.BP30
  TOP w0.102: 165.45,128 165.67,128.22 TP15.1
XTALIN: length 6.3
  TOP w0.102: Y10.3 100.52,85.22 C1419.2 99.34,84.79 95.96,84.79 95.45,84.28 G1.BL6
XTALOUT: length 7.6
  TOP w0.102: G1.BM6 96.15,84.43 96.25,84.53 99.47,84.53 C1418.2 100.23,84.23 100.53,84.53 101.44,84.53 Y10.1
XTALOUTBUFF: length 1.3
  TOP w0.102: v1(95.1,83.93) G1.BK6
  BOTTOM w0.102: R2771.2 95.5,84.33 v1(95.1,83.93)
XTALSSIN: length 10.4
  TOP w0.1: G1.BJ6 v1(93.73,83.97)
  TOP w0.102: R2781.2 v1(94.51,75.67)
  L8_IN3 w0.089: 94.44,79.2 93.17,80.47 93.17,81.36 93.42,81.61 93.42,83.26 93.73,83.58 v1(93.73,83.97) ; v1(94.51,75.67) 94.51,76.36
  L8_IN3 w0.102: 94.51,76.36 94.06,76.81 94.06,77.93 94.44,78.31 94.44,79.2
N883295: length 12.7
  TOP w0.102: R404.1 v1(76.28,161.88) ; v1(73.74,157.13) 74.7,157.13 74.8,157.23 R150.2 74.8,157.89 74.51,158.18 Q44.3 74.51,159.2 74.37,159.34 73.99,159.34 73.86,159.21 Q44.2
  L3_IN1 w0.102: v1(73.74,157.13) 73.63,157.13 73.1,157.66 73.1,160.86 74.12,161.88 v1(76.28,161.88)
N883416: length 2.2
  TOP w0.102: Q42.G 75.65,163.48 R404.2 R405.2
N888421: length 1.6
  TOP w0.508: R911.2 62.04,163.59 Q101.G
N891534: length 5.8
  TOP w0.102: Q57.D 74.37,167.29 72.11,165.03 71.73,165.03 R509.2 71.25,164.54 Q27.G
N906504: length 5.3
  BOTTOM w0.102: v3(80.62,158.3) 80.36,158.3 R989.2 C667.1 C2575.1 77.62,158.19 76.53,158.19 76.3,158.42 CNEDP1.40
N963492: length 2.4
  TOP w0.254: Q86.G 59.82,164.91 C428.2 R430.1
N963794: length 20.3
  TOP w0.254: R425.1 65.3,170.03 R428.1 v1(65.28,169.37) ; R426.1 v1(72.92,169.37) ; R427.1 v1(62.61,169.52) 62.61,169.04 Q86.D ; R408.1 70.38,170.16 R429.1 v1(70.23,169.34) ; v1(67.97,169.37) R418.1 67.69,170.28 R424.1
  BOTTOM w0.254: v1(62.61,169.52) 62.76,169.37 v1(65.28,169.37) v1(67.97,169.37) 67.99,169.34 v1(70.23,169.34) 70.26,169.37 v1(72.92,169.37)
N1023915: length 6.6
  TOP w0.102: v1(150.11,51.67) 146.94,51.67 v1(146.68,51.41)
  BOTTOM w0.102: Q58.2 v1(150.11,51.67) 150.47,51.67 R501.1 ; R492.1 146.53,51.57 v1(146.68,51.41) 146.94,51.67 Q58.5
N1590508: length 1.9
  TOP w0.203: AC6.2 15.6,62.81 AR18.1 15.6,61.03 AR9.2
N1590745: length 1.9
  TOP w0.203: AC7.2 14.68,62.81 AR18.2 14.68,61.03 AR8.2
N1812137: length 3.4
  TOP w0.203: C3572.2 60.72,39.27 R3331.2 62.31,39.91 62.31,40.34 62.5,40.54 U97.28
N1820431: length 61.5
  TOP w0.508: v1(15.95,45.93) 15.9,45.88 C3564.2 15.14,45.93 Q10.4 ; R3327.2 v1(64.21,46.64)
  L6_IN2 w0.508: v1(15.95,45.93) 16.59,46.56 19.63,46.56 20.78,45.42 49.1,45.42 51.45,43.07 53.86,43.07 58.14,38.79 62.28,38.79 63.19,39.7 63.19,45.62 v1(64.21,46.64)
N1840040: length 66.2
  TOP w0.381: v1(68.2,35.39) C3582.2 68.58,36.02 67.5,36.02 R3321.2 66.84,35.91 66.47,36.27 C3556.1 65.73,36.48 65.35,36.86 R3319.1
  TOP w0.508: Q9.4 v1(14.3,47.32)
  L6_IN2 w0.508: v1(68.2,35.39) 67.88,35.39 65.34,37.93 63.32,37.93 62.94,37.54 57.61,37.54 57.58,37.57 57.48,37.57 54.08,40.97 48.21,40.97 46.18,43.01 33.48,43.01 32.08,44.4 17.09,44.4 16.59,44.91 15.7,44.91 14.3,46.31 v1(14.3,47.32)
N1860184: length 4.4
  TOP w0.203: Q119.5 37.79,37.29 37.16,36.66 36.32,36.66 C244.1 R196.1 R191.1
N1862290: length 0.9
  BOTTOM w0.102: R320.2 R317.2
N1862418: length 5.3
  TOP w0.102: v1(53.54,55.07) 53.29,55.32 52.98,55.32 C355.1 ; C355.1 R326.1 ; C355.1 53.11,55.71 53.54,55.71 53.81,55.98 53.81,56.1 54.25,56.54 U2.1
  BOTTOM w0.102: v1(53.54,55.07) 53.24,55.07 C355.1
N2049790: length 1.4
  BOTTOM w0.254: Q120.6 44.72,158.59 R420.2
N2053305: length 4.3
  BOTTOM w0.254: R3326.1 R325.2 C410.1 45.46,160.05 45.16,160.35 Q120.5
N18840201: length 1.4
  TOP w0.381: Q44.6 73.21,161.26 72.85,161.62 R3036.2
N19731168: length 2.4
  TOP w0.102: v1(89.46,10.62) 89.2,10.36 CNWLAN1.38
  BOTTOM w0.102: TP194.1 88.95,11.41 89.46,10.9 v1(89.46,10.62)
N19731171: length 2.7
  TOP w0.102: CNWLAN1.40 89.7,10.09 89.88,10.26 89.88,11.07 v1(89.62,11.32)
  BOTTOM w0.102: v1(89.62,11.32) 90.02,11.71 TP190.1
N19731174: length 2.4
  TOP w0.102: CNWLAN1.42 90.2,8.8 89.13,7.72 TP193.1
N22296316: length 2.1
  TOP w0.254: U722.9 18.74,111.66 R971.2
N22296338: length 1.2
  TOP w0.254: R1932.1 13.41,113.31 R933.2
N22296342: length 1.1
  TOP w0.254: R936.2 R935.1
N22296384: length 1.1
  TOP w0.254: R975.1 15.24,111.71 R976.2
N22296783: length 1.2
  TOP w0.102: R1929.1 19.76,102.44 Q126.D
N22297924: length 1
  TOP w0.254: R984.1 R990.2
N22297928: length 1
  TOP w0.254: R991.2 R979.1
N22297930: length 1.2
  TOP w0.254: R985.1 24.43,113.13 R995.2
N22298251: length 15
  TOP w0.102: Q139.G 18.05,104.09 20.27,104.09 20.59,104.41 Q126.G 21.54,104.85 22.43,103.97 22.43,102.44 23.06,101.81 24.21,101.81 Q125.D 24.33,105.03 C1368.1 24.08,105.69 R1794.1
N22300749: length 1.2
  TOP w0.508: R232.2 13.59,117.62 C273.1
N22302053: length 1.2
  TOP w0.508: R239.2 24.79,117.75 C272.1
N23471734: length 1.2
  TOP w0.508: R584.2 C1222.1
N23555323: length 2.5
  TOP w0.102: Q67.G 72.41,36.29 R357.2 72.49,35.72 R3325.2
N24336526: length 1.7
  TOP w0.102: R502.1 71.39,175.07 71.39,174.26 71.18,174.05 L27.2
N24336578: length 1.7
  TOP w0.102: R504.1 71.82,175 71.82,174.21 71.98,174.05 L27.3
N24336650: length 1.7
  TOP w0.102: L26.2 66.16,173.99 66.35,174.17 66.35,175.03 R507.1
N24336705: length 1.6
  TOP w0.102: L26.3 66.96,174.11 66.78,174.29 66.78,175.04 R516.1
N24336752: length 1.7
  TOP w0.102: L24.2 68.69,174.1 68.9,174.31 68.9,175.02 R518.1
N24336771: length 1.6
  TOP w0.102: L24.3 69.49,174 69.33,174.16 69.33,175.05 R517.1
N24336854: length 1.7
  TOP w0.102: L25.2 63.62,174.09 63.81,174.28 63.81,175.03 R537.1
N24336873: length 1.6
  TOP w0.102: R519.1 64.24,175.04 64.24,174.29 64.42,174.11 L25.3
N25303038: length 1.2
  TOP w0.102: R926.1 16.46,102.44 Q139.D
N25505101: length 3.1
  TOP w0.1: G1.BD20 v6(90.25,93.78)
  BOTTOM w0.102: v6(90.25,93.78) 90.42,93.96 92.41,93.96 92.68,93.68 TP95.1
N25505109: length 1.5
  TOP w0.25: G1.BD18 v6(90.25,92.98)
  BOTTOM w0.102: v6(90.25,92.98) 90.82,93.55 TP96.1
N25508077: length 4.3
  TOP w0.102: Q104.6 97.34,61.94 97.48,61.8 97.48,61.55 97.23,61.29 Q104.5 96.6,61.29 96.09,60.79 95.71,60.79 95.53,60.61 R832.2
N25508415: length 2.6
  TOP w0.102: Q92.5 102.23,60.02 102.74,60.53 R3539.2 102.65,60.67 Q92.6
N25531916: length 3
  BOTTOM w0.102: C877.2 R2738.1 R2737.1 41.86,122.58 v3(41.91,122.53)
N25531999: length 3.1
  TOP w0.381: R2713.2 39.45,122 40.97,123.52 Q62.D
N25542499: length 3.3
  BOTTOM w0.102: C879.2 R2742.1 R2741.1 41.43,87.63 v3(42.11,86.95)
N25542563: length 4.9
  TOP w0.381: Q64.D 32.46,89.74 v3(33.73,88.47) 33.86,88.34 R2719.2
N25548280: length 3.1
  BOTTOM w0.102: v3(42.11,89.23) 41.91,89.03 R2746.1 R2745.1 C1042.2
N26058442: length 3.9
  TOP w0.102: R373.1 75.64,162 75.26,162.39 74.29,162.39 C452.1 73.79,160.75 Q44.5
N26121620: length 8.3
  TOP w0.229: U26.G2 125.35,104.46 125.08,104.46 124.85,104.23
  TOP w0.254: 124.47,103.54 124.85,103.92 124.85,104.23
  TOP w0.381: R148.2 119.07,103.2 119.46,102.82 123.27,102.82 123.98,103.54 124.47,103.54
N26123034: length 5.8
  TOP w0.102: R262.1 119.71,130.89 120.85,129.75 122,129.75 122.12,129.62 123.6,129.62 U26.D37
N26124061: length 2.8
  TOP w0.102: R36.1 183.19,138.09
  TOP w0.508: Q2.5 183.84,137.66 183.41,138.09 183.19,138.09 Q2.6
N26124148: length 1.5
  TOP w0.076: U26.AW13 150.1,111.88 v1(150.39,111.59)
  BOTTOM w0.102: TP7.1 150.34,111.54 v1(150.39,111.59)
N26124150: length 1.5
  TOP w0.076: U26.AT13 148.25,111.88 v1(148.54,111.59)
  BOTTOM w0.102: v1(148.54,111.59) 147.78,111.59 TP14.1
N26124355: length 5.4
  TOP w0.102: R46.1 167.08,121.54 U26.BT25
N26148392: length 19.2
  TOP w0.203: U26.BH13 157.11,111.88 v1(156.79,111.58)
  TOP w0.254: U26.G11 125.81,110.99 125.81,111.09 v1(125.84,111.12)
  TOP w0.381: U26.BH13 157.6,112.24 U26.BJ13
  L8_IN3 w0.381: v1(125.84,111.12) 125.97,111.12 126.41,111.56 138.23,111.56 138.25,111.59
  BOTTOM w0.508: R197.1 160.66,112.36 v3(159.68,112.36) 159.48,112.55 C203.1 C207.1 157.3,112.55 156.79,112.04 v1(156.79,111.58)
N26150436: length 139.6
  TOP w0.102: v1(101.29,23.83) R431.1 ; v1(127.42,120.56) 127.06,120.2 126.91,120.2 U26.J23
  L6_IN2 w0.089: v1(127.42,120.56) 127.25,120.56 126.31,121.49 126.31,121.75 125.93,122.13 124.79,122.13 124.03,122.89 121.74,122.89 119.58,125.05 119.58,128.1 118.82,128.86 114.25,128.86 113.51,128.11 113.51,113.38 108.87,108.75 108.87,91.86 106.16,89.14 106.16,80.06 104.53,78.43 104.53,62.07 105.02,61.58 105.23,61.37 105.23,60.15 109.68,55.71 109.68,50.63 108.17,49.12 105.73,49.12 105.03,48.42 v1(104.65,48.42)
  L8_IN3 w0.089: v1(104.65,48.42) 104.09,47.87 104.09,45.78 101.21,42.89 101.21,42.17 98.93,39.89 98.93,36.47 97.4,34.95 97.4,27.47 101.04,23.83 v1(101.29,23.83)
N26150438: length 3.6
  TOP w0.102: U26.A36 120.88,129.34 120.22,130 R432.1
N26150440: length 5
  TOP w0.076: 121.66,131.27 U26.A37
  TOP w0.102: R433.1 120.85,132.29 121.66,131.47 121.66,131.27
N26151913: length 4.7
  TOP w0.076: U28.BE41 125.33,16.12 125.04,15.83 125.04,15.44 125.12,15.37 125.12,13.41
  TOP w0.102: R82.2 125.12,12.3 125.12,13.41
N26152241: length 6.5
  TOP w0.089: U28.AV43 v2(126.15,19.06)
  BOTTOM w0.102: R80.2 129.08,17.05 129.08,18.27 128,19.35 126.43,19.35 v2(126.15,19.06)
N26152243: length 1.3
  TOP w0.089: U28.AR37 v2(123.23,20.38)
  BOTTOM w0.102: v2(123.23,20.38) 123.14,20.47 R88.2
N26152245: length 1.6
  TOP w0.089: v2(122.63,20.32) 122.63,20.77 U28.AR35
  BOTTOM w0.102: R89.2 122.63,20.71 v2(122.63,20.32)
N26152247: length 3.4
  TOP w0.089: v1(129.35,19.78) 129.21,19.63 128.19,19.63 U28.AV47
  BOTTOM w0.102: v1(129.35,19.78) 129.35,18.37 129.86,17.86 R85.2
N26152271: length 2.6
  TOP w0.076: v1(105.23,36.02) 105.36,35.89 105.36,35.77 105.61,35.51 106.06,35.51 U28.F3
  BOTTOM w0.102: v1(105.23,36.02) 105.36,36.02 105.99,36.66 R78.2
N26152273: length 1.9
  TOP w0.076: U28.F4 106.63,35.59 106.63,36.02 106.5,36.15 v1(106.45,36.15)
  BOTTOM w0.102: R84.2 106.88,36.63 106.5,36.25 106.5,36.17 106.48,36.15 v1(106.45,36.15)
N26152279: length 2.8
  TOP w0.076: U28.G3 106.84,34.96 107.14,35.26 107.14,35.61 107.54,36.02 v1(107.62,36.02)
  BOTTOM w0.102: v1(107.62,36.02) 107.54,36.02 107.52,36.05 107.52,36.53 107.77,36.78 R83.2
N26153792: length 4.2
  TOP w0.076: 131.14,22.43 130.89,22.18 130.5,22.18 130.25,21.92 128.73,21.92 128.61,21.8 U28.AN47
  TOP w0.102: 131.14,22.43 v1(131.27,22.56)
  BOTTOM w0.102: v1(131.27,22.56) 131.7,22.56 R92.1
N26154194: length 4.1
  TOP w0.076: v1(129.99,23.71) 129.77,23.49 129.03,23.49 128.98,23.44 128.52,23.44 128.47,23.49 U28.AK47
  BOTTOM w0.102: v1(129.99,23.71) 130.36,24.08 R109.1
N26154209: length 2.2
  TOP w0.089: U28.AM43 v2(126.19,21.98)
  BOTTOM w0.102: R107.1 127.51,21.62 127.08,22.05 126.26,22.05 v2(126.19,21.98)
N26154211: length 7.8
  TOP w0.089: U28.AH41 125.47,24.55 125.42,24.59 125.42,24.64 v1(125.42,24.64)
  BOTTOM w0.102: R100.1 131.01,24.97 130.38,25.61 128.85,25.61 128.06,24.81 127.51,24.81 127.35,24.97 125.75,24.97 v1(125.42,24.64)
N26156301: length 1.2
  TOP w0.254: R133.1 182.62,25.77 D1.2
N26156319: length 5.1
  TOP w0.254: R133.2 182.62,28.3 v1(182.63,28.3)
  BOTTOM w0.254: v3(183.84,31.83) 183.26,31.83 182.63,31.2 CN4.1 v1(182.63,28.3)
N26156460: length 2.1
  TOP w0.102: R164.1 R113.2 182.4,22.51 D1.1
N26156487: length 8.6
  TOP w0.102: Q16.6 169.41,23.03 170,22.43 171.65,22.43 172.34,23.12 173.8,23.12 174.21,22.71 175.87,22.71 175.92,22.76 R269.2 176.99,22.76 R315.1
N26158678: length 1.4
  TOP w0.089: v2(122.32,17.57) U28.BB34
  BOTTOM w0.102: v2(122.32,17.57) 121.87,17.12 R334.1
N26158680: length 1.9
  TOP w0.089: U28.BB36 v2(123.72,17.57)
  BOTTOM w0.089: v2(123.72,17.57) 124.41,16.88 R323.1
N26158684: length 4.1
  TOP w0.076: 123.09,13.41 123.09,13.5 122.96,13.63 122.96,14.65 123.42,15.1 123.42,15.19 123.78,15.55 U28.BF38
  TOP w0.102: 123.09,13.41 123.09,12.69 122.76,12.36 TP10.1
N26159826: length 5.6
  BOTTOM w0.102: R349.1 C276.1 104.52,30.15 101.2,30.15 Y3.3
N26162446: length 2.9
  TOP w0.254: U28.AN24 116.91,22.07 v2(116.56,21.72)
  BOTTOM w0.305: R369.1 115.89,19.98 115.89,20.95 C323.2 116.42,21.48 116.42,21.59 v2(116.56,21.72)
N26162493: length 2
  TOP w0.254: U28.AF19 114.51,25.59 v2(114.88,25.96) 115.05,25.78 115.23,25.6 U28.AF20
  BOTTOM w0.381: R376.1 114.35,25.96 v2(114.88,25.96)
