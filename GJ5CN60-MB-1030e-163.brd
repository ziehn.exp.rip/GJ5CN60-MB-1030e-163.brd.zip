# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Nets (continued)
FBC_DBI2: G1.J18 M45.D13
FBC_DBI3: G1.F12 M45.D2
FBC_DBI4: G1.D29 M46.D2
FBC_DBI5: G1.E27 M46.D13
FBC_DBI6: G1.F20 M46.P13
FBC_DBI7: G1.E26 M46.P2
FBC_DEBUG0: G1.A9 R913.2
FBC_DEBUG1: G1.C24 R914.2
FBC_EDC0: G1.D5 M45.R2
FBC_EDC1: G1.D8 M45.R13
FBC_EDC2: G1.E17 M45.C13
FBC_EDC3: G1.E12 M45.C2
FBC_EDC4: G1.E30 M46.C2
FBC_EDC5: G1.B29 M46.C13
FBC_EDC6: G1.G21 M46.R13
FBC_EDC7: G1.E24 M46.R2
FBC_VREFC: C973.2 C1040.2 M45.J14 M46.J14 R2714.2 R2717.1 R2719.1
FBC_WCK01_N: G1.G8 M45.P5
FBC_WCK01_P: G1.F8 M45.P4
FBC_WCK23_N: G1.G12 M45.D5
FBC_WCK23_P: G1.H12 M45.D4
FBC_WCK45_N: G1.H27 M46.D5
FBC_WCK45_P: G1.J27 M46.D4
FBC_WCK67_N: G1.H23 M46.P5
FBC_WCK67_P: G1.G23 M46.P4
FBC_ZQ0: M45.J13 R2718.1
FBC_ZQ2: M46.J13 R2732.1
FBCAL_GND: G1.P44 R2759.1
FBCAL_TERM: G1.R45 R2760.1
FBCAL_VDDQ: G1.R44 R2758.1
FBD_DEBUG0: G1.AD3 R920.2
FBD_DEBUG1: G1.J3 R921.2
FBVDDQ_EN: C666.1 D16.3 Q136.G Q165.4 R869.1 U84.3
FBVDDQ_GND_SENSE: R2751.2 R2755.2
FBVDDQ_MEM: C422.1 C423.1 C424.1 C425.1 C427.1 C429.1 C430.1 C433.1 C674.1 C686.1 C687.1 C688.1 C689.1 C690.1 C885.1 C886.1 C887.1 C888.1 C889.1 C890.2 C891.2 C892.1 C893.2 C894.1 C895.1 C896.1 C897.1 C898.1 C899.1 C900.1 C901.1 C902.2 C903.1 C904.2 C905.2 C906.1 C907.1 C908.1 C909.1 C910.1 C911.1 C912.1 C913.1 C914.1 C915.2 C916.1 C917.2 C918.2 C919.1 C920.1 C921.1 C922.1 C923.1 C924.1 C925.1 C926.1 C927.1 C928.2 C929.1 C930.1 C931.2 C932.2 C933.1 C934.1 C935.1 C936.1 C937.1 C938.1 C939.2 C940.2 C941.2 C942.2 C943.1 C944.1 C945.1 C946.1 C947.2 C948.1 C949.2 C950.2 C951.1 C952.2 C953.1 C954.1 C956.2 C957.2 C958.1 C959.1 C960.1 C961.1 C962.1 C963.2 C964.1 C965.1 C966.1 C967.1 C968.1 C972.1 C974.1 C975.1 C976.1 C977.1 C978.2 C979.2 C980.2 C981.1 C982.2 C983.1 C984.2 C985.2 C986.1 C987.2 C988.1 C989.2 C990.2 C991.1 C992.2 C993.1 C994.2 C995.2 C996.1 C997.2 C998.1 C999.2 C1000.2 C1001.1 C1002.2 C1003.1 C1004.2 C1005.1 C1006.1 C1007.1 C1008.1 C1009.1 C1010.1 C1011.1 C1012.1 C1013.1 C1014.1 C1015.1 C1016.1 C1017.2 C1018.1 C1019.2 C1020.1 C1021.2 C1022.1 C1023.1 C1024.1 C1025.1 C1026.2 C1027.1 C1028.1 C1029.1 C1030.1 C1031.1 C1032.2 C1033.1 C1034.1 C1035.1 C1036.1 C1037.1 C1038.1 C1039.1 C1041.1 C1044.1 C1045.1 C1046.1 C1047.1 C1048.1 C1049.1 C1050.2 C1051.1 C1052.1 C1053.2 C1054.2 C1055.1 C1056.1 C1057.1 C1058.1 C1059.1 C1060.1 C1061.1 C1062.1 C1063.1 C1064.2 C1065.1 C1066.1 C1067.1 C1068.2 C1069.1 C1070.1 C1071.1 C1072.1 C1073.1 C1074.2 C1075.1 C1076.2 C1077.2 C1078.1 C1139.2 C1165.2 C1309.2 C1320.2 C1343.2 C1344.2 C1345.2 C1346.2 C1348.2 C1350.1 C1351.1 C1352.1 C1353.1 C1387.2 C1388.2 C1391.2 C1392.2 C1393.2 C1394.1 C1395.2 C1396.1 C1397.2 C1398.2 C1399.2 C1400.2 C1403.1 C1404.2 C1405.2 C1406.2 C1407.2 C1408.2 C1409.2 C1410.1 C1411.2 C1412.2 C1416.2 C1421.2 C1422.2 C1431.2 G1.AA10 G1.AA11 G1.AA42 G1.AA43 G1.AC10 G1.AC11 G1.AC42 G1.AC43 G1.AD10 G1.AD11 G1.AD42 G1.AD43 G1.AF10 G1.AF43 G1.AG10 G1.AG11 G1.AG42 G1.AG43 G1.AJ10 G1.AJ11 G1.AJ42 G1.AJ43 G1.AK10 G1.AK11 G1.AK42 G1.AK43 G1.AM42 G1.AM43 G1.AN43 G1.AR42 G1.AR43 G1.AT43 G1.K12 G1.K14 G1.K15 G1.K17 G1.K18 G1.K20 G1.K21 G1.K23 G1.K24 G1.K26 G1.K27 G1.K29 G1.K30 G1.K32 G1.K33 G1.K35 G1.K36 G1.K38 G1.K39 G1.K41 G1.L14 G1.L15 G1.L18 G1.L20 G1.L21 G1.L23 G1.L24 G1.L26 G1.L27 G1.L30 G1.L32 G1.L33 G1.L35 G1.L36 G1.L39 G1.M10 G1.M43 G1.P10 G1.P11 G1.P42 G1.P43 G1.R10 G1.R11 G1.R42 G1.R43 G1.U10 G1.U11 G1.U43 G1.V10 G1.V42 G1.V43 G1.Y10 G1.Y11 G1.Y42 G1.Y43 L43.2 M41.B1 M41.B3 M41.B12 M41.B14 M41.C5 M41.C10 M41.D1 M41.D3 M41.D11 M41.D12 M41.D14 M41.E5 M41.E10 M41.F1 M41.F3 M41.F12 M41.F14 M41.G1 M41.G2 M41.G4 M41.G11 M41.G13 M41.G14 M41.H3 M41.H12 M41.J1 M41.K3 M41.K12 M41.L1 M41.L2 M41.L4 M41.L11 M41.L13 M41.L14 M41.M1 M41.M3 M41.M12 M41.M14 M41.N5 M41.N10 M41.P1 M41.P3 M41.P11 M41.P12 M41.P14 M41.R5 M41.R10 M41.T1 M41.T3 M41.T12 M41.T14 M42.B1 M42.B3 M42.B12 M42.B14 M42.C5 M42.C10 M42.D1 M42.D3 M42.D11 M42.D12 M42.D14 M42.E5 M42.E10 M42.F1 M42.F3 M42.F12 M42.F14 M42.G1 M42.G2 M42.G4 M42.G11 M42.G13 M42.G14 M42.H3 M42.H12 M42.K3 M42.K12 M42.L1 M42.L2 M42.L4 M42.L11 M42.L13 M42.L14 M42.M1 M42.M3 M42.M12 M42.M14 M42.N5 M42.N10 M42.P1 M42.P3 M42.P11 M42.P12 M42.P14 M42.R5 M42.R10 M42.T1 M42.T3 M42.T12 M42.T14 M43.B1 M43.B3 M43.B12 M43.B14 M43.C5 M43.C10 M43.D1 M43.D3 M43.D11 M43.D12 M43.D14 M43.E5 M43.E10 M43.F1 M43.F3 M43.F12 M43.F14 M43.G1 M43.G2 M43.G4 M43.G11 M43.G13 M43.G14 M43.H3 M43.H12 M43.J1 M43.K3 M43.K12 M43.L1 M43.L2 M43.L4 M43.L11 M43.L13 M43.L14 M43.M1 M43.M3 M43.M12 M43.M14 M43.N5 M43.N10 M43.P1 M43.P3 M43.P11 M43.P12 M43.P14 M43.R5 M43.R10 M43.T1 M43.T3 M43.T12 M43.T14 M44.B1 M44.B3 M44.B12 M44.B14 M44.C5 M44.C10 M44.D1 M44.D3 M44.D11 M44.D12 M44.D14 M44.E5 M44.E10 M44.F1 M44.F3 M44.F12 M44.F14 M44.G1 M44.G2 M44.G4 M44.G11 M44.G13 M44.G14 M44.H3 M44.H12 M44.K3 M44.K12 M44.L1 M44.L2 M44.L4 M44.L11 M44.L13 M44.L14 M44.M1 M44.M3 M44.M12 M44.M14 M44.N5 M44.N10 M44.P1 M44.P3 M44.P11 M44.P12 M44.P14 M44.R5 M44.R10 M44.T1 M44.T3 M44.T12 M44.T14 M45.B1 M45.B3 M45.B12 M45.B14 M45.C5 M45.C10 M45.D1 M45.D3 M45.D11 M45.D12 M45.D14 M45.E5 M45.E10 M45.F1 M45.F3 M45.F12 M45.F14 M45.G1 M45.G2 M45.G4 M45.G11 M45.G13 M45.G14 M45.H3 M45.H12 M45.J1 M45.K3 M45.K12 M45.L1 M45.L2 M45.L4 M45.L11 M45.L13 M45.L14 M45.M1 M45.M3 M45.M12 M45.M14 M45.N5 M45.N10 M45.P1 M45.P3 M45.P11 M45.P12 M45.P14 M45.R5 M45.R10 M45.T1 M45.T3 M45.T12 M45.T14 M46.B1 M46.B3 M46.B12 M46.B14 M46.C5 M46.C10 M46.D1 M46.D3 M46.D11 M46.D12 M46.D14 M46.E5 M46.E10 M46.F1 M46.F3 M46.F12 M46.F14 M46.G1 M46.G2 M46.G4 M46.G11 M46.G13 M46.G14 M46.H3 M46.H12 M46.K3 M46.K12 M46.L1 M46.L2 M46.L4 M46.L11 M46.L13 M46.L14 M46.M1 M46.M3 M46.M12 M46.M14 M46.N5 M46.N10 M46.P1 M46.P3 M46.P11 M46.P12 M46.P14 M46.R5 M46.R10 M46.T1 M46.T3 M46.T12 M46.T14 R132.2 R887.1 R888.1 R890.1 R892.1 R893.1 R898.1 R904.1 R907.1 R913.1 R914.1 R915.1 R916.1 R920.1 R921.1 R1934.2 R2692.1 R2712.1 R2714.1 R2758.2
FBVDDQ_MEM_VIN: C1290.1 C1297.1 C1304.1 C1305.1 C1306.1 C1378.1 C4121.1 PJP10.2 PQ52.2 PQ52.3 PQ52.4 PQ53.2 PQ53.3 PQ53.4
FBVDDQ_PG_1V8AON_GC6: D52.3 R365.1 U28.BE23
FBVDDQ_SENSE: C151.1 G1.E52 R127.1 R132.1 R812.2
G_HDR1: R918.2 U721.2
G_HDR1_R: PQ44.1 R918.1 R980.2
G_LDR1: C546.1 PQ44.8 R2879.1 U721.19
G_LDR2: R954.1 U721.17
G_SMBCLK0: G1.BJ8 Q58.1 R486.1
G_SMBDAT0: G1.BH8 Q58.4 R483.1
GFX_CLKREQ: Q78.D R764.1 U28.BE31
GPIO0_NVVDD_PWM_GPU: G1.BD6 R2938.1
GPIO1_GC6FBEN: G1.BB5 Q92.2 R2798.2
GPIO2_GPUEVENT*: D23.A G1.BD1 R2809.2
GPIO4_1V8MAIN_ON: D27.A Q104.3 Q130.2 R834.2 R966.1 R1007.1
GPIO4_1V8MAINEN: G1.BE1 Q104.2 R2808.2
GPIO5_FRM_LOCK: G1.BG2 R2814.2
GPIO6_NVVDD_PSI*: G1.BD2 R943.1 R944.1 R2811.2
GPIO7_LCD_BL_PWM: G1.BD7 R2806.2
GPIO8_MEM_VDD_CTL: G1.BH4 Q129.G R850.2 R867.1
GPIO10_MEM_REF_CTL: G1.BD3 Q59.G Q62.G Q64.G R2836.1
GPIO11_LCD_VDD: G1.BH3 R2801.2
GPIO12_AC_DETECT: D24.A G1.BE6 R2813.2
GPIO13_LCD_BLEN: G1.BB1 R2803.2
GPIO14_IFPA_HPD#: G1.BG4 R439.2
GPIO15_IFPB_HPD#: G1.BG1 R440.2
GPIO17_IFPD_HPD#: G1.BH1 R437.2
GPIO18_IFPE_HPD#: G1.BE3 Q53.C R438.2
GPIO24_IFPF_HPD#: G1.BD5 R441.2
GPIO27_IFPC_HPD#: G1.BA4 R436.2
GPIO28_OC_WARN: R2949.2 U1.8 U1.9
GPIO28_OCWARN: G1.BB4 R2812.2 R2949.1
GPP_A11: TP18.1 U28.BE36
GPP_B18: R361.2 U28.BE30
GPP_H12: R76.1 U28.AB47
GPP_H15: R73.1 U28.AC47
GPP_J9: R355.2 U28.AU9
GPPJ_RCOMP_1P8: R360.1 U28.BD1 U28.BE1 U28.BE2
GPU_ADAPTOR_IN: D24.C Q4.3 U5.123
GPU_BUFRST#: G1.BF9 R2878.2
GPU_EVENT#_GC6: D23.C U28.BE21
GPU_NVVDD_FBRTN: C2550.2 G1.BL45 R948.1 R987.1 R998.1 U722.10
GPU_NVVDD_SENSE: C550.1 G1.BK45 R952.1 R2940.1 R2942.1
GPU_NVVDDS_FBRTN: C796.2 C798.2 C2555.2 G1.BM44 R946.1 R947.2 R962.1 R965.2 U721.10
GPU_NVVDDS_SENSE: C548.1 C802.1 G1.BM45 R959.2 R2939.1 R2941.1
H-PECI: R3129.2 U26.BT34 U28.AF2
H_A20GATE: R3290.2 U5.126
H_RCIN#: R321.1 U5.4 U28.BE39
H_THERMTRIP_N: Q51.E R94.1 R98.2 U26.J31
HDMI1_CLK_DN: C365.1 G1.BG14
HDMI1_CLK_DP: C404.1 G1.BH14
HDMI1_TX0_DN: C408.1 G1.BF14
HDMI1_TX0_DP: C409.1 G1.BE14
HDMI1_TX1_DN: C403.1 G1.BF15
HDMI1_TX1_DP: C369.1 G1.BG15
HDMI1_TX2_DN: C411.1 G1.BG17
HDMI1_TX2_DP: C414.1 G1.BH17
HDMI_5V_C: B19.1 C610.1 CN26.18
HDMI_+5V: B19.2 PS1.1
HDMI_CLK: CN26.15 D59.1 Q114.6 R495.1
HDMI_DAT: CN26.16 D59.2 Q114.3 R494.2
HDMI_HPD_CN: CN26.19 D10.3 Q37.D R544.1
HDMIOUT_CLK+: CN26.10 R519.2 S10.1
HDMIOUT_CLK-: CN26.12 R537.2 S11.1
HDMIOUT_D0+: CN26.7 R504.2 S21.1
HDMIOUT_D0-: CN26.9 R502.2 S22.1
HDMIOUT_D1+: CN26.4 R516.2 S19.1
HDMIOUT_D1-: CN26.6 R507.2 S20.1
HDMIOUT_D2+: CN26.1 R517.2 S12.1
HDMIOUT_D2-: CN26.3 R518.2 S13.1
HDRV_CHG: PQ37.1 U97.26
HOLD#_DGPU: R2881.1 U83.7
HP_JD_SENSE#: AR5.2 CN12.11
HP_L: AR12.2 U7.32
HP_R: AR11.2 U7.33
HPD_HDMI: Q37.S R259.2 R557.1 R674.2 S23.1
HYB_ON#: R3332.2 R3335.2 U5.98
I2C0_SCL: CN17.3 R484.1 U28.BC22
I2C0_SDA: CN17.4 R485.1 U28.BF23
I2CB_SCL_G: G1.BG8 R2924.2
I2CB_SDA_G: G1.BF8 R2849.2
I2CC_SCL: Q122.6 R2850.2 U1.6
I2CC_SCL_G: G1.BG9 Q122.1 R2848.2
I2CC_SDA: Q122.3 R201.2 R2925.2 U1.7
I2CC_SDA_G: G1.BH9 Q122.4 R2921.2
I_NVVDD_N: R185.1 R1092.1
I_NVVDD_P: R182.1 R1084.1
I_NVVDDS_N: R204.1 R1093.1
I_NVVDDS_P: R208.1 R1085.1
I_VIN_N: R181.1 R1083.1
I_VIN_P: R177.1 R1091.1
IACM: R3298.1 U97.1
IACP: R3295.1 U97.2
IADAPTER_I BAT: C182.1 C3537.2 U5.72 U97.7
ICHM: C3574.1 R3318.1 U97.19
ICHP: C3574.2 R3307.1 U97.20
ID_DET: CN9.5 Q48.G Q49.G R245.2 R3585.2 R3626.2 U5.96
ID_DET_R: CN12.44 R3626.1
IFPAB_RSET: G1.BD23 R202.2
IFPE_AUX_CK: G1.BK8 Q114.1 R493.2
IFPE_AUX_DATA: G1.BL8 Q114.4 R489.2
IFPEF_RSET: G1.BD17 R165.2
ILIM: C3576.2 C3580.2 R3328.1 R3329.2 U97.21
INT_SERIRQ: C214.1 R338.1 U5.5 U28.AW35
ISEN1_NVD: R979.2 U722.15
ISEN2_NVD: R984.2 U722.14
ISEN3_NVD: R985.2 U722.13
ISOLATEB: R1908.2 R1921.2 R1936.1 U1901.20
IST_TRIG_CPU: TP13.1 U26.E3
ITP_PMODE_PCH: TP37.1 U28.AL3
JACK_HP_L: AR12.1 C195.1 CN12.9
JACK_HP_R: AR11.1 C194.1 CN12.10
JACK_MIC1_L: AR8.1 AR13.1 CN12.8
JACK_MIC1_R: AR9.1 AR14.1 CN12.7
JDREF_CODEC: AR6.1 U7.19
JTAG_TCK_PCH: TP26.1 U28.AJ3
JTAG_TDI_PCH: R291.1 U28.AH2
JTAG_TDO_PCH: R298.1 U28.AH3
JTAG_TMS_PCH: R292.1 U28.AJ4
KEY_OUT0: CNKB1.1 U5.36
KEY_OUT1: CNKB1.2 U5.37
KEY_OUT2: CNKB1.3 U5.38
KEY_OUT3: CNKB1.7 U5.39
KEY_OUT4: CNKB1.9 U5.40
KEY_OUT5: CNKB1.10 U5.41
KEY_OUT6: CNKB1.13 U5.42
KEY_OUT7: CNKB1.16 U5.43
KEY_OUT8: CNKB1.17 U5.44
KEY_OUT9: CNKB1.18 U5.45
KEY_OUT10: CNKB1.19 U5.46
KEY_OUT11: CNKB1.20 U5.51
KEY_OUT12: CNKB1.21 U5.52
KEY_OUT13: CNKB1.22 U5.53
KEY_OUT14: CNKB1.23 U5.54
KEY_OUT15: CNKB1.24 U5.55
KEYIN0: CNKB1.4 U5.58
KEYIN1: CNKB1.5 U5.59
KEYIN2: CNKB1.6 U5.60
KEYIN3: CNKB1.8 U5.61
KEYIN4: CNKB1.11 U5.62
KEYIN5: CNKB1.12 U5.63
KEYIN6: CNKB1.14 TP151.1 U5.64
KEYIN7: CNKB1.15 TP152.1 U5.65
LAN_ACT: TP1903.1 U1901.27
LAN_EN: R104.2 U28.BB26
LAN_HSON: C266.1 U1901.18
LAN_HSOP: C265.1 U1901.17
LAN_LINK: R104.1 U1901.26
LAN_MDI0+: LT2.8 U1901.1
LAN_MDI0-: LT2.9 U1901.2
LAN_MDI1+: LT2.11 U1901.4
LAN_MDI1-: LT2.12 U1901.5
LAN_MDI2+: LT2.2 U1901.6
LAN_MDI2-: LT2.3 U1901.7
LAN_MDI3+: LT2.5 U1901.9
LAN_MDI3-: LT2.6 U1901.10
LAN_PWR: R255.2 U5.119
LAN_RSET: R1912.2 U1901.31
LAN_XTAL_IN: C247.1 R260.1 U1901.28 Y2.3
LAN_XTAL_OUT: R1925.2 U1901.29
LANWAKEB: Q68.S R226.1 R434.2 U1901.21
LB_BLUE_PWM: R3518.2 U5.32
LB_GREEN_PWM: R3515.2 U5.29
LB_RED_PWM: R661.2 U5.25
LDO_+5VA: C308.1 R69.2 U9.21
LDOCAP_CODEC: C1234.1 U7.28
LDRV_CHG: C3581.1 PQ37.8 U97.23
LED_B: C3904.1 CN19.4 R3519.1
LED_G: C3902.1 CN19.3 R3516.1
LED_R: C2747.1 CN19.1 CN19.2 R664.1
LG1_NVD: C3941.1 PQ42.8 PQ43.8 R2880.1 U722.23
LG2_NVD: C3940.1 PQ40.8 PQ41.8 R950.1 U722.20
LG3_NVD: C3939.1 PQ48.8 PQ49.8 U32.5
LG_MEM: C554.1 PQ52.8 PQ53.8 U84.6
LID#: CN12.49 R16.2 SW5.3 U5.19
LID_OFF: C450.1 CN12.40 Q183.G R688.1
LINE2_L: CN12.5 U7.14
LINE2_R: CN12.4 U7.15
LPC_AD0: CNDEG1.9 U5.10 U28.BB39
LPC_AD1: CNDEG1.8 U5.9 U28.AW37
LPC_AD2: CNDEG1.7 U5.8 U28.AV37
LPC_AD3: CNDEG1.10 U5.7 U28.BA38
LPC_FRAME#: CNDEG1.5 U5.6 U28.BE38
LRST1#: C162.1 R118.1 U5.14
LVDS_VIN: R373.2 U5.35
LX_+1.0VA: C3603.2 L53.1 U17.10 U17.11 U17.16 U17.17 U17.18
LX_+1.8VA: L52.1 U19.2 U19.3
LX_+3.3VA: C68.2 L35.1 U12.10 U12.11 U12.16 U12.17 U12.18
LX_+5VA: C310.1 L50.1 U9.10 U9.11 U9.16 U9.17 U9.18
LX_VCCIO: C3645.2 L62.1 U18.10 U18.11 U18.16 U18.17 U18.18
M_A_A0: CN1.144 U26.AH3
M_A_A1: CN1.133 U26.AP4
M_A_A2: CN1.132 U26.AN4
M_A_A3: CN1.131 U26.AP5
M_A_A4: CN1.128 U26.AP2
M_A_A5: CN1.126 U26.AP1
M_A_A6: CN1.127 U26.AP3
M_A_A7: CN1.122 U26.AN1
M_A_A8: CN1.125 U26.AN3
M_A_A9: CN1.121 U26.AT4
M_A_A10_AP: CN1.146 U26.AH2
M_A_A11: CN1.120 U26.AN2
M_A_A12: CN1.119 U26.AU4
M_A_A13: CN1.158 U26.AE3
M_A_A14_MA_WE#: CN1.151 U26.AG4
M_A_A15_MA_CAS#: CN1.156 U26.AD1
M_A_A16_MA_RAS#: CN1.152 U26.AH4
M_A_ACT_N: CN1.114 U26.AU3
M_A_BA0: CN1.150 U26.AH5
M_A_BA1: CN1.145 U26.AH1
M_A_BG0: CN1.115 U26.AU1
M_A_BG1: CN1.113 U26.AU2
M_A_DQ0: CN1.8 U26.BR6
M_A_DQ1: CN1.3 U26.BT6
M_A_DQ2: CN1.21 U26.BP3
M_A_DQ3: CN1.17 U26.BR3
M_A_DQ4: CN1.7 U26.BN5
M_A_DQ5: CN1.4 U26.BP6
M_A_DQ6: CN1.20 U26.BP2
M_A_DQ7: CN1.16 U26.BN3
M_A_DQ8: CN1.24 U26.BL4
M_A_DQ9: CN1.28 U26.BL5
M_A_DQ10: CN1.42 U26.BL2
M_A_DQ11: CN1.38 U26.BM1
M_A_DQ12: CN1.25 U26.BK4
M_A_DQ13: CN1.29 U26.BK5
M_A_DQ14: CN1.41 U26.BK1
M_A_DQ15: CN1.37 U26.BK2
M_A_DQ16: CN1.49 U26.BG4
M_A_DQ17: CN1.45 U26.BG5
M_A_DQ18: CN1.58 U26.BF4
M_A_DQ19: CN1.62 U26.BF5
M_A_DQ20: CN1.50 U26.BG2
M_A_DQ21: CN1.46 U26.BG1
M_A_DQ22: CN1.59 U26.BF1
M_A_DQ23: CN1.63 U26.BF2
M_A_DQ24: CN1.71 U26.BD2
M_A_DQ25: CN1.67 U26.BD1
M_A_DQ26: CN1.79 U26.BC4
M_A_DQ27: CN1.83 U26.BC5
M_A_DQ28: CN1.70 U26.BD5
M_A_DQ29: CN1.66 U26.BD4
M_A_DQ30: CN1.84 U26.BC1
M_A_DQ31: CN1.80 U26.BC2
M_A_DQ32: CN1.170 U26.AB1
M_A_DQ33: CN1.174 U26.AB2
M_A_DQ34: CN1.187 U26.AA4
M_A_DQ35: CN1.183 U26.AA5
M_A_DQ36: CN1.169 U26.AB5
M_A_DQ37: CN1.173 U26.AB4
M_A_DQ38: CN1.186 U26.AA2
M_A_DQ39: CN1.182 U26.AA1
M_A_DQ40: CN1.195 U26.V5
M_A_DQ41: CN1.190 U26.V2
M_A_DQ42: CN1.208 U26.U1
M_A_DQ43: CN1.204 U26.U2
M_A_DQ44: CN1.194 U26.V1
M_A_DQ45: CN1.191 U26.V4
M_A_DQ46: CN1.207 U26.U5
M_A_DQ47: CN1.203 U26.U4
M_A_DQ48: CN1.212 U26.R2
M_A_DQ49: CN1.229 U26.P5
M_A_DQ50: CN1.215 U26.R4
M_A_DQ51: CN1.225 U26.P4
M_A_DQ52: CN1.211 U26.R5
M_A_DQ53: CN1.224 U26.P2
M_A_DQ54: CN1.216 U26.R1
M_A_DQ55: CN1.228 U26.P1
M_A_DQ56: CN1.232 U26.M4
M_A_DQ57: CN1.237 U26.M1
M_A_DQ58: CN1.246 U26.L4
M_A_DQ59: CN1.245 U26.L2
M_A_DQ60: CN1.236 U26.M5
M_A_DQ61: CN1.233 U26.M2
M_A_DQ62: CN1.250 U26.L5
M_A_DQ63: CN1.249 U26.L1
M_A_DQS0: CN1.13 U26.BP5
M_A_DQS1: CN1.34 U26.BK3
M_A_DQS2: CN1.55 U26.BF3
M_A_DQS3: CN1.76 U26.BC3
M_A_DQS4: CN1.179 U26.AB3
M_A_DQS5: CN1.200 U26.V3
M_A_DQS6: CN1.221 U26.R3
M_A_DQS7: CN1.242 U26.M3
M_A_DQS#0: CN1.11 U26.BR5
M_A_DQS#1: CN1.32 U26.BL3
M_A_DQS#2: CN1.53 U26.BG3
M_A_DQS#3: CN1.74 U26.BD3
M_A_DQS#4: CN1.177 U26.AA3
M_A_DQS#5: CN1.198 U26.U3
M_A_DQS#6: CN1.219 U26.P3
M_A_DQS#7: CN1.240 U26.L3
M_A_EVENT#: CN1.134 R206.1
M_B_A0: CN11.144 U26.AJ9
M_B_A1: CN11.133 U26.AK6
M_B_A2: CN11.132 U26.AK5
M_B_A3: CN11.131 U26.AL5
M_B_A4: CN11.128 U26.AL6
M_B_A5: CN11.126 U26.AM6
M_B_A6: CN11.127 U26.AN7
M_B_A7: CN11.122 U26.AN10
M_B_A8: CN11.125 U26.AN8
M_B_A9: CN11.121 U26.AR11
M_B_A10_AP: CN11.146 U26.AH7
M_B_A11: CN11.120 U26.AN11
M_B_A12: CN11.119 U26.AR10
M_B_A13: CN11.158 U26.AF9
M_B_A14_MB_WE#: CN11.151 U26.AH11
M_B_A15_MB_CAS#: CN11.156 U26.AF8
M_B_A16_MB_RAS#: CN11.152 U26.AH10
M_B_ACT_N: CN11.114 U26.AT9
M_B_BA0: CN11.150 U26.AH8
M_B_BA1: CN11.145 U26.AH9
M_B_BG0: CN11.115 U26.AR9
M_B_BG1: CN11.113 U26.AR7
M_B_DQ0: CN11.4 U26.BT11
M_B_DQ1: CN11.8 U26.BR11
M_B_DQ2: CN11.17 U26.BT9
M_B_DQ3: CN11.20 U26.BR8
M_B_DQ4: CN11.7 U26.BP11
M_B_DQ5: CN11.3 U26.BN11
M_B_DQ6: CN11.21 U26.BP8
M_B_DQ7: CN11.16 U26.BN8
M_B_DQ8: CN11.25 U26.BL12
M_B_DQ9: CN11.29 U26.BL11
M_B_DQ10: CN11.28 U26.BL8
M_B_DQ11: CN11.42 U26.BJ8
M_B_DQ12: CN11.37 U26.BJ11
M_B_DQ13: CN11.41 U26.BJ10
M_B_DQ14: CN11.24 U26.BL7
M_B_DQ15: CN11.38 U26.BJ7
M_B_DQ16: CN11.45 U26.BG11
M_B_DQ17: CN11.49 U26.BG10
M_B_DQ18: CN11.50 U26.BG8
M_B_DQ19: CN11.63 U26.BF8
M_B_DQ20: CN11.62 U26.BF11
M_B_DQ21: CN11.58 U26.BF10
M_B_DQ22: CN11.46 U26.BG7
M_B_DQ23: CN11.59 U26.BF7
M_B_DQ24: CN11.84 U26.BB11
M_B_DQ25: CN11.71 U26.BC11
M_B_DQ26: CN11.83 U26.BB8
M_B_DQ27: CN11.66 U26.BC8
M_B_DQ28: CN11.67 U26.BC10
M_B_DQ29: CN11.80 U26.BB10
M_B_DQ30: CN11.70 U26.BC7
M_B_DQ31: CN11.79 U26.BB7
M_B_DQ32: CN11.187 U26.AA11
M_B_DQ33: CN11.183 U26.AA10
M_B_DQ34: CN11.169 U26.AC11
M_B_DQ35: CN11.173 U26.AC10
M_B_DQ36: CN11.182 U26.AA7
M_B_DQ37: CN11.186 U26.AA8
M_B_DQ38: CN11.170 U26.AC8
M_B_DQ39: CN11.174 U26.AC7
M_B_DQ40: CN11.195 U26.W8
M_B_DQ41: CN11.191 U26.W7
M_B_DQ42: CN11.204 U26.V10
M_B_DQ43: CN11.208 U26.V11
M_B_DQ44: CN11.190 U26.W11
M_B_DQ45: CN11.194 U26.W10
M_B_DQ46: CN11.203 U26.V7
M_B_DQ47: CN11.207 U26.V8
M_B_DQ48: CN11.211 U26.R11
M_B_DQ49: CN11.228 U26.P11
M_B_DQ50: CN11.225 U26.P7
M_B_DQ51: CN11.212 U26.R8
M_B_DQ52: CN11.215 U26.R10
M_B_DQ53: CN11.224 U26.P10
M_B_DQ54: CN11.216 U26.R7
M_B_DQ55: CN11.229 U26.P8
M_B_DQ56: CN11.250 U26.L11
M_B_DQ57: CN11.233 U26.M11
M_B_DQ58: CN11.249 U26.L7
M_B_DQ59: CN11.232 U26.M8
M_B_DQ60: CN11.246 U26.L10
M_B_DQ61: CN11.237 U26.M10
M_B_DQ62: CN11.236 U26.M7
M_B_DQ63: CN11.245 U26.L8
M_B_DQS0: CN11.13 U26.BP9
M_B_DQS1: CN11.34 U26.BJ9
M_B_DQS2: CN11.55 U26.BF9
M_B_DQS3: CN11.76 U26.BB9
M_B_DQS4: CN11.179 U26.AA9
M_B_DQS5: CN11.200 U26.V9
M_B_DQS6: CN11.221 U26.P9
M_B_DQS7: CN11.242 U26.L9
M_B_DQS#0: CN11.11 U26.BN9
M_B_DQS#1: CN11.32 U26.BL9
M_B_DQS#2: CN11.53 U26.BG9
M_B_DQS#3: CN11.74 U26.BC9
M_B_DQS#4: CN11.177 U26.AC9
M_B_DQS#5: CN11.198 U26.W9
M_B_DQS#6: CN11.219 U26.R9
M_B_DQS#7: CN11.240 U26.M9
M_B_EVENT#: CN11.134 R207.1
M_VREF_CA_DIMM0: C73.2 CN1.164 R37.1 R38.2 R39.1
MA_CKE0: CN1.109 U26.AT1
MA_CKE1: CN1.110 U26.AT2
MA_CLK0: CN1.137 U26.AG1
MA_CLK1: CN1.138 U26.AK2
MA_CLK#0: CN1.139 U26.AG2
MA_CLK#1: CN1.140 U26.AK1
MA_CS#0: CN1.149 U26.AD5
MA_CS#1: CN1.157 U26.AE2
MA_ODT0: CN1.155 U26.AD3
MA_ODT1: CN1.161 U26.AE4
MB_CKE0: CN11.109 U26.AT8
MB_CKE1: CN11.110 U26.AT10
MB_CLK0: CN11.137 U26.AM9
MB_CLK1: CN11.138 U26.AM7
MB_CLK#0: CN11.139 U26.AN9
MB_CLK#1: CN11.140 U26.AM8
MB_CS#0: CN11.149 U26.AF11
MB_CS#1: CN11.157 U26.AE7
MB_ODT0: CN11.155 U26.AF7
MB_ODT1: CN11.161 U26.AE8
ME_KB_ID: CNKB1.30 R155.2 R157.1 U5.69
ME_KB_QKEY: CNKB1.29 R125.2 R131.2
ME_WE: Q5.G R296.1 U5.33
ME_WE_R: Q5.D R284.2 R296.2
MIC1_JD_SENSE#: AR17.2 CN12.12
MIC1_L: AC7.1 U7.21
MIC1_R: AC6.1 U7.22
MIC1_VREF_L: AR13.2 R3627.2 U7.31
MIC1_VREF_R: AR14.2 U7.30
MIC2_L: C140.1 U7.16
MIC2_R: C141.1 U7.17
MINI_CLKREQ0#: CNWLAN1.53 R343.2 U28.AN29
MODE_1.2VS: R854.1 U25.14
MODEM_CLKREQ: CNWLAN1.14 U28.BA17
MUTE: R121.2 R123.1 U7.4
NVD_NVDS_ON_DELAY: C413.2 D26.C D51.3 R963.1 R977.1 R1007.2
NVDDS_PEX_VDD_EN: C818.1 Q96.4 Q123.G Q128.2 R849.1 R964.2 R3722.1 U721.3
NVVDD: C416.1 C417.1 C418.1 C419.1 C692.1 C693.1 C694.1 C695.1 C696.1 C697.1 C698.1 C699.1 C700.1 C701.1 C702.1 C703.1 C804.2 C806.2 C808.2 C969.1 C970.1 C971.1 C1128.2 C1137.2 C1138.2 C1144.2 C1151.2 C1152.2 C1161.2 C1163.2 C1164.2 C1167.2 C1181.2 C1182.2 C1183.2 C1184.2 C1186.2 C1187.2 C1188.2 C1189.2 C1190.2 C1191.2 C1192.2 C1244.2 C1245.2 C1246.2 C1248.2 C1249.2 C1250.2 C1251.2 C1252.2 C1253.2 C1254.2 C1255.2 C1256.2 C1257.2 C1260.2 C1261.2 C1262.2 C1263.2 C1269.2 C1273.2 C1274.2 C1275.2 C1277.2 C1279.2 C1281.2 C1282.2 C1287.2 C1313.2 C1330.2 C1331.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1338.2 C1382.2 C1383.2 C1384.2 C1386.2 C1389.2 C1390.2 C1401.2 C1402.2 C1420.1 C1424.1 C1435.1 C1436.1 C1439.1 C1449.1 C1453.1 C1459.1 C1469.1 G1.AA14 G1.AA15 G1.AA16 G1.AA17 G1.AA18 G1.AA19 G1.AA20 G1.AA21 G1.AA22 G1.AA23 G1.AA24 G1.AA25 G1.AA26 G1.AA27 G1.AA28 G1.AA29 G1.AA30 G1.AA31 G1.AA32 G1.AA33 G1.AA34 G1.AA35 G1.AA36 G1.AA37 G1.AA38 G1.AA39 G1.AB13 G1.AB40 G1.AC19 G1.AC20 G1.AC21 G1.AC22 G1.AC23 G1.AC30 G1.AC31 G1.AC32 G1.AC33 G1.AC34 G1.AE14 G1.AE15 G1.AE16 G1.AE17 G1.AE18 G1.AE19 G1.AE20 G1.AE21 G1.AE22 G1.AE23 G1.AE24 G1.AE25 G1.AE26 G1.AE27 G1.AE28 G1.AE29 G1.AE30 G1.AE31 G1.AE32 G1.AE33 G1.AE34 G1.AE35 G1.AE36 G1.AE37 G1.AE38 G1.AE39 G1.AF13 G1.AF30 G1.AF31 G1.AF32 G1.AF33 G1.AF34 G1.AF40 G1.AG13 G1.AG19 G1.AG20 G1.AG21 G1.AG22 G1.AG23 G1.AG40 G1.AH14 G1.AH15 G1.AH16 G1.AH17 G1.AH18 G1.AH19 G1.AH20 G1.AH21 G1.AH22 G1.AH23 G1.AH24 G1.AH25 G1.AH26 G1.AH27 G1.AH28 G1.AH29 G1.AH30 G1.AH31 G1.AH32 G1.AH33 G1.AH34 G1.AH35 G1.AH36 G1.AH37 G1.AH38 G1.AH39 G1.AK19 G1.AK20 G1.AK21 G1.AK22 G1.AK23 G1.AK30 G1.AK31 G1.AK32 G1.AK33 G1.AK34 G1.AL13 G1.AL40 G1.AM14 G1.AM15 G1.AM16 G1.AM17 G1.AM18 G1.AM19 G1.AM20 G1.AM21 G1.AM22 G1.AM23 G1.AM24 G1.AM25 G1.AM26 G1.AM27 G1.AM28 G1.AM29 G1.AM30 G1.AM31 G1.AM32 G1.AM33 G1.AM34 G1.AM35 G1.AM36 G1.AM37 G1.AM38 G1.AM39 G1.AP19 G1.AP20 G1.AP21 G1.AP22 G1.AP23 G1.AP30 G1.AP31 G1.AP32 G1.AP33 G1.AP34 G1.AR13 G1.AR40 G1.AT14 G1.AT15 G1.AT16 G1.AT17 G1.AT18 G1.AT19 G1.AT20 G1.AT21 G1.AT22 G1.AT23 G1.AT24 G1.AT25 G1.AT26 G1.AT27 G1.AT28 G1.AT29 G1.AT30 G1.AT31 G1.AT32 G1.AT33 G1.AT34 G1.AT35 G1.AT36 G1.AT37 G1.AT38 G1.AT39 G1.AT42 G1.AU43 G1.AV19 G1.AV20 G1.AV21 G1.AV22 G1.AV23 G1.AV30 G1.AV31 G1.AV32 G1.AV33 G1.AV34 G1.AV42 G1.AV43 G1.AV44 G1.AW13 G1.AW40 G1.AW42 G1.AW43 G1.AW44 G1.AW45 G1.AY14 G1.AY18 G1.AY22 G1.AY26 G1.AY27 G1.AY31 G1.AY35 G1.AY39 G1.AY43 G1.AY45 G1.BA43 G1.BA44 G1.BA45 G1.BA46 G1.BA47 G1.BB38 G1.BB39 G1.BB45 G1.BB46 G1.BB47 G1.BB48 G1.BC38 G1.BC39 G1.BC40 G1.BC41 G1.BC45 G1.BC47 G1.BC49 G1.BD39 G1.BD41 G1.BD46 G1.BD47 G1.BD48 G1.BD49 G1.BD50 G1.BD51 G1.BE41 G1.BE42 G1.BE43 G1.BE46 G1.BE47 G1.BE48 G1.BE49 G1.BE50 G1.BE51 G1.BE52 G1.BF42 G1.BF44 G1.BF45 G1.BF47 G1.BF49 G1.BF51 G1.BG43 G1.BG44 G1.BG45 G1.BG46 G1.BG47 G1.BG48 G1.BG49 G1.BG50 G1.BG51 G1.BG52 G1.BH44 G1.BH45 G1.BH47 G1.BH48 G1.BH49 G1.BH50 G1.BH51 G1.BH52 G1.BJ44 G1.BJ45 G1.BJ46 G1.BJ47 G1.BJ48 G1.BJ49 G1.BJ50 G1.BJ51 G1.BJ52 G1.BK47 G1.BK48 G1.BK49 G1.BK50 G1.BK51 G1.BK52 G1.BL46 G1.BL47 G1.BL48 G1.BL49 G1.BL50 G1.BL51 G1.BL52 G1.BM47 G1.BM48 G1.BM49 G1.BM50 G1.BM51 G1.N14 G1.N18 G1.N22 G1.N26 G1.N27 G1.N31 G1.N35 G1.N39 G1.P13 G1.P40 G1.R19 G1.R20 G1.R21 G1.R22 G1.R23 G1.R30 G1.R31 G1.R32 G1.R33 G1.R34 G1.U14 G1.U15 G1.U16 G1.U17 G1.U18 G1.U19 G1.U20 G1.U21 G1.U22 G1.U23 G1.U24 G1.U25 G1.U26 G1.U27 G1.U28 G1.U29 G1.U30 G1.U31 G1.U32 G1.U33 G1.U34 G1.U35 G1.U36 G1.U37 G1.U38 G1.U39 G1.V13 G1.V40 G1.W19 G1.W20 G1.W21 G1.W22 G1.W23 G1.W30 G1.W31 G1.W32 G1.W33 G1.W34 L3.2 L10.2 L11.2 R351.1 R364.1 R380.1 R381.1 R382.1 R390.1 R926.2 R1929.2 R2940.2 R2942.2
NVVDD_ADJ: R1932.2 U722.6
NVVDD_REFIN: C799.1 R974.2 R975.2 U722.7
NVVDD_VIN: C1310.1 C1311.1 C1312.1 C1448.1 C1454.1 C1455.1 C1463.1 C1464.1 C1465.1 C1466.1 C1467.1 C1468.1 C1470.1 C1471.1 C1472.1 C2396.1 C2397.1 C2398.1 C2821.1 C4120.1 PQ40.2 PQ40.3 PQ40.4 PQ41.2 PQ41.3 PQ41.4 PQ42.2 PQ42.3 PQ42.4 PQ43.2 PQ43.3 PQ43.4 PQ48.2 PQ48.3 PQ48.4 PQ49.2 PQ49.3 PQ49.4 R346.1 R971.1 R1092.2
NVVDD_VSNS: R992.2 R994.2 R996.2 U722.11
NVVDDS: C420.1 C421.1 C801.2 C1169.2 C1264.2 C1265.2 C1266.2 C1267.2 C1268.2 C1283.2 C1284.2 C1285.2 C1286.2 C1288.2 C1289.2 C1291.2 C1292.2 C1298.2 C1299.2 C1339.2 C1340.2 C1341.2 C1342.2 C1354.1 C1355.1 C1356.1 C1357.1 C1428.1 C1437.1 G1.AC14 G1.AC15 G1.AC16 G1.AC17 G1.AC18 G1.AC24 G1.AC25 G1.AC26 G1.AC27 G1.AC28 G1.AC29 G1.AC35 G1.AC36 G1.AC37 G1.AC38 G1.AC39 G1.AF14 G1.AF15 G1.AF16 G1.AF17 G1.AF18 G1.AF24 G1.AF25 G1.AF26 G1.AG27 G1.AG28 G1.AG29 G1.AG35 G1.AG36 G1.AG37 G1.AG38 G1.AG39 G1.AK14 G1.AK15 G1.AK16 G1.AK17 G1.AK18 G1.AK24 G1.AK25 G1.AK26 G1.AK27 G1.AK28 G1.AK29 G1.AK35 G1.AK36 G1.AK37 G1.AK38 G1.AK39 G1.AP14 G1.AP15 G1.AP16 G1.AP17 G1.AP18 G1.AP24 G1.AP25 G1.AP26 G1.AP27 G1.AP28 G1.AP29 G1.AP35 G1.AP36 G1.AP37 G1.AP38 G1.AP39 G1.AV14 G1.AV15 G1.AV16 G1.AV17 G1.AV18 G1.AV24 G1.AV25 G1.AV26 G1.AV27 G1.AV28 G1.AV29 G1.AV35 G1.AV36 G1.AV37 G1.AV38 G1.AV39 G1.R14 G1.R15 G1.R16 G1.R17 G1.R18 G1.R24 G1.R25 G1.R26 G1.R27 G1.R28 G1.R29 G1.R35 G1.R36 G1.R37 G1.R38 G1.R39 G1.W14 G1.W15 G1.W16 G1.W17 G1.W18 G1.W24 G1.W25 G1.W26 G1.W27 G1.W28 G1.W29 G1.W35 G1.W36 G1.W37 G1.W38 G1.W39 L28.2 R351.2 R364.2 R380.2 R381.2 R382.2 R390.2 R927.2 R2939.2 R2941.2
NVVDDS_VIN: C1363.1 C1385.1 C1414.1 C1429.1 C1434.1 C1447.1 C1450.1 PQ44.2 PQ44.3 PQ44.4 R387.1 R1093.2
ON1_1V8_AON: C3912.1 D4.3 U107.3
OVERT_GPU#: G1.BG5 Q63.S R845.2
PANEL_3.3V_ON: R986.1 U5.106 U28.AV44
PCH_2_CPU_TRIGGER: R383.1 U26.H23
PCH_AUDIO_CLK: R289.1 U26.G27
PCH_AUDIO_CLK_R: R289.2 U28.AM3
PCH_AUDIO_SDI: R7.1 U28.AN3
PCH_AUDIO_SDO: R166.1 U26.G25
PCH_AUDIO_SDO_R: R166.2 U28.AM2
PCH_BL_EN: U5.94 U28.AV46 U29.2
PCH_BL_PWM: R1022.1 U28.AU48
PCH_BM_BUSY#: TP28.1 U28.BF36
PCH_EXT_PWR_GATE#: TP27.1 U28.AP41
PCH_JTAGX: TP51.1 U28.AH4
PCH_LAN_WAKE#: Q68.D Q105.D R288.2 U28.BG44
PCH_LANPHYPWR: TP33.1 U28.BF41
PCH_PCIE_WAKE#: R290.1 U28.BB47
PCH_PLTRST_PROC: U26.BP35 U28.AG5
PCH_PM_SYNC: R91.2 U28.AF3
PCH_PWROK: R249.2 R301.2 U5.86 U23.1 U28.AY42
PCH_SMB_CLK: Q109.6 R287.1 U28.BE26
PCH_SMB_CLK_DDR: CN1.253 CN11.253 L51.2 Q109.1 R264.2 R884.2
PCH_SMB_DATA: Q109.3 R135.1 U28.BF26
PCH_SMB_DATA_DDR: CN1.254 CN11.254 L51.3 Q109.4 R266.1 R885.2
PCH_SPI0_IO2: R58.2 U28.AY48
PCH_SPI0_IO3: R74.2 U28.BA46
PCH_SPI_CLK: R71.1 U20.6
PCH_SPI_CLK_R: R71.2 U28.AW47
PCH_SPI_CS0#: U20.1 U28.AY47
PCH_SPI_HOLD#: R59.1 R74.1 U20.7
PCH_SPI_SI: R75.1 U20.5
PCH_SPI_SI_R: R72.1 R75.2 U28.AU41
PCH_SPI_SO: R57.1 U20.2
PCH_SPI_SO_R: R57.2 U28.BA45
PCH_SPI_WP: R58.1 R60.1 U20.3
PCH_SUSCLK: CNWLAN1.50 U28.BE45
PCH_THERMTRIP#: R94.2 U28.AD3
PCH_VRALERT#: TP31.1 U28.BE32
PCH_WLANPWR: R258.1 U28.BD42
PCH_XATL24_IN: C277.1 R352.1 U28.U10 Y3.1
PCH_XCLK_BIASREF: R340.2 U28.T3
PCH_XTAL24_OUT: R349.2 R352.2 U28.U9
PCIE4_CLKN_MD2_SSD1: CNSSD1.53 U28.AC14
PCIE4_CLKP_MD2_SSD1: CNSSD1.55 U28.AC15
PCIE6_CLKN_MD2_SSD2: CNSSD2.53 U28.AE14
PCIE6_CLKP_MD2_SSD2: CNSSD2.55 U28.AE15
PCIE9_RXN: CNSSD2.5 U28.G36
PCIE9_RXP: CNSSD2.7 U28.F36
PCIE9_TXN: C239.2 CNSSD2.11
PCIE9_TXN_C: C239.1 U28.C34
PCIE9_TXP: C223.2 CNSSD2.13
PCIE9_TXP_C: C223.1 U28.D34
PCIE10_RXN: CNSSD2.17 U28.K37
PCIE10_RXP: CNSSD2.19 U28.J37
PCIE10_TXN: C224.2 CNSSD2.23
PCIE10_TXN_C: C224.1 U28.C35
PCIE10_TXP: C237.2 CNSSD2.25
PCIE10_TXP_C: C237.1 U28.B35
PCIE11_RXN: CNSSD2.29 U28.G38
PCIE11_RXP: CNSSD2.31 U28.F39
PCIE11_TXN: C229.2 CNSSD2.35
PCIE11_TXN_C: C229.1 U28.B36
PCIE11_TXP: C250.2 CNSSD2.37
PCIE11_TXP_C: C250.1 U28.C36
PCIE12_RXN: CNSSD2.43 U28.H42
PCIE12_RXP: CNSSD2.41 U28.J41
PCIE12_TXN: C235.2 CNSSD2.47
PCIE12_TXN_C: C235.1 U28.D38
PCIE12_TXP: C234.2 CNSSD2.49
PCIE12_TXP_C: C234.1 U28.E37
PCIE14_RXN: C266.2 U28.D46
PCIE14_RXP: C265.2 U28.C47
PCIE14_TXN: C287.1 U1901.14
PCIE14_TXP: C300.1 U1901.13
PCIE15_RXN: CNWLAN1.43 U28.F44
PCIE15_RXP: CNWLAN1.41 U28.E45
PCIE15_TXN: C241.1 CNWLAN1.37
PCIE15_TXP: C242.1 CNWLAN1.35
PCIE17_RXN: CNSSD1.43 U28.K43
PCIE17_RXP: CNSSD1.41 U28.K44
PCIE17_TXN: C236.2 CNSSD1.47
PCIE17_TXN_C: C236.1 U28.A42
PCIE17_TXP: C233.2 CNSSD1.49
PCIE17_TXP_C: C233.1 U28.B42
PCIE18_RXN: CNSSD1.29 U28.P41
PCIE18_RXP: CNSSD1.31 U28.R40
PCIE18_TXN: C230.2 CNSSD1.35
PCIE18_TXN_C: C230.1 U28.C42
PCIE18_TXP: C226.2 CNSSD1.37
PCIE18_TXP_C: C226.1 U28.D42
PCIE19_RXN: CNSSD1.17 U28.M44
PCIE19_RXP: CNSSD1.19 U28.N42
PCIE19_TXN: C228.2 CNSSD1.23
PCIE19_TXN_C: C228.1 U28.C44
PCIE19_TXP: C243.2 CNSSD1.25
PCIE19_TXP_C: C243.1 U28.D43
PCIE20_RXN: CNSSD1.5 U28.R35
PCIE20_RXP: CNSSD1.7 U28.R37
PCIE20_TXN: C249.2 CNSSD1.11
PCIE20_TXN_C: C249.1 U28.A44
PCIE20_TXP: C245.2 CNSSD1.13
PCIE20_TXP_C: C245.1 U28.B44
PCIE_DETECT_SSD1: CNSSD1.69 R342.2 U28.AM46
PCIE_DETECT_SSD2: CNSSD2.69 R335.2 U28.AJ43
PCIE_RCOMPN: R366.2 U28.B12
PCIE_RCOMPP: R366.1 U28.A13
PCIE_TXN14_C: C287.2 U28.C39
PCIE_TXP14_C: C300.2 U28.D39
PEG_TXN0: C1476.1 U26.A25
PEG_TXN1: C1477.1 U26.C24
PEG_TXN2: C1478.1 U26.A23
PEG_TXN3: C1479.1 U26.C22
PEG_TXN4: C1480.1 U26.A21
PEG_TXN5: C1481.1 U26.C20
PEG_TXN6: C1482.1 U26.A19
PEG_TXN7: C1483.1 U26.C18
PEG_TXN8: C1488.1 U26.B17
PEG_TXN9: C1489.1 U26.B16
PEG_TXN10: C1490.1 U26.B15
PEG_TXN11: C1491.1 U26.B14
PEG_TXN12: C1510.1 U26.B13
PEG_TXN13: C1512.1 U26.B12
PEG_TXN14: C1514.1 U26.B11
PEG_TXN15: C1516.1 U26.B10
PEG_TXP0: C1492.1 U26.B25
PEG_TXP1: C1493.1 U26.B24
PEG_TXP2: C1494.1 U26.B23
PEG_TXP3: C1495.1 U26.B22
PEG_TXP4: C1496.1 U26.B21
PEG_TXP5: C1497.1 U26.B20
PEG_TXP6: C1498.1 U26.B19
PEG_TXP7: C1499.1 U26.B18
PEG_TXP8: C1504.1 U26.A17
PEG_TXP9: C1505.1 U26.C16
PEG_TXP10: C1506.1 U26.A15
PEG_TXP11: C1507.1 U26.C14
PEG_TXP12: C1509.1 U26.A13
PEG_TXP13: C1511.1 U26.C12
PEG_TXP14: C1513.1 U26.A11
PEG_TXP15: C1515.1 U26.C10
PEX_CLKREQ#: G1.BL26 Q78.S R756.1 R765.1
PEX_RST#: G1.BK26 Q99.4 R158.2 R3204.1
PEX_RST_HOLD#_GC6: G1.BG3 R2810.2
PEX_RXN0: C822.1 U26.D25
PEX_RXN1: C824.1 U26.F24
PEX_RXN2: C826.1 U26.D23
PEX_RXN3: C828.1 U26.F22
PEX_RXN4: C829.1 U26.D21
PEX_RXN5: C831.1 U26.F20
PEX_RXN6: C833.1 U26.D19
PEX_RXN7: C834.1 U26.F18
PEX_RXN8: C847.1 U26.E17
PEX_RXN9: C851.1 U26.E16
PEX_RXN10: C853.1 U26.E15
PEX_RXN11: C855.1 U26.E14
PEX_RXN12: C867.1 U26.E13
PEX_RXN13: C1223.1 U26.E12
PEX_RXN14: C1225.1 U26.E11
PEX_RXN15: C1227.1 U26.E10
PEX_RXP0: C788.1 U26.E25
PEX_RXP1: C821.1 U26.E24
PEX_RXP2: C823.1 U26.E23
PEX_RXP3: C825.1 U26.E22
PEX_RXP4: C789.1 U26.E21
PEX_RXP5: C827.1 U26.E20
PEX_RXP6: C830.1 U26.E19
PEX_RXP7: C832.1 U26.E18
PEX_RXP8: C848.1 U26.D17
PEX_RXP9: C846.1 U26.F16
PEX_RXP10: C854.1 U26.D15
PEX_RXP11: C852.1 U26.F14
PEX_RXP12: C868.1 U26.D13
PEX_RXP13: C859.1 U26.F12
PEX_RXP14: C1226.1 U26.D11
PEX_RXP15: C1224.1 U26.F10
PEX_TERMP: G1.BL44 R2729.2
PEX_VCC_FB: C333.1 R178.2 R215.1 U30.6
PEX_VCC_LX: L46.1 R409.1 U30.1 U30.2 U30.3
PEX_VDD: C333.2 C400.1 C405.1 C522.1 C782.2 C783.2 C784.2 C785.2 C856.1 C860.1 C866.1 C1153.2 C1218.2 C1370.1 C1438.1 C1451.2 C1456.2 C1458.2 G1.BB15 G1.BB17 G1.BB18 G1.BB20 G1.BB21 G1.BB23 G1.BB33 G1.BB35 G1.BB36 G1.BC15 G1.BC17 G1.BC18 G1.BC20 G1.BC21 G1.BC23 G1.BC33 G1.BC35 G1.BC36 G1.BD33 G1.BD36 L46.2 R178.1 R934.2
PEX_VDD_ON_R: C1426.1 R849.2 U30.5
PFM_+1.0VA: R62.2 R87.1 U17.3
PFM_+3.3VA: R61.2 R68.1 U12.3
PFM_VCCIO: R65.2 R70.1 U18.3
PG_+1.0VA: D3.3 D29.C R931.1 U17.1
PG_+1.8VA: R63.2 R942.2 U19.4
PG_+3.3VA: R64.2 R889.1 U12.1
PG_+5VA: R93.2 R225.1 U9.1
PG_FBVDDQ: D4.2 D52.2 R3537.2 U84.1
PG_PEX_VDD: D16.1 D52.1 Q165.1 R3536.2 U30.4
PG_VCCIO: R937.1 U18.1
PH1_NVD: C273.2 L3.1 PQ42.9 PQ43.9 R981.2 R991.1 R1060.1 R1065.1 U722.24
PH2_NVD: C272.2 L10.1 PQ40.9 PQ41.9 R982.2 R990.1 R1054.1 R1061.1 U722.19
PH3_NVD: C274.2 L11.1 PQ48.9 PQ49.9 R983.2 R995.1 R1064.1 R1066.1 U32.8
PHASE_GCORE1: C720.2 L28.1 PQ44.9 R422.2 R973.2 R980.1 U721.20
PID_2_PWR_LED0: C436.1 Q30.G R316.2
PIRQA#: R339.1 U28.BA36
PLT_RST#: CNDEG1.4 CNSSD1.50 CNSSD2.50 CNWLAN1.52 Q99.1 R67.2 R95.2 U5.22 U28.AV29 U1901.19
PM_CLKRUN#: R273.1 U5.93 U28.AV32
PM_DOWN: R21.1 U28.AE2
PM_DOWN_R: R21.2 U26.BP31
PM_RSMRST#: R285.2 R299.2 R311.1 U5.66 U28.BA47
PM_SLP_S3#: R172.2 R3377.1 U5.109 U23.2 U24.2 U28.BF42
PM_SLP_S4#: R156.1 R3372.1 U5.108 U28.BE42 U104.5 U106.3
PM_SLP_S5#: TP29.1 U28.BC42
PM_SLP_SUS#: TP30.1 U28.BD39
PM_SYNC: R91.1 U26.BM34
PRDY#_PCH: TP54.1 U28.AM5
PREQ#_PCH: TP53.1 U28.AL2
PROC_AUDIO_SDO_R: R7.2 U26.G29
PROCHOT#: Q1.D Q3.3 R28.1 R29.1 R47.1 R3320.2
PROCHOT#_R: R47.2 U26.BR30
PROCHOT_#: R3320.1 R3323.2 U97.10
PROCPWRGD_CPU: U26.BT31 U28.AE3
PS_NVVDD_COMP: C2549.1 R955.2 U722.12
PS_NVVDD_EN: C1427.1 D51.1 Q125.G R977.2 U722.3
PS_NVVDD_GNDSNS_R: C797.2 C799.2 R976.1 R998.2 R3541.2
PS_NVVDD_PGOOD_PCH: R972.2 U722.16
PS_NVVDD_PSI: R943.2 R945.1 U722.4
PS_NVVDD_PVCC: C1362.2 R970.1 U722.21
PS_NVVDD_VID: C800.1 R2938.2 U722.5
PS_NVVDD_VREF: C803.2 R935.2 U722.8
PS_NVVDD_VREF_L: C797.1 R933.1 R936.1 R974.1
PS_NVVDD_VSNS: C805.1 C807.1 C809.1 R1002.1
PS_NVVDDS_COMP: C2551.2 R958.1 U721.12
PS_NVVDDS_PVCC: C817.1 C1361.2 R969.2 U721.18
PS_NVVDDS_VID: G1.BE4 R949.1 R2815.2
PS_NVVDDS_VREF: C816.1 C1364.2 R928.2 R967.1 U721.8
PSYS_H: C3565.2 R513.2 R3309.1 U97.9
PWM3_NVD: R308.2 U32.3
PWM3_NVD_R: R99.2 R308.1 U722.22
PWM_EDP: C465.1 CNEDP1.27 R1022.2 S14.1
PWR LED N: C4115.1 CN9.4 CN12.41 Q30.D R13.1 SW6.L2
PWR_B_LED_GND: LED4.C Q182.C R3624.1
PWR_LED#: R316.1 U5.31
PWR_LED+: R585.1 SW6.L1
PWR_LED_5V: Q50.D R15.2 R585.2
PWR_USB#: R143.1 R623.2 U5.83 U27.4 U31.4 U733.4
PWRBTN#: U5.21 U28.BE46
PWRON#: C641.1 C3989.1 CN9.2 CN12.43 Q47.2 Q116.5 R31.2 R125.1 R203.2 R218.1 S17.1 S111.1 SW2.1 SW2.2
PWRSW: Q47.3 R216.1 U5.125
PWRSW_0: Q47.5 Q47.6 R297.1 R359.2
QKEY0#: R131.1 U5.95
QKEY1#: C8.1 C296.1 C3988.1 CN9.9 CN12.47 R3514.2 R3702.2 S1.1 S110.1 SW1.1 SW1.2 SW3.3 SW3.4 U5.85
QKEY2#: C292.1 CN9.10 CN12.46 R313.2 R3512.2 R3625.1 U5.88
REGOUT_LAN: L54.1 R213.1 U1901.24
ROM_CS#: G1.BJ4 R2875.1 U83.1
ROM_SCLK: G1.BK3 R820.1 R825.2 R2865.1
ROM_SCLK_R: R2865.2 U83.6
ROM_SI: G1.BK2 R822.2 R824.1 R2876.1
ROM_SI_R: R2876.2 U83.5
ROM_SO: G1.BK4 R821.1 R823.2 U83.2
RT8237E_BOOT_GDDR: R838.2 U84.10
RT8237E_CS_GDDR: C668.1 R836.1 U84.2
RT8237E_FB_GDDR: C151.2 C556.1 C559.2 R124.1 R127.2 R1125.1 U84.4
RT8237E_LX_GDDR: C665.2 L43.1 PQ52.9 PQ53.9 R552.2 U84.8
RT8237E_RF_GDDR: C673.1 R835.1 U84.5
RT8237E_VDD_GDDR: C663.1 R837.1 U84.7
RTC_X1: C281.2 R353.1 U28.BA49 Y1.1
RTC_X2: C280.2 R353.2 U28.BA48 Y1.2
RTCRST#: C253.1 JP1.1 R149.2 R269.1 U28.BE47
RUN_ON: R3376.1 U5.118 U104.3 U106.5
RUN_ON_CPU_1.00V: R3376.2 R3377.2 U105.5
S_GND_R: AR25.1 CN12.2 CN12.3
SA0_DIM0: CN1.256 R175.1 R180.2
SA0_DIM1: CN11.256 R183.2 R184.1
SA1_DIM0: CN1.260 R167.2 R169.1
SA1_DIM1: CN11.260 R188.1 R195.2
SA2_DIM0: CN1.166 R173.1 R205.2
SA2_DIM1: CN11.166 R211.2 R227.1
SAFTY_PROTECT: R3325.1 R3326.2 U5.112
SATA_PWR_EN: R1014.1 U28.AU46
SATA_RXN0: C18.2 U28.C45
SATA_RXN0_C: C18.1 CNHDD1.5
SATA_RXP0: C19.2 U28.C46
SATA_RXP0_C: C19.1 CNHDD1.6
SATA_TXN0: C17.2 U28.B38
SATA_TXN0_C: C17.1 CNHDD1.3
SATA_TXP0: C16.2 U28.C38
SATA_TXP0_C: C16.1 CNHDD1.2
SD_RCOMP_1P8: R354.1 U28.BE5
SD_RCOMP_3P3: R358.1 U28.BE4
SENBAT_V: R191.2 U5.56
SENSEA: AR5.1 AR17.1 U7.13
SKL_CNL_N: R24.2 U26.BN1
SLP_LAN: R256.2 U28.BF40
SLP_S0#: U28.BC28
SM_INTRUDER#: R142.2 U28.BB44
SMBALERT#: R137.2 U28.BE25
SMBCLK_EC: C334.2 Q58.6 R475.1 U3.33 U5.115 U28.BF27
SMBCLK_KB: Q60.1 R122.1 R488.1
SMBDAT_EC: C335.2 Q58.3 R482.1 U3.32 U5.116 U28.BE27
SMBDAT_KB: CNKB1.31 Q60.4 R487.1
SMC_WAKE_SCI#: R114.2 R126.1 U28.BB24
SMI#: R336.1 U28.T48
SML0ALERT#: R112.2 U28.BF24
SML0CLK: R314.2 U28.BF25
SML0DATA: R286.2 U28.BE24
SML1ALERT#: R309.2 U28.BD33
SPI0_CS1#: TP19.1 U28.AW48
SPI0_CS2#: TP25.1 U28.AT40
SPI_CE#: U5.101 U8.1
SPI_CLK: B2.1 C227.1 U5.105
SPI_CLK_EC: B2.2 U8.6
SPI_HOLD#: R168.1 U8.7
SPI_SI: U5.102 U8.5
SPI_SO: U5.103 U8.2
SPI_WP#: R171.1 U8.3
SPK_L+: AB12.2 ACN1.4 C258.1 S6.1
SPK_L-: AB11.2 ACN1.3 C256.1 S5.1
SPK_R+: AB8.2 ACN1.1 C225.1 S7.1
SPK_R-: AB9.2 ACN1.2 C240.1 S8.1
SPKL1+: AB12.1 U7.40
SPKL1-: AB11.1 U7.41
SPKR1+: AB8.1 U7.45
SPKR1-: AB9.1 U7.44
SRTCRST#: C259.1 JP2.1 Q16.3 R138.2 U28.BD46
SS_+1.0VA: C88.2 U17.23
SS_+3.3VA: C87.2 U12.23
SS_+5VA: C1315.1 U9.23
SS_VCCIO: C89.2 U18.23
SSD1_DEVSLP4: CNSSD1.38 U28.AR47
SSD2_DEVSLP1: CNSSD2.38 U28.AH35
STRAP0: G1.BL3 R398.1 R818.1
STRAP1: G1.BL4 R787.1 R790.2
STRAP2: G1.BM4 R791.1 R815.2
STRAP3: G1.BM5 R792.1 R819.2
STRAP4: G1.BK5 R816.1 R817.2
STRAP5: G1.BJ5 R860.1 R861.2
SUSACK#: R300.2 U28.BE35
SUSWARN#: R300.1 U28.BC37
SW1_VRA: C1314.2 L12.1 R579.1 U4.2 U4.3 U4.4
SW2_GT: C1324.2 L20.1 R583.1 U13.2 U13.3 U13.4
SW2_VRA: C1316.2 L14.1 R580.1 U6.2 U6.3 U6.4
SW3_VRA: C1317.2 L15.1 R581.1 U10.2 U10.3 U10.4
SW4_VRA: C1323.2 L17.1 R582.1 U11.2 U11.3 U11.4
SW_1.2VS: C581.2 L13.1 R3202.2 U25.9
SW_SA: C1325.2 L21.1 R584.1 U15.2 U15.3 U15.4
SYS_PWROK: R293.2 R302.2 U5.57 U28.AU3
SYS_RESET#: R294.1 U28.AU2
SYS_TEMP_EC: R170.1 RT10.2 U5.67
T/P LED_PWM: R2665.2 U5.30
TBTA_CC1: CON3.A5 R632.2
TBTA_CC2: CON3.B5 R793.2
TEMP_MPS: C1170.1 R532.1 R533.1 U3.45
TMDSB_CLK+: C404.2 L25.4 R425.2 R500.1
TMDSB_CLK-: C365.2 L25.1 R427.2 R499.1
TMDSB_D0+: C409.2 L27.4 R426.2 R463.1
TMDSB_D0-: C408.2 L27.1 R429.2 R444.1
TMDSB_D1+: C369.2 L26.4 R418.2 R496.1
TMDSB_D1-: C403.2 L26.1 R428.2 R477.1
TMDSB_D2+: C414.2 L24.4 R408.2 R498.1
TMDSB_D2-: C411.2 L24.1 R424.2 R497.1
TON_+1.0VA: R1397.2 U17.6
TON_+3.3VA: R879.2 U12.6
TON_+5VA: R224.2 U9.6
TON_VCCIO: R1398.2 U18.6
TP20: G1.BK24 TP20.1
TP23: G1.BL23 TP23.1
TP32: G1.BM23 TP32.1
TP34: G1.BM24 TP34.1
TP35: G1.BL24 R2799.1 TP35.1
TP36: G1.BK23 R2800.1 TP36.1
TP_CLK: C297.1 L48.2 R472.2 R882.2 R1000.2 U5.89
TP_DATA: C298.1 L48.3 R460.2 R883.2 R940.2 U5.90
TP_INT#: R3521.2 U28.AM45
TP_LED_PWM_OUT: CN42.6 R2667.2
TP_P: C291.1 CN17.8 R253.2 R3523.2
TR0+: CN34.1 LT2.17
TR0-: CN34.2 LT2.16
TR1+: CN34.3 LT2.14
TR1-: CN34.6 LT2.13
TR2+: CN34.4 LT2.23
TR2-: CN34.5 LT2.22
TR3+: CN34.7 LT2.20
TR3-: CN34.8 LT2.19
TS_VREF: G1.BF12 TP21.1
TYPC_RX1+: CON3.B11 ESD2.5 ESD2.6 L37.1 R417.1
TYPC_RX1-: CON3.B10 ESD2.4 ESD2.7 L37.4 R416.1
TYPC_RX2+: CON3.A11 ESD1.5 ESD1.6 L38.4 R419.1
TYPC_RX2-: CON3.A10 ESD1.4 ESD1.7 L38.1 R394.1
TYPC_TX1+: CON3.A2 ESD2.2 ESD2.9 L45.1 R388.1
TYPC_TX1-: CON3.A3 ESD2.1 ESD2.10 L45.4 R386.1
TYPC_TX2+: CON3.B2 ESD3.1 ESD3.10 L44.1 R385.1
TYPC_TX2-: CON3.B3 ESD3.2 ESD3.9 L44.4 R384.1
TYPE_C_D1+: CON3.A6 ESD1.1 ESD1.10 L36.1 R392.1
TYPE_C_D1-: CON3.A7 ESD1.2 ESD1.9 L36.4 R413.1
TYPE_C_D2+: CON3.B6 ESD3.4 ESD3.7 L34.1 R415.1
TYPE_C_D2-: CON3.B7 ESD3.5 ESD3.6 L34.4 R414.1
TYPE_C_OC#: R81.2 U27.5 U28.AH36
UART2_DEBUG_RXD: CNDEG2.3 R327.2 TP2.1 U28.BD20
UART2_DEBUG_TXD: CNDEG2.4 R329.2 TP1.1 U28.BE20
UG1_NVD: PQ42.1 PQ43.1 R1060.2 U722.2
UG2_NVD: PQ40.1 PQ41.1 R1061.2 U722.17
UG3_NVD: PQ48.1 PQ49.1 R1066.2 U32.1
UG_MEM: PQ52.1 PQ53.1 U84.9
USB0_5V: C499.1 C500.1 C576.1 C630.1 C631.1 C632.1 C4078.1 C4079.1 CN23.1 U31.6 U31.7 U31.8
USB1_5V: C4102.1 C4103.1 C4105.1 C4106.1 C4107.1 C4108.1 C4109.1 C4110.1 CN32.1 U733.6 U733.7 U733.8
USB3_TX1_N_C: C261.2 U28.F9
USB3_TX1_P_C: C498.2 U28.F7
USB3_TX3_N_C: C268.2 U28.F11
USB3_TX3_P_C: C271.2 U28.G12
USB3_TX5_N_C: C270.2 U28.B15
USB3_TX5_P_C: C275.2 U28.C15
USB3_TX6_N_C: C269.2 U28.C17
USB3_TX6_P_C: C262.2 U28.C16
USB31_1_RX_N: L37.3 R416.2 U28.D11
USB31_1_RX_P: L37.2 R417.2 U28.C11
USB31_1_TX_N: C261.1 L45.3 R386.2
USB31_1_TX_P: C498.1 L45.2 R388.2
USB31_3_RX_N: L38.2 R394.2 U28.B10
USB31_3_RX_P: L38.3 R419.2 U28.C10
USB31_3_TX_N: C268.1 L44.3 R384.2
USB31_3_TX_P: C271.1 L44.2 R385.2
USB31_5_RX_N: L67.2 R3697.2 U28.K13
USB31_5_RX_P: L67.3 R3698.2 U28.J13
USB31_5_TX_N: C270.1 L66.2 R3700.2
USB31_5_TX_P: C275.1 L66.3 R3699.2
USB31_6_RX_N: L23.2 R607.2 U28.G14
USB31_6_RX_P: L23.3 R608.2 U28.F14
USB31_6_TX_N: C269.1 L29.2 R600.2
USB31_6_TX_P: C262.1 L29.3 R599.2
USB32_OC#: R77.2 U28.AL40 U733.5
USB32_RX_N_IN: CN32.5 D60.1 L67.1 R3697.1 S113.1
USB32_RX_P_IN: CN32.6 D60.2 L67.4 R3698.1 S114.1
USB32_TX_N_IN: CN32.8 D62.1 L66.1 R3700.1 S112.1
USB32_TX_P_IN: CN32.9 D62.2 L66.4 R3699.1 S115.1
USB33_OC#: R86.2 U28.AJ44 U31.5
USB33_RX_N_IN: CN23.5 D38.1 L23.1 R607.1 S30.1
USB33_RX_P_IN: CN23.6 D38.2 L23.4 R608.1 S29.1
USB33_TX_N_IN: CN23.8 D39.1 L29.1 R600.1 S27.1
USB33_TX_P_IN: CN23.9 D39.2 L29.4 R599.1 S25.1
USB_PN1: L34.3 R414.2 U28.J3
USB_PN2: R3710.2 U28.N13
USB_PN3: CN12.38 U28.K4
USB_PN4: L22.3 R606.2 U28.M10
USB_PN5: L36.3 R413.2 U28.M1
USB_PN6: R139.1 U28.K7
USB_PN7: CN14.3 U28.L4
USB_PN8: CN14.6 U28.G4
USB_PN9: L65.3 R3695.2 U28.M6
USB_PN12: CN12.34 U28.G1
USB_PN13: L16.3 R528.2 U28.N3
USB_PN14: CNWLAN1.5 U28.E5
USB_PP1: L34.2 R415.2 U28.J2
USB_PP2: R3711.2 U28.N15
USB_PP3: CN12.37 U28.K3
USB_PP4: L22.2 R605.2 U28.L9
USB_PP5: L36.2 R392.2 U28.L2
USB_PP6: R153.1 U28.K6
USB_PP7: CN14.2 U28.L3
USB_PP8: CN14.5 U28.G5
USB_PP9: L65.2 R3694.2 U28.N8
USB_PP12: CN12.33 U28.G2
USB_PP13: L16.2 R542.2 U28.N2
USB_PP14: CNWLAN1.3 U28.F6
V_DDR_CA_VREF: C72.2 R37.2 U26.BN13
VAD_BATT: C3556.2 Q8.1 Q8.2 Q8.3 Q9.1 Q9.2 Q9.3 R3322.1
VB: Q88.3 Q88.6 Q116.6 Q163.G R899.2 R901.1
VCHG: B36.2 B37.2 C3548.1 C3559.2 D28.2 R3311.2 R3318.2
VCHG_OUT: C3544.1 C3545.1 C3546.1 C3547.1 C3560.2 C3564.1 L49.1 Q10.1 Q10.2 Q10.3 R3307.2 R3311.1 R3336.2
VCORE_VCCSENSE: R49.1 R550.1 U26.AG37
VCORE_VSSSENSE: R48.2 R551.1 U26.AG38
VIDALERT#: R8.2 U26.BH31
VR_READY: R794.2 U3.30 U5.68
VR_VIDALERT#: R8.1 R691.2 R951.2
VR_VIDSCK: R780.2 R785.2 U26.BH32
VR_VIDSOUT: R750.2 R953.2 U26.BH29
VRA_ADDRP: R511.2 R512.1 U3.25
VRA_GND: C155.1 C156.1 C157.1 C158.2 C165.2 C166.2 C216.2 C592.1 C602.1 C615.1 C656.2 C1170.2 PJP3210.1 R512.2 R514.2 R521.2 R529.2 R530.2 R531.2 R532.2 R559.2 R803.2 U3.S1
VRA_IREF: R521.1 U3.24
VRA_PE: C602.2 R514.1 R515.2 U3.36 U5.82
VRA_PSYS: C592.2 R513.1 R803.1 U3.46
VRA_STB: U3.34 U4.16 U6.16 U10.16 U11.16 U13.16 U15.16
VRA_VDD18: C656.1 R511.1 R515.1 U3.26
VRA_VIDALERT#: R951.1 U3.29
VRA_VIDSCLK: R780.1 U3.27
VRA_VIDSOUT: R953.1 U3.28
VRA_VINSEN: C615.2 R558.2 R559.1 U3.47
VRA_VTEMP: R533.2 R573.2 R574.2 R575.2 R576.2 R577.2 R578.2
VRACPU_CS1: R522.2 U3.5 U4.18
VRACPU_CS2: R523.2 U3.4 U6.18
VRACPU_CS3: R524.2 U3.3 U10.18
VRACPU_CS4: R525.2 U3.2 U11.18
VRACPU_CSUMA: R522.1 R523.1 R524.1 R525.1 U3.18
VRACPU_IMON: C155.2 R529.1 U3.21
VRACPU_PWM1: R566.2 U3.43
VRACPU_PWM1_R: R566.1 U4.15
VRACPU_PWM2: R567.2 U3.42
VRACPU_PWM2_R: R567.1 U6.15
VRACPU_PWM3: R568.2 U3.41
VRACPU_PWM3_R: R568.1 U10.15
VRACPU_PWM4: R569.2 U3.40
VRACPU_PWM4_R: R569.1 U11.15
VRACPU_VDIFF: C438.2 R553.2 U3.6
VRACPU_VFB: C438.1 R553.1 R554.2 U3.7
VRACPU_VORTN: R551.2 U3.9
VRACPU_VOSEN: R550.2 U3.8
VRACPU_VTEMP1: R573.1 U4.17
VRACPU_VTEMP2: R574.1 U6.17
VRACPU_VTEMP3: R575.1 U10.17
VRACPU_VTEMP4: R576.1 U11.17
VRAGT_CS2: R526.2 U3.1 U13.18
VRAGT_CSUMB: R526.1 U3.19
VRAGT_IMON: C156.2 R530.1 U3.22
VRAGT_PWM2: R570.2 U3.39
VRAGT_PWM2_R: R570.1 U13.15
VRAGT_VDIFF: C289.2 R548.2 U3.10
VRAGT_VFB: C289.1 R548.1 R549.2 U3.11
VRAGT_VORTN: R547.2 U3.13
VRAGT_VOSEN: R539.2 U3.12
VRAGT_VTEMP2: R577.1 U13.17
VRASA_CS1: R527.2 U3.48 U15.18
VRASA_CSUMC: R527.1 U3.20
VRASA_IMON: C157.2 R531.1 U3.23
VRASA_PWM1: R571.2 U3.38
VRASA_PWM1_R: R571.1 U15.15
VRASA_VDIFF: C288.1 R534.2 U3.14
VRASA_VFB: C288.2 R534.1 R535.2 U3.15
VRASA_VORTN: R538.2 U3.17
VRASA_VOSEN: R536.2 U3.16
VRASA_VTEMP1: R578.1 U15.17
VREF_CODEC: C161.1 C163.1 U7.27
VTTREF_1.2VS: C119.1 U25.7
WEBCAM_+5V: B14.1 B25.1 C669.1 CNEDP1.39
WEBCAM_ON: R192.1 R251.2 R989.1 U5.124
WEBCAM_USB+: CNEDP1.37 D45.2 L16.1 R542.1 S15.1
WEBCAM_USB-: CNEDP1.38 D45.1 L16.4 R528.1 S16.1
WLAN_3.3VDD: C3491.2 C3493.2 C3495.2 C3496.2 CNWLAN1.2 CNWLAN1.4 CNWLAN1.72 CNWLAN1.74 Q147.D R281.2 R909.1
WLAN_LED_MD#: CNWLAN1.6 R281.1
WLAN_ON: CNWLAN1.56 R140.2 R141.1 U5.17
WP#_DGPU: R2877.1 U83.3
XDP_PRDY#: R25.1 U26.BP27
XDP_PREQ#: TP16.1 U26.BL30
XDP_TCK: R27.1 U26.BR28
XDP_TDI: TP9.1 U26.BL32
XDP_TDO: R198.1 U26.BT28
XDP_TMS: TP11.1 U26.BP28
XDP_TRST#: TP15.1 U26.BP30
XTALIN: C1419.2 G1.BL6 Y10.3
XTALOUT: C1418.2 G1.BM6 Y10.1
XTALOUTBUFF: G1.BK6 R2771.2
XTALSSIN: G1.BJ6 R2781.2
N883295: Q44.2 Q44.3 R150.2 R404.1
N883416: Q42.G R404.2 R405.2
N888421: Q101.G Q113.5 Q113.6 R911.2
N891534: Q27.G Q57.D R509.2
N906504: C667.1 C2575.1 CNEDP1.40 R989.2
N963492: C428.2 Q86.G R430.1
N963794: Q86.D R408.1 R418.1 R424.1 R425.1 R426.1 R427.1 R428.1 R429.1
N1023915: Q58.2 Q58.5 R492.1 R501.1
N1590508: AC6.2 AR9.2 AR18.1
N1590745: AC7.2 AR8.2 AR18.2
N1812137: C3572.2 R3331.2 U97.28
N1820431: C3564.2 Q10.4 R3327.2
N1840040: C3556.1 C3582.2 Q9.4 R3319.1 R3321.2
N1860184: C244.1 Q119.5 R191.1 R196.1
N1862290: R317.2 R320.2
N1862418: C355.1 R320.1 R326.1 U2.1
N2049790: Q120.6 R420.2
N2051160: C426.1 Q120.2 Q120.3 R347.1 R393.2
N2053305: C410.1 Q120.5 R325.2 R3326.1
N18840201: Q44.6 R3036.2
N19731168: CNWLAN1.38 TP194.1
N19731171: CNWLAN1.40 TP190.1
N19731174: CNWLAN1.42 TP193.1
N22296316: R971.2 U722.9
N22296338: R933.2 R1932.1
N22296342: R935.1 R936.2
N22296384: R975.1 R976.2
N22296783: Q126.D R1929.1
N22297924: R984.1 R990.2
N22297928: R979.1 R991.2
N22297930: R985.1 R995.2
N22298251: C1368.1 Q125.D Q126.G Q139.G R1794.1
N22300749: C273.1 R232.2
N22302053: C272.1 R239.2
N22554790: C1325.1 U15.21
N23471734: C1222.1 R584.2
N23555323: Q67.G R357.2 R3325.2
N24336526: L27.2 R444.2 R502.1
N24336578: L27.3 R463.2 R504.1
N24336650: L26.2 R477.2 R507.1
N24336705: L26.3 R496.2 R516.1
N24336752: L24.2 R497.2 R518.1
N24336771: L24.3 R498.2 R517.1
N24336854: L25.2 R499.2 R537.1
N24336873: L25.3 R500.2 R519.1
N25303038: Q139.D R926.1
N25505101: G1.BD20 TP95.1
N25505109: G1.BD18 TP96.1
N25508077: Q104.5 Q104.6 R832.2
N25508415: Q92.5 Q92.6 R3539.2
N25531916: C877.2 R2737.1 R2738.1
N25531999: Q62.D R2713.2
N25542499: C879.2 R2741.1 R2742.1
N25542563: Q64.D R2719.2
N25548280: C1042.2 R2745.1 R2746.1
N26058442: C452.1 Q44.5 R373.1
N26121620: R148.2 U26.G2
N26123034: R262.1 U26.D37
N26124061: Q2.5 Q2.6 R36.1
N26124148: TP7.1 U26.AW13
N26124150: TP14.1 U26.AT13
N26124355: R46.1 U26.BT25
N26148392: C203.1 C207.1 R197.1 U26.BH13 U26.BJ13 U26.G11
N26150436: R431.1 U26.J23
N26150438: R432.1 U26.A36
N26150440: R433.1 U26.A37
N26151913: R82.2 U28.BE41
N26152241: R80.2 U28.AV43
N26152243: R88.2 U28.AR37
N26152245: R89.2 U28.AR35
N26152247: R85.2 U28.AV47
N26152271: R78.2 U28.F3
N26152273: R84.2 U28.F4
N26152279: R83.2 U28.G3
N26153792: R92.1 U28.AN47
N26154194: R109.1 U28.AK47
N26154209: R107.1 U28.AM43
N26154211: R100.1 U28.AH41
N26156301: D1.2 R133.1
N26156319: CN4.1 R133.2
N26156460: D1.1 R113.2 R164.1
N26156487: Q16.6 R269.2 R315.1
N26158678: R334.1 U28.BB34
N26158680: R323.1 U28.BB36
N26158684: TP10.1 U28.BF38
N26159826: C276.1 R349.1 Y3.3
N26162446: C323.2 R369.1 U28.AN24
N26162493: R376.1 U28.AF19 U28.AF20
N26162920: C283.1 R389.1 U28.BG5
N26166714: R383.2 U28.AK3
N26182237: CNWLAN1.55 Q105.S R435.1
N26195158: Q100.5 Q100.6 Q106.G R1010.2
N26195204: Q100.3 R510.1
N26195271: C1349.2 Q100.2 R1014.2
N26196507: Q147.G Q148.D R3240.2
N26288217: C720.1 R925.1
N26288246: C1043.1 R422.1
N26288248: C544.1 R958.2
N26289109: R961.2 U721.13
N26289115: R939.1 R944.2 R956.2 U721.4
N26289147: C1367.1 Q123.D Q124.G R795.1
N26289174: Q124.D R927.1
N26289193: R967.2 R968.1 U721.9
N26289201: R949.2 U721.5
N26289253: C796.1 R923.1 R930.1 R938.1
N26289271: C798.1 R938.2 R960.2 U721.7
N26289273: R922.2 U721.6
N26289275: R922.1 R923.2
N26289279: R928.1 R930.2
N26289296: R960.1 R962.2
N26319346: R247.2 U14.1
N26319364: R230.2 U14.3
N26351252: Q45.C Q146.G R3197.1
N26351618: C154.2 R3201.2 R3202.1
N26351797: C581.1 R842.1
N26351954: Q45.B R305.1
N26369347: C3645.1 R3379.1
N26369876: C3638.2 R3820.2 R3821.1 U24.1
N26372282: C231.2 R93.1 U19.5
N26377234: Q130.3 R1001.1
N26380768: C330.1 R409.2
N26383954: C3913.1 D27.C R966.2 U107.5
N26385077: C1374.1 Q128.5 Q128.6 R828.1
N26385142: Q128.3 R934.1
N26394971: C412.2 D26.A Q96.2 R963.2
N26464311: R146.1 U28.AM47
N26464376: R102.1 U28.AM48
N26527034: Q19.G Q20.C R257.2
N26527036: C295.1 Q20.B R255.1 R256.1
N26527291: C248.1 R260.2 R1925.1 Y2.1
N26527487: Q68.G R1920.2
N26530187: C140.2 C141.2 TP150.1
N26544075: C3627.2 U105.12
N26544079: C3625.2 U105.10
N26588054: C310.2 R223.1
N26588611: C309.1 Q88.5 R897.2 R900.2
N26590368: C68.1 R66.1
N26592108: C3616.2 U104.10
N26592112: C3617.2 U104.12
N26594780: C3620.2 U106.10
N26594784: C3621.2 U106.12
N26604944: C166.1 R554.1
N26604971: C165.1 R549.1
N26605053: C158.1 R535.1
N26782510: C653.1 Q116.2 Q116.3 R199.1 R217.2
N27015590: D29.A R299.1
N27015623: D3.2 R301.1
N27015645: D3.1 R302.1
N27019998: TP50.1 U28.BE40
N27250731: C3604.1 R3365.2 R3367.1 R3395.2
N27251032: C3603.1 R3361.1
N27251259: R3368.2 R3385.1 R3402.2
N27441446: C1185.1 R1065.2
N27441743: C1179.1 R1054.2
N27442312: C274.1 R242.2
N27442322: C1180.1 R1064.2
N27450736: Q129.S R128.2 R2751.1 R2773.2
N27450822: C559.1 R812.1
N27450930: Q137.D R1934.1
N27451075: C540.1 R552.1
N27451111: C665.1 R838.1
N27451164: R1125.2 R1126.1
N27451174: Q129.D R1126.2
N27451176: R124.2 R128.1
N27451317: C1371.1 Q136.D Q137.G R1795.1
N27502534: C875.2 R2733.1 R2735.1
N27502635: Q59.D R2693.2
N27513223: C876.2 R2734.1 R2736.1
N27520900: C878.2 R2739.1 R2740.1
N27541184: TP4.1 U1.10
N27541202: TP5.1 U1.13
N27541212: TP6.1 U1.16
N27541791: Q63.G R158.1
N27543467: C435.2 Q53.B R259.1 R307.2
N27580537: C801.1 C802.2 R973.1
N27581046: C804.1 C805.2 R981.1
N27581205: C806.1 C807.2 R982.1
N27581374: C808.1 C809.2 R983.1
N27587554: C1317.1 U10.21
N27588103: C1219.1 R581.2
N27591037: C1314.1 U4.21
N27591192: C1216.1 R579.2
N27607596: C1217.1 R580.2
N27607656: C1316.1 U6.21
N27607947: C1323.1 U11.21
N27608201: C1220.1 R582.2
N27609663: C1221.1 R583.2
N27609681: C1324.1 U13.21
N27618113: R248.2 U16.1
N27618129: R214.2 U16.3
N27698754: C2552.1 R955.1
N27698937: C2549.2 C2552.2 R957.2 R992.1
N27699396: C2553.1 R994.1
N27699400: C2550.1 C2553.2 R952.2 R996.1 R1002.2
N27823376: D30.A R557.2
N27824089: C529.1 LT2.1 LT2.4 LT2.7 LT2.10
N27824103: C629.1 R624.2 R625.2 R626.2 R627.2
N27824173: LT2.24 R624.1
N27824188: LT2.21 R627.1
N27824214: LT2.18 R626.1
N27824236: LT2.15 R625.1
N27866744: CN12.24 CN12.25 R3721.1
N27867045: CN12.6 R3627.1 R3628.1
N27867078: CN12.16 R3710.1
N27867098: CN12.15 R3711.1
N27873712: CNKB1.34 R139.2
N27873763: CNKB1.32 R122.2
N27873827: CNKB1.35 R153.2
N27875269: C198.1 Q55.D R16.1 R687.2 SW5.1
N27875273: Q55.G Q183.D R3654.2
N27876704: Q48.D Q50.G R222.1
N27876766: C13.1 R31.1 S4.1 SW6.1 SW6.2
N27877142: C4114.1 Q190.G R3723.2
N27877177: Q49.D Q54.G R3724.2
N27877224: C738.1 LED2.A R653.2
N27877504: C445.1 Q182.B R3625.2
N27877536: LED4.A R586.2
N27877746: C15.1 LED1.3 R5.1
N27877768: LED1.2 R13.2
N27877784: C4.1 LED1.1 R15.1
N27877788: LED1.4 R10.2
N27961480: R993.1 R997.1 R999.1 U721.11
N27962552: C544.2 C2551.1 R988.2 R993.2
N27962987: C2554.2 R997.2
N27963579: C2554.1 C2555.1 R959.1 R999.2
N28420063: CN17.9 R3521.1 R3716.2
N28420086: CN17.6 R1000.1
N28420111: CN17.7 R940.1
N28421453: C492.1 CN18.1 L51.1 R884.1
N28421455: C493.1 CN18.2 L51.4 R885.1
N28421527: CN18.5 L48.4 R883.1
N28421551: CN18.4 L48.1 R882.1
N28421578: C294.1 CN18.6 R235.2
N28458362: Q160.G Q161.D Q162.G R3520.2
N28458364: Q160.D Q162.D R3519.2
N28458368: C3903.1 Q161.G R3518.1
N28459330: Q157.G Q158.D Q159.G R3517.2
N28459365: Q157.D Q159.D R3516.2
N28459409: C3901.1 Q158.G R3515.1
N28460272: Q69.G Q70.D Q71.G R662.2
N28460315: Q69.D Q71.D R664.2
N28460401: C2746.1 Q70.G R661.1
N28460991: Q66.D R2667.1
N28460993: C2745.1 Q66.G R2665.1
N28461285: CN41.1 CN41.2 R3693.2
N28461351: Q188.D R3693.1
N28461365: C4094.1 Q188.G R3692.1
N28475358: C290.2 Q51.B R95.1 R96.2
N28637804: C299.1 Q148.G R258.2
N28935332: C241.2 U28.B40
N28935334: C242.2 U28.C40
N29198335: R69.1 R228.2 U9.3
N116328469: C168.1 U5.12
N174219019: R319.1 R337.1 U2.3
N174219031: R319.2 R348.2 U2.4
N179219122: C76.1 R45.1
N190033853: C72.1 R40.1
N190076837: CNWLAN1.16 TP184.1
N190076855: CNWLAN1.44 TP185.1
N190076857: CNWLAN1.46 TP186.1
N190076859: CNWLAN1.48 TP187.1
N192354995: Q113.3 R912.2
N192365706: D41.1 R494.1
