# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ56: length 57.2
  TOP w0.076: v1(127.55,110.9) U26.L11
  TOP w0.102: CN11.250 116.9,69.54 v1(117.41,70.06)
  L3_IN1 w0.076: v1(127.55,110.9) 127.27,110.62 126.39,110.62 126.26,110.75 124.23,110.75 123.92,111.06 123.43,111.06
  L3_IN1 w0.089: v1(117.41,70.06) 117.37,70.06 115.57,71.86 115.57,74.14 113.43,76.28 113.43,81.95 113.23,82.15 113.23,83.12 111.8,84.55 111.8,85.92 113.24,87.36 113.24,88.83 113.39,88.98 113.39,100.96 116.14,103.71 116.14,105.43 116.23,105.52 116.49,105.52 116.58,105.61 116.58,105.79 116.49,105.88 116.23,105.88 116.14,105.97 116.14,106.11 118.99,108.96 120.65,108.96 122.75,111.06 123.43,111.06
M_B_DQ57: length 58.3
  TOP w0.076: v1(128.44,110.9) U26.M11
  TOP w0.102: CN11.233 121.15,75.27 121.08,75.2 121.08,74.66 119.85,73.44 119.85,73.44 v1(119.67,73.26)
  L3_IN1 w0.076: v1(128.44,110.9) 128.98,110.36 128.98,109.39 129.26,109.11 129.26,107.99 128.71,107.44 128.71,103.63 126.46,101.37 125.96,101.37 125.62,101.71 125.62,102.21 124.87,102.96 124.84,102.96
  L3_IN1 w0.089: 124.84,102.96 119.56,102.96 116.34,99.74 116.34,95.38 117.55,94.17 117.55,88.58 117.2,88.23 117.2,85.31 117.29,85.22 117.79,85.22 117.88,85.13 117.88,84.95 117.79,84.86 117.11,84.86 117,84.76 117,83.74 116.92,83.66 116.92,82.24 117.23,81.94 117.76,81.94 117.88,81.82 117.88,81.29 119.09,80.08 119.09,78.88 120.4,77.57 120.4,73.99 v1(119.67,73.26)
M_B_DQ58: length 54.2
  TOP w0.076: U26.L7 127.72,107.98 127.58,108.08 v1(127.58,108.34)
  TOP w0.102: v1(116.65,74.3) 117.15,74.8 CN11.249
  L3_IN1 w0.076: 123.24,108.38 126.19,108.38 126.41,108.59 127.33,108.59 v1(127.58,108.34)
  L3_IN1 w0.089: 123.24,108.38 122.72,108.38 122.5,108.16 122.5,107.64 121.87,107.01 118.7,107.01 117.92,106.23 117.92,104.26 114.26,100.6 114.26,94.44 114.66,94.04 114.66,89.09 114.94,88.81 114.94,85.33 114.94,85.05 114.94,85.05 114.94,84.55 114.83,84.44 114.83,81.44 115.17,81.11 115.17,80.91 115.08,80.82 114.73,80.82 114.64,80.73 114.64,80.55 114.73,80.46 115.08,80.46 115.17,80.37 115.17,79.6 115.53,79.23 115.53,78.92 115.44,78.83 115.04,78.83 114.95,78.74 114.95,78.57 115.04,78.48 115.44,78.48 115.52,78.39 115.52,77.68 116.13,77.07 116.13,76.84 116.04,76.75 115.59,76.75 115.51,76.66 115.51,76.48 115.59,76.4 116.61,76.4 116.69,76.31 116.69,76.13 116.61,76.04 115.59,76.04 115.51,75.95 115.51,75.77 115.59,75.68 116.48,75.68 116.58,75.59 116.58,75.48 116.24,75.14 116.24,74.7 v1(116.65,74.3)
M_B_DQ59: length 54.1
  TOP w0.076: U26.M8 128.51,108.93 v1(128.51,108.93)
  TOP w0.102: CN11.232 121.39,69.78 121.08,70.09 v1(120.86,70.09)
  L3_IN1 w0.076: 124.84,105.66 126.08,105.66 127.12,106.7 127.12,106.94 127.62,107.44 128.17,107.44 128.87,108.15 128.87,108.56 v1(128.51,108.93)
  L3_IN1 w0.089: v1(120.86,70.09) 120.88,70.09 121.31,70.52 121.31,70.92 119.19,73.04 119.19,76.86 118.5,77.55 118.5,79.84 116.34,82 116.34,83.9 116.39,83.95 116.39,84.8 116.39,84.8 116.39,85.36 116.39,89.9 116.12,90.17 116.12,93.14 116.21,93.23 116.58,93.23 116.67,93.32 116.67,93.5 116.58,93.59 116.21,93.59 116.12,93.67 116.12,93.85 116.21,93.94 116.36,93.94 116.5,94.07 116.5,94.39 115.73,95.16 115.73,99.99 119.29,103.55 122.73,103.55 124.84,105.66
M_B_DQ60: length 55.7
  TOP w0.076: v1(127.55,110.25) U26.L10
  TOP w0.102: CN11.246 117.9,70.27 117.45,70.72 v1(117.38,70.72)
  L3_IN1 w0.076: v1(127.55,110.25) 126.98,109.68 126.44,109.68 126.16,109.96 123.27,109.96 123.24,109.93
  L3_IN1 w0.089: 123.24,109.93 122.81,109.93 121.55,108.67 119.11,108.67 117.33,106.89 117.33,104.49 113.68,100.84 113.68,88.86 113.53,88.71 113.53,87.24 112.09,85.8 112.09,84.67 113.52,83.24 113.52,82.27 113.72,82.07 113.72,76.4 115.86,74.26 115.86,72.24 v1(117.38,70.72)
M_B_DQ61: length 55.9
  TOP w0.076: v1(128.44,110.25) U26.M10
  TOP w0.102: CN11.237 120.15,75.03 v1(119.67,74.55)
  L3_IN1 w0.076: v1(128.44,110.25) 128.81,109.88 128.81,109.3 129.04,109.08 129.04,108.03 128.41,107.4 128.41,103.59 126.35,101.54 126.03,101.54 125.79,101.78 125.79,102.33 124.87,103.25 124.84,103.25
  L3_IN1 w0.089: v1(119.67,74.55) 120.05,74.93 120.05,77.5 118.79,78.76 118.79,79.96 116.63,82.12 116.63,83.78 116.71,83.86 116.71,89.99 116.43,90.27 116.43,91.12 116.52,91.21 117.17,91.21 117.26,91.29 117.26,91.47 117.17,91.56 116.52,91.56 116.43,91.65 116.43,91.88 116.53,91.97 117.17,91.97 117.26,92.06 117.26,92.29 117.17,92.38 116.62,92.38 116.49,92.51 116.49,92.72 117.03,93.26 117.03,94.05 116.79,94.29 116.79,94.51 116.02,95.28 116.02,99.83 119.44,103.25 124.84,103.25
M_B_DQ62: length 52.5
  TOP w0.076: v1(128.51,108.3) 128.51,108.3 128.74,108.11 U26.M7
  TOP w0.102: CN11.236 120.39,69.87 120.38,69.89 120.38,70.29 120.8,70.72 v1(120.84,70.72)
  L3_IN1 w0.076: v1(128.51,108.3) 128.51,108.28 127.83,107.6 127.55,107.6 126.96,107.01 126.96,106.77 126.14,105.95 124.84,105.95
  L3_IN1 w0.089: v1(120.84,70.72) 118.84,72.71 118.84,76.24 117.44,77.64 117.44,78.33 117.53,78.42 117.91,78.42 118.01,78.52 118.01,78.67 117.91,78.77 117.53,78.77 117.44,78.86 117.44,80.49 116.04,81.88 116.04,84.02 116.09,84.07 116.09,84.86 116.1,84.86 116.09,85.36 116.09,89.78 115.83,90.05 115.83,94.65 115.44,95.04 115.44,100.11 119.17,103.85 122.1,103.85 124.21,105.95 124.84,105.95
M_B_DQ63: length 55
  TOP w0.076: v1(127.55,108.95) 127.55,108.95 U26.L8
  TOP w0.102: CN11.245 118.15,75.37 117.55,74.78 117.55,74.49 v1(116.65,73.59)
  L3_IN1 w0.076: 123.24,109.18 127.32,109.18 v1(127.55,108.95)
  L3_IN1 w0.089: v1(116.65,73.59) 116.15,74.09 116.15,74.38 115.68,74.86 115.68,74.98 115.81,75.12 115.81,75.24 115.69,75.37 115.56,75.37 115.43,75.23 115.3,75.23 115.11,75.42 115.11,75.77 115.02,75.86 114.77,75.86 114.69,75.95 114.69,76.12 114.77,76.21 115.02,76.21 115.11,76.3 115.11,76.48 115.02,76.57 114.77,76.57 114.69,76.66 114.69,76.84 114.77,76.92 115.02,76.92 115.11,77.01 115.11,77.19 115.02,77.28 114.77,77.28 114.69,77.37 114.69,77.55 114.77,77.64 115.02,77.64 115.11,77.72 115.11,77.98 114.33,78.76 114.33,78.95 114.42,79.03 114.82,79.03 114.91,79.12 114.91,79.3 114.82,79.39 114.42,79.39 114.33,79.48 114.33,79.98 114.5,80.15 114.5,80.28 114.33,80.45 114.33,80.97 114.54,81.18 114.54,81.67 113.82,82.39 113.82,82.8 114.54,83.53 114.54,84.56 114.65,84.67 114.65,85.07 114.65,85.07 114.65,85.33 114.65,88.69 114.37,88.97 114.37,93.92 113.97,94.31 113.97,100.72 117.62,104.36 117.62,106.34 118.77,107.49 120.79,107.49 122.47,109.18 123.24,109.18
M_B_DQS0: length 54.2
  TOP w0.076: U26.BP9 v1(160.67,110.1)
  TOP w0.114: v1(177.1,73.37) 176.96,73.23 176.96,73.07 177.11,72.93 177.46,72.93 177.81,73.27 177.81,74.39 178.34,74.92 178.34,75.19 178.15,75.38 CN11.13
  L3_IN1 w0.076: v1(160.67,110.1) 160.59,110.1 160.43,109.93 160.43,109.81 160.59,109.64 161.54,109.64 162.31,110.41 163.28,110.41 164.06,109.63 164.73,109.63 165.29,109.07 166.37,109.07 167.28,108.16 167.28,107.46 168.55,106.19 168.55,102.46 172.89,98.12 172.89,95.44 174.73,93.61 174.73,92.41 176.18,90.96 176.18,87.6 176.17,87.6 176.17,86.71 176.23,86.65 176.23,76.2 176.87,75.56 176.87,74.52 176.48,74.13 176.48,72.98 176.56,72.9 176.87,72.9 177.1,73.13 v1(177.1,73.37)
M_B_DQS1: length 51.1
  TOP w0.076: U26.BJ9 v1(158.55,109.6)
  TOP w0.114: v1(171.79,71.54) 171.79,71.93 171.89,72.03 172.49,72.03 173.09,71.43 173.09,69.41 172.9,69.22 CN11.34
  L3_IN1 w0.076: v1(171.79,71.54) 171.79,71.88 171.57,72.1 171.31,72.1 171.13,72.28 171.13,73.43 171.69,73.99 171.69,77.04 171.8,77.16 171.8,80.6 170.84,81.56 170.84,88.12 168.65,90.31 168.65,97.14 164.48,101.31 164.48,101.31 163.54,102.25 163.54,102.73 162.02,104.25 162.02,106.44 160.41,108.04 159.79,108.04 159.67,107.93 159.1,107.93 158.8,108.22 158.8,109.52 158.73,109.6 v1(158.55,109.6)
M_B_DQS2: length 50.4
  TOP w0.076: U26.BF9 v1(154.96,109.6)
  TOP w0.114: v1(166.19,72.42) 166.19,72.21 166.4,71.99 166.41,71.99 166.59,71.81 166.8,71.81 167.84,72.85 167.84,75.19 167.65,75.38 CN11.55
  L3_IN1 w0.076: v1(166.19,72.42) 166.19,72.22 166.36,72.05 166.71,72.05 167.01,72.35 167.01,77.85 166.49,78.37 166.49,79.8 165.59,80.69 165.59,85.46 164.62,86.43 164.62,88.58 163.43,89.77 163.43,94.7 159.44,98.69 159.44,99.11 159.46,99.13 159.46,101.71 156.66,104.51 156.66,106.75 155.35,108.07 155.35,109.29 155.42,109.36 155.42,109.51 155.33,109.6 v1(154.96,109.6)
M_B_DQS3: length 48.5
  TOP w0.076: v1(152.21,109.6) U26.BB9
  TOP w0.114: v1(161.18,72.12) 161.18,72.5 161.3,72.62 162.09,72.62 162.59,72.12 162.59,69.41 162.4,69.22 CN11.76
  L3_IN1 w0.076: v1(152.21,109.6) 152.6,109.22 152.6,107.78 153.23,107.15 153.23,99.86 155.15,97.94 155.15,97.48 155.13,97.47 155.13,97.29 158.77,93.65 158.77,88.91 159.62,88.06 159.62,84.35 158.95,83.67 158.95,81.96 159.42,81.48 159.42,77.65 159.68,77.39 159.68,75.48 160.27,74.89 160.27,73.11 160.85,72.52 161.03,72.52 161.18,72.37 v1(161.18,72.12)
M_B_DQS4: length 47.4
  TOP w0.076: U26.AA9 v1(135.76,109.6)
  TOP w0.114: CN11.179 134.65,75.65 134.74,75.56 134.74,75.5 134.74,75.5 134.74,75.3 132.63,73.19 132.63,73.08 v1(132.27,72.72)
  L3_IN1 w0.076: v1(132.27,72.72) 132.58,72.72 132.65,72.8 132.65,73.38 133.18,73.91 133.18,75.52 132.77,75.92 132.77,76.34 133.33,76.9 133.33,77 132.46,77.87 132.46,79.93 129.93,82.46 129.93,88.47 131.54,90.07 131.54,95.08 133.68,97.22 133.68,98.46 133.7,98.48 133.7,98.95 135.88,101.13 135.88,107.81 136.14,108.07 136.14,109.53 136.06,109.6 v1(135.76,109.6)
M_B_DQS5: length 49.1
  TOP w0.076: v1(133.01,109.6) 133.03,109.6 133.47,109.29 U26.V9
  TOP w0.114: v1(129.2,70.73) 129.08,70.84 129.08,71.02 129.22,71.16 129.66,71.16 129.77,71.04 129.77,69.6 129.4,69.22 CN11.200
  L3_IN1 w0.076: v1(133.01,109.6) 133.39,109.22 133.39,102.28 128.91,97.8 128.47,97.8 128.31,97.64 128.31,97.51 128.28,97.48 128.28,96.9 126.55,95.16 126.55,89.92 125.29,88.65 125.29,82.27 125.76,81.79 125.76,81.03 127,79.79 127,76.48 128.06,75.43 128.06,73.49 128.55,73.01 128.55,71.36 128.84,71.07 129.12,71.07 129.2,70.99 v1(129.2,70.73)
M_B_DQS6: length 57
  TOP w0.076: U26.P9 v1(130.27,109.6)
  TOP w0.114: v1(123.1,73.8) 123.1,73.38 123.19,73.29 123.78,73.29 124.34,73.85 124.34,75.19 124.15,75.38 CN11.221
  L3_IN1 w0.076: v1(123.1,73.8) 123.1,73.49 123.28,73.32 123.38,73.32 123.61,73.54 123.61,74.48 123.53,74.56 123.53,76.73 122.6,77.65 122.6,78.42 121.53,79.5 121.53,80.29 119.74,82.08 119.74,88.07 120.3,88.63 120.3,91.78 120.48,91.96 120.75,91.96 120.84,92.05 120.84,92.18 120.75,92.27 120.48,92.27 120.3,92.45 120.3,92.75 120.48,92.93 120.73,92.93 120.81,93 120.81,93.16 120.73,93.23 120.48,93.23 120.3,93.41 120.3,94.05 118.29,96.06 118.29,99.05 120.26,101.02 125.05,101.02 125.57,100.5 127.04,100.5 127.23,100.68 128.08,100.68 130.65,103.25 130.65,109.53 130.57,109.6 v1(130.27,109.6)
M_B_DQS7: length 54.9
  TOP w0.076: v1(127.55,109.6) U26.L9
  TOP w0.114: v1(118.02,71.23) 118.02,71.5 118.1,71.57 118.11,71.57 118.11,71.58 118.22,71.58 118.41,71.76 118.56,71.76 119.09,71.23 119.09,69.41 118.9,69.22 CN11.242
  L3_IN1 w0.076: v1(118.02,71.23) 117.67,71.58 117.38,71.58 117.2,71.76 117.2,76.7 116.02,77.87 116.02,80.95 115.32,81.65 115.32,84.24 115.43,84.35 115.43,84.98 115.43,84.98 115.43,85.33 115.43,89.02 115.15,89.29 115.15,94.24 114.75,94.64 114.75,100.39 118.96,104.6 119.88,104.6 120.16,104.88 120.16,106.21 120.47,106.52 123.34,106.52 123.58,106.76 124.95,106.76 125.87,107.67 126.88,107.67 127.16,107.95 127.73,107.95 127.96,108.18 127.96,109.2 v1(127.55,109.6)
M_B_DQS#0: length 54.3
  TOP w0.076: U26.BN9 v1(160.02,110.11)
  TOP w0.114: CN11.11 178.65,74.79 178.12,74.26 178.12,73.15 177.59,72.62 177.22,72.62 v1(177.02,72.42)
  L3_IN1 w0.076: v1(177.02,72.42) 176.72,72.73 176.48,72.73 176.3,72.91 176.3,74.21 176.69,74.6 176.69,75.49 176.05,76.12 176.05,86.58 175.99,86.64 175.99,87.67 176,87.68 176,90.89 174.55,92.34 174.55,93.54 172.71,95.37 172.71,98.05 168.37,102.39 168.37,106.12 167.11,107.39 167.11,108.09 166.8,108.39 166.8,108.42 166.31,108.92 165.23,108.92 164.67,109.48 163.99,109.48 163.21,110.26 162.37,110.26 161.6,109.49 160.53,109.49 160.27,109.74 160.27,109.94 160.11,110.11 v1(160.02,110.11)
M_B_DQS#1: length 51.1
  TOP w0.076: U26.BL9 v1(158.63,110.15)
  TOP w0.114: CN11.32 173.4,71.55 172.61,72.34 172,72.34 v1(171.82,72.52)
  L3_IN1 w0.076: v1(171.82,72.52) 171.57,72.28 171.39,72.28 171.31,72.35 171.31,73.36 171.86,73.91 171.86,76.97 171.97,77.08 171.97,80.68 171.02,81.64 171.02,88.19 168.83,90.38 168.83,97.21 164.69,101.35 164.66,101.35 163.69,102.32 163.69,102.79 162.17,104.31 162.17,106.5 160.48,108.2 159.73,108.2 159.61,108.08 159.16,108.08 158.95,108.28 158.95,109.83 v1(158.63,110.15)
M_B_DQS#2: length 50.4
  TOP w0.076: v1(155.87,109.6) U26.BG9
  TOP w0.114: CN11.53 168.15,72.73 166.92,71.51 v1(166.2,71.51)
  L3_IN1 w0.076: v1(155.87,109.6) 155.5,109.23 155.5,108.13 156.82,106.81 156.82,104.57 159.61,101.78 159.61,99.13 159.62,99.11 159.62,98.77 163.61,94.78 163.61,89.84 164.8,88.66 164.8,86.51 165.77,85.53 165.77,80.76 166.66,79.87 166.66,78.45 167.19,77.92 167.19,72.28 166.79,71.87 166.36,71.87 166.2,71.72 v1(166.2,71.51)
M_B_DQS#3: length 48.5
  TOP w0.076: v1(153.13,109.6) U26.BC9
  TOP w0.114: CN11.74 162.9,72.25 162.22,72.93 161.38,72.93 v1(161.2,73.11)
  L3_IN1 w0.076: v1(153.13,109.6) 152.77,109.6 152.67,109.51 152.67,109.36 152.75,109.28 152.75,107.84 153.38,107.21 153.38,99.92 155.3,98.01 155.3,97.51 155.31,97.49 155.31,97.36 158.95,93.73 158.95,88.98 159.8,88.13 159.8,84.27 159.12,83.6 159.12,82.03 159.6,81.55 159.6,77.72 159.86,77.47 159.86,75.55 160.44,74.97 160.44,73.18 160.92,72.7 161.03,72.7 161.2,72.87 v1(161.2,73.11)
M_B_DQS#4: length 47.5
  TOP w0.076: v1(136.67,109.6) 136.85,109.47 U26.AC9
  TOP w0.114: v1(133.21,72.72) 133.11,72.72 132.94,72.9 132.94,73.06 135.05,75.18 135.05,75.49 135.15,75.59 CN11.177
  L3_IN1 w0.076: v1(133.21,72.72) 132.91,72.72 132.83,72.8 132.83,73.31 133.36,73.83 133.36,75.59 132.95,75.99 132.95,76.27 133.51,76.82 133.51,77.08 132.64,77.94 132.64,80.01 130.11,82.54 130.11,88.39 131.72,90 131.72,95 133.86,97.15 133.86,98.46 133.85,98.46 133.85,98.89 136.03,101.06 136.03,107.75 136.29,108.01 136.29,109.53 136.37,109.6 v1(136.67,109.6)
M_B_DQS#5: length 49.2
  TOP w0.076: v1(133.93,109.6) U26.W9
  TOP w0.114: CN11.198 129.9,69.29 130.08,69.47 130.08,71.17 129.78,71.46 129.34,71.46 v1(129.16,71.64)
  L3_IN1 w0.076: v1(133.93,109.6) 133.47,109.6 133.42,109.55 133.42,109.41 133.55,109.28 133.55,102.22 128.98,97.65 128.54,97.65 128.46,97.57 128.46,96.82 126.73,95.09 126.73,89.84 125.46,88.58 125.46,82.34 125.94,81.86 125.94,81.11 127.18,79.87 127.18,76.56 128.24,75.5 128.24,73.57 128.73,73.08 128.73,71.44 128.89,71.27 129,71.27 129.16,71.43 v1(129.16,71.64)
M_B_DQS#6: length 57
  TOP w0.076: v1(131.18,109.6) U26.R9
  TOP w0.114: v1(123.12,72.8) 123.31,72.99 123.91,72.99 124.65,73.72 CN11.219
  L3_IN1 w0.076: v1(123.12,72.8) 123.12,72.99 123.28,73.14 123.46,73.14 123.79,73.47 123.79,74.55 123.7,74.64 123.7,76.8 122.78,77.73 122.78,78.5 121.7,79.57 121.7,80.36 119.91,82.15 119.91,87.99 120.48,88.56 120.48,91.71 120.56,91.78 120.82,91.78 121.01,91.98 121.01,92.25 120.82,92.45 120.56,92.45 120.48,92.52 120.48,92.67 120.56,92.75 120.8,92.75 120.98,92.93 120.98,93.23 120.8,93.41 120.56,93.41 120.48,93.49 120.48,94.12 118.47,96.13 118.47,98.98 120.33,100.84 124.84,100.84 124.86,100.87 124.99,100.87 125.51,100.34 127.1,100.34 127.29,100.53 128.15,100.53 130.8,103.19 130.8,109.34 131.06,109.6 v1(131.18,109.6)
M_B_DQS#7: length 55
  TOP w0.076: v1(128.43,109.6) U26.M9
  TOP w0.114: v1(118.02,72.06) 118.69,72.06 119.39,71.36 CN11.240
  L3_IN1 w0.076: v1(118.02,72.06) 117.72,71.76 117.63,71.76 117.45,71.76 117.37,71.83 117.37,76.77 116.2,77.95 116.2,81.02 115.5,81.72 115.5,84.17 115.61,84.27 115.61,84.95 115.61,84.95 115.61,85.33 115.61,89.09 115.33,89.37 115.33,94.32 114.93,94.71 114.93,100.32 119.04,104.42 119.95,104.42 120.33,104.81 120.33,106.13 120.54,106.34 123.38,106.34 123.64,106.61 125.02,106.61 125.93,107.52 126.94,107.52 127.22,107.8 127.79,107.8 128.11,108.12 128.11,109.26 128,109.37 128,109.56 128.14,109.69 128.34,109.69 v1(128.43,109.6)
M_B_EVENT#: length 2.1
  TOP w0.102: v1(147.78,69.5) 147.9,69.38 CN11.134
  BOTTOM w0.102: v1(147.78,69.5) 148.03,69.24 R207.1
M_VREF_CA_DIMM0: length 7.4
  TOP w0.305: CN1.164 138.39,82.09 138.09,82.4 v1(137.45,82.4)
  BOTTOM w0.508: R39.1 C73.2 136.74,81.69 v1(137.45,82.4) ; R39.1 135.2,82.7 v3(135.22,82.71) ; R39.1 R38.2 R37.1
MA_CKE0: length 30.4
  TOP w0.076: U26.AT1 148.16,103.96 148.16,100.99 148.8,100.34
  TOP w0.165: v1(155.61,86.29) 155.94,86.29 156.12,86.11 156.12,85.19 156.25,85.07 156.63,85.07 156.79,85.23 156.79,86.87 156.55,87.11 154.98,87.11 154.14,87.94 CN1.109 ; v1(149.9,100.06) 149.08,100.06 148.8,100.34
  L8_IN3 w0.076: 152.43,97.48 152.43,97.99 150.36,100.06 v1(149.9,100.06)
  L8_IN3 w0.135: 152.43,97.48 152.43,96.31 156.07,92.67 156.07,86.75 v1(155.61,86.29)
MA_CKE1: length 29.2
  TOP w0.076: 148.36,100.12 148.33,100.15 148.33,100.15 147.82,100.67 147.82,104.27 U26.AT2
  TOP w0.165: 148.36,100.12 148.89,99.59 148.89,99.59 148.94,99.54 150.17,99.54 v1(150.23,99.6) ; v1(155.53,84.26) 155.05,84.26 153.9,83.1 CN1.110
  L8_IN3 w0.135: v1(155.53,84.26) 155.42,84.37 155.35,84.37 155.06,84.66 155.06,86.44 155.45,86.84 155.45,92.67 151.99,96.13 151.99,97.84 v1(150.23,99.6)
MA_CLK0: length 36
  TOP w0.076: U26.AG1 140.84,104.19 140.84,104.39 140.8,104.43 140.44,104.43 140.33,104.32 140.33,104.03 140.93,103.43 140.93,100.48 141.03,100.38 141.13,100.38 141.14,100.37
  TOP w0.114: CN1.137 147.14,87.94 146.98,87.78 146.98,86.13 146.69,85.84 146.19,85.84 v1(146.01,85.65) ; v1(144.87,100.32) 144.72,100.17 144.69,100.17 144.51,99.99 143.89,99.99 143.64,99.74 141.77,99.74 141.14,100.37
  L8_IN3 w0.076: v1(146.01,85.65) 145.73,85.93 145.67,85.93 145.42,85.68 145.13,85.68 144.95,85.87 144.95,86.44 145.21,86.7 145.21,86.86 145.13,86.93 144.77,86.93 144.4,87.3 144.4,87.56 144.99,88.15 145.24,88.15 145.71,87.69 145.9,87.69 145.98,87.77 145.98,88.71 145.9,88.79 145.48,88.79 145.3,88.97 145.3,89.35 145.48,89.53 145.86,89.53 145.93,89.6 145.93,89.83 145.86,89.91 145.36,89.91 145.14,90.13 145.14,90.55 145.32,90.73 145.74,90.73 145.81,90.81 145.81,91.44 145.63,91.63 145.63,91.96 145.81,92.14 145.81,92.59 145.68,92.72 145.14,92.72 144.96,92.9 144.96,93.15 145.14,93.33 145.14,93.44 144.96,93.62 144.96,97.46 144.95,97.46 144.95,97.56 144.97,97.58 144.97,98.04 144.3,98.72 144.3,99.93 144.47,100.1 144.66,100.1 v1(144.87,100.32)
MA_CLK1: length 33.4
  TOP w0.076: v1(144.84,102.96) 144.62,102.74 144.5,102.74 143.68,103.56 143.68,104.27 143.5,104.45 143.33,104.45 143.23,104.55 U26.AK2
  TOP w0.114: v1(146.06,83.58) 146.13,83.65 146.13,83.88 146.02,83.99 145.28,83.99 145.15,83.86 145.15,83.11 145.81,82.45 146.38,82.45 146.9,81.94 CN1.138
  L8_IN3 w0.076: v1(146.06,83.58) 145.77,83.87 145.29,83.87 145.1,84.06 145.1,84.32 145.47,84.69 145.47,84.79 145.3,84.96 145.2,84.96 144.76,84.52 144.51,84.52 144.29,84.74 144.29,86.31 144.18,86.43 144.03,86.43 143.82,86.63 143.82,86.95 143.29,87.47 143.29,87.8 143.47,87.98 143.89,87.98 144.63,88.73 144.63,88.97 144.56,89.04 144.56,89.45 144.63,89.52 144.63,89.7 144.1,90.22 144.1,90.48 144.52,90.9 144.52,91 144.26,91.26 144.26,91.66 144.46,91.86 144.66,91.86 144.74,91.94 144.74,92.17 144.66,92.25 144.36,92.25 144.06,92.54 144.06,92.95 144.28,93.17 144.28,97.47 144.31,97.49 144.31,97.5 144.28,97.52 144.28,97.58 144.28,98.02 143.96,98.34 143.96,102.31 144.45,102.81 144.7,102.81 v1(144.84,102.96)
MA_CLK#0: length 36
  TOP w0.076: U26.AG2 140.6,104.6 140.37,104.6 140.16,104.39 140.16,103.96 140.77,103.36 140.77,100.41 140.91,100.26 140.91,100.17 140.93,100.15
  TOP w0.114: CN1.139 146.65,88.49 146.84,88.3 146.84,88.07 146.67,87.9 146.67,86.26 146.56,86.14 146.1,86.14 145.97,86.14 145.88,86.23 v1(145.88,86.49) ; 140.93,100.15 141.65,99.43 143.77,99.43 144.01,99.68 v1(144.9,99.68)
  L8_IN3 w0.076: v1(145.88,86.49) 146,86.49 146.08,86.41 146.08,86.29 145.9,86.11 145.59,86.11 145.34,85.86 145.21,85.86 145.13,85.94 145.13,86.37 145.38,86.63 145.38,86.93 145.2,87.11 144.84,87.11 144.58,87.38 144.58,87.49 145.06,87.97 145.17,87.97 145.63,87.51 145.97,87.51 146.15,87.69 146.15,88.79 145.97,88.97 145.55,88.97 145.48,89.04 145.48,89.27 145.55,89.35 145.93,89.35 146.11,89.53 146.11,89.9 145.93,90.08 145.44,90.08 145.32,90.2 145.32,90.48 145.39,90.56 145.81,90.56 145.99,90.74 145.99,91.52 145.81,91.7 145.81,91.89 145.99,92.07 145.99,92.66 145.75,92.9 145.21,92.9 145.13,92.98 145.13,93.08 145.32,93.26 145.32,93.51 145.13,93.69 145.13,97.48 145.13,97.49 145.13,97.56 145.12,97.57 145.12,97.64 145.12,98.11 144.45,98.78 144.45,99.87 144.54,99.95 144.82,99.95 144.9,99.87 v1(144.9,99.68)
MA_CLK#1: length 33.4
  TOP w0.076: v1(144.87,102.32) 144.62,102.57 144.44,102.57 143.52,103.49 143.52,104.2 143.43,104.29 143.3,104.29 143.23,104.21 U26.AK1
  TOP w0.114: CN1.140 146.39,82 146.25,82.15 145.68,82.15 144.85,82.98 144.85,83.99 145.16,84.3 145.82,84.3 v1(146.01,84.48)
  L8_IN3 w0.076: v1(146.01,84.48) 146.14,84.36 146.14,84.15 146.04,84.05 145.37,84.05 145.28,84.14 145.28,84.24 145.64,84.61 145.64,84.87 145.38,85.13 145.12,85.13 144.69,84.7 144.58,84.7 144.47,84.81 144.47,86.39 144.25,86.6 144.1,86.6 144,86.71 144,87.02 143.47,87.55 143.47,87.73 143.55,87.81 143.96,87.81 144.81,88.65 144.81,89.05 144.74,89.12 144.74,89.37 144.81,89.44 144.81,89.77 144.28,90.3 144.28,90.41 144.7,90.82 144.7,91.08 144.44,91.34 144.44,91.59 144.53,91.69 144.74,91.69 144.92,91.87 144.92,92.24 144.74,92.42 144.43,92.42 144.24,92.62 144.24,92.88 144.46,93.09 144.46,97.39 144.46,97.56 144.43,97.58 144.43,97.64 144.43,98.08 144.11,98.4 144.11,102.25 144.52,102.66 144.63,102.66 144.87,102.42 v1(144.87,102.32)
MA_CS#0: length 32.5
  TOP w0.076: v1(140.3,100.53) 140.26,100.53 138.49,102.3 138.49,105.15 138.57,105.23 138.57,106.29 U26.AD5
  TOP w0.165: v1(139.85,84.41) 140.18,84.74 140.18,85.28 142.11,87.22 142.11,87.23 142.15,87.26 CN1.149
  L8_IN3 w0.135: v1(140.3,100.53) 140.27,100.53 139.68,99.94 139.68,97.9 139.81,97.77 139.81,97.01 136.39,93.59 136.39,90.54 138.74,88.18 138.74,85.12 139.45,84.41 v1(139.85,84.41)
MA_CS#1: length 32.4
  TOP w0.076: U26.AE2 139.26,104.39 139.26,103.25 140.11,102.4 v1(140.25,102.4)
  TOP w0.165: CN1.157 140.15,88.32 139.57,87.75 139.56,87.75 138.09,86.28 138.09,86.02 137.59,85.53 v1(137.34,85.53)
  L8_IN3 w0.135: v1(137.34,85.53) 137.43,85.43 137.66,85.43 137.86,85.63 137.86,86.85 137.72,86.99 137.39,86.99 137.22,87.16 137.22,87.39 137.35,87.53 137.72,87.53 137.85,87.66 137.85,87.83 137.28,88.4 137.08,88.4 136.75,88.74 136.75,88.93 136.48,89.2 136.28,89.2 136.04,89.44 136.04,89.64 135.87,89.81 135.67,89.81 135.37,90.11 135.37,90.74 135.51,90.88 135.51,93.96 138.9,97.35 138.9,100.84 139.04,100.98 139.44,100.98 139.58,101.11 139.58,101.38 139.44,101.51 139.04,101.51 138.9,101.65 138.9,102.51 139.05,102.65 139.39,102.65 139.53,102.52 139.53,102.17 139.66,102.03 139.88,102.03 v1(140.25,102.4)
MA_ODT0: length 33.3
  TOP w0.165: CN1.155 140.64,88.38 140.98,88.04 140.98,87.51 140.52,87.05 139.53,87.05 138.56,86.08 138.56,85.83 138.56,85.82 138.56,85.11 138.82,84.84 139.09,84.84 139.22,84.97 139.22,85.84 139.67,86.29 v1(139.79,86.29) ; v1(140.3,99.38) 140.2,99.27 138.11,99.27 137.81,99.58 137.81,100.15 137.97,100.31 138.41,100.31 138.57,100.48 138.57,100.81 138.41,100.97 137.97,100.97 137.81,101.14 137.81,104.99 138.18,105.37 U26.AD3
  L8_IN3 w0.135: v1(139.79,86.29) 139.79,88.38 137.95,90.22 137.95,93.91 140.69,96.65 140.69,97.77 140.3,98.16 v1(140.3,99.38)
MA_ODT1: length 30.9
  TOP w0.076: U26.AE4 138.97,106.02 139.42,105.56 139.42,103.41 139.88,102.96 v1(140.2,102.96)
  TOP w0.165: CN1.161 139.15,88.03 137.35,86.24 v1(137.35,86.17)
  L8_IN3 w0.135: v1(140.2,102.96) 139.64,102.96 139.5,103.09 139.5,103.87 139.26,104.11 138.74,104.11 138.46,103.83 138.46,97.53 134.93,94 134.93,93.78 135.07,93.64 135.07,93.22 134.93,93.08 134.93,92.7 135.07,92.56 135.07,92.14 134.93,92 134.93,91.63 135.07,91.49 135.07,91.06 134.93,90.92 134.93,89.93 136.54,88.32 136.54,87.21 137.35,86.39 v1(137.35,86.17)
MB_CKE0: length 49.9
  TOP w0.076: v1(147.64,108.3) U26.AT8
  TOP w0.165: CN11.109 154.14,75.4 v1(154.94,74.6)
  L3_IN1 w0.135: v1(154.94,74.6) 154.94,75.58 155.07,75.72 155.7,75.72 155.83,75.85 155.83,76.12 155.7,76.25 155.4,76.25 155.26,76.39 155.26,76.66 155.4,76.79 155.7,76.79 155.83,76.93 155.83,77.2 155.7,77.33 155.4,77.33 155.26,77.47 155.26,79.59 155.4,79.72 155.7,79.72 155.83,79.85 155.83,80.12 155.7,80.26 155.4,80.26 155.26,80.39 155.26,80.57 155.01,80.83 155.01,81.23 155.14,81.36 155.51,81.36 155.65,81.5 155.65,81.77 155.51,81.9 155.14,81.9 155.01,82.03 155.01,87.43 155.14,87.56 155.28,87.56 155.41,87.69 155.41,87.96 155.28,88.1 155.14,88.1 155.01,88.23 155.01,88.5 155.14,88.64 155.28,88.64 155.41,88.77 155.41,89.04 155.28,89.18 155.14,89.18 155.01,89.31 155.01,89.58 155.14,89.71 155.28,89.71 155.41,89.85 155.41,90.12 155.28,90.25 155.14,90.25 155.01,90.39 155.01,90.66 155.14,90.79 155.28,90.79 155.41,90.93 155.41,91.19 155.28,91.33 155.14,91.33 155.01,91.46 155.01,91.73 155.14,91.87 155.28,91.87 155.41,92 155.41,92.27 155.28,92.41 155.14,92.41 155.01,92.54 155.01,92.71 154.76,92.95 154.76,93.14 155,93.38 155,93.57 154.81,93.76 154.62,93.76 154.38,93.52 154.19,93.52 154,93.71 154,93.9 154.3,94.2 154.3,94.34 154.06,94.58 153.92,94.58 153.62,94.28 153.43,94.28 153.24,94.47 153.24,94.66 153.48,94.9 153.48,95.09 153.29,95.28 153.1,95.28 152.86,95.05 152.67,95.05 152.48,95.24 152.48,95.43 152.78,95.72 152.78,95.86 152.53,96.11 152.4,96.11 152.1,95.81 151.91,95.81 151.64,96.07 151.64,96.22 151.94,96.52 151.94,96.7 151.64,97 151.64,97.98 150.67,98.95 150.67,101.78 149.68,102.77 149.68,102.8 149.36,103.12 149.36,106.58 v1(147.64,108.3)
MB_CKE1: length 48.3
  TOP w0.076: U26.AT10 v1(147.64,110.24)
  TOP w0.165: CN11.110 153.9,70.15 v1(153.88,70.16)
  L3_IN1 w0.076: 151.2,97.48 151.2,98.06 148.97,100.29 148.97,106.63 148,107.61 147.82,107.61 147.27,108.15 147.27,109.87 v1(147.64,110.24)
  L3_IN1 w0.135: v1(153.88,70.16) 153.66,70.38 153.66,70.63 153.95,70.92 153.95,71.15 153.66,71.44 153.66,71.81 153.8,71.94 154.06,71.94 154.19,72.07 154.19,72.34 154.06,72.48 153.8,72.48 153.66,72.61 153.66,72.79 153.88,73.01 154.3,73.01 154.43,73.15 154.43,75.84 154.76,76.17 154.76,76.36 154.43,76.68 154.43,76.97 154.82,77.36 154.82,80.35 154.3,80.87 154.3,81.54 154.57,81.81 154.57,92.53 151.2,95.89 151.2,97.48
MB_CLK0: length 46.5
  TOP w0.076: U26.AM9 v1(144.03,109.59)
  TOP w0.114: CN11.137 147.14,74.85 145.67,73.37 145.29,73.37 v1(145.12,73.21)
  L3_IN1 w0.076: v1(145.12,73.21) 145.12,73.37 145.27,73.52 145.45,73.52 145.74,73.81 145.74,75.07 144.99,75.82 144.99,80.44 144.87,80.56 144.87,85.9 144.75,86.02 144.75,86.56 144.42,86.89 144.42,87.91 143.28,89.05 143.28,90.91 143.3,90.93 143.3,92.39 143.75,92.84 143.75,97.46 143.74,97.48 143.74,98.36 143.48,98.63 143.48,107.25 143.18,107.54 143.18,108.16 142.56,108.78 142.56,109.15 142.7,109.28 142.7,109.89 143.04,110.23 144.14,110.23 144.46,109.91 144.46,109.6 144.32,109.47 144.15,109.47 v1(144.03,109.59)
MB_CLK1: length 48.2
  TOP w0.076: U26.AM7 v1(144.06,108.28)
  TOP w0.114: v1(147.31,72.24) 147.49,72.06 147.8,72.06 148.1,71.77 148.1,70.52 146.9,69.32 CN11.138
  L3_IN1 w0.076: v1(144.06,108.28) 144.06,108.46 143.95,108.57 143.74,108.57 143.62,108.45 143.62,107.85 143.9,107.58 143.9,98.99 144.45,98.44 144.45,97.71 144.45,97.52 144.45,97.52 144.45,97.49 144.46,97.47 144.46,90.05 144.64,89.87 145.22,89.87 145.41,89.67 145.41,89.18 145.23,89 144.82,89 144.74,88.92 144.74,88.77 144.82,88.69 145.23,88.69 145.41,88.51 145.41,88.26 145.11,87.96 145.11,87.85 145.41,87.55 145.41,87.25 145.27,87.11 145.27,87 145.41,86.85 145.41,86.29 145.53,86.18 145.53,80.83 145.65,80.72 145.65,76.15 146.41,75.39 146.41,73.03 146.23,72.85 145.9,72.85 145.82,72.78 145.82,72.62 145.9,72.55 146.23,72.55 146.41,72.37 146.41,71.82 146.57,71.67 146.79,71.67 146.86,71.74 147.2,71.74 147.42,71.96 147.42,72.14 v1(147.31,72.24)
MB_CLK#0: length 46.5
  TOP w0.076: U26.AN9 v1(144.84,109.61)
  TOP w0.114: CN11.139 146.65,75.58 146.84,75.39 146.84,74.98 145.54,73.68 145.27,73.68 145.02,73.94 v1(145.02,74.2)
  L3_IN1 w0.076: v1(144.84,109.61) 144.61,109.84 144.61,109.97 144.2,110.39 142.98,110.39 142.55,109.96 142.55,109.34 142.41,109.21 142.41,108.72 143.03,108.1 143.03,107.48 143.32,107.18 143.32,98.57 143.59,98.3 143.59,97.48 143.58,97.46 143.58,92.91 143.12,92.46 143.12,91 143.11,90.98 143.11,88.97 144.24,87.84 144.24,86.82 144.57,86.49 144.57,85.95 144.69,85.83 144.69,80.49 144.81,80.37 144.81,75.75 145.57,74.99 145.57,73.88 145.38,73.7 145.27,73.7 145.02,73.95 v1(145.02,74.2)
MB_CLK#1: length 48.2
  TOP w0.076: U26.AM8 v1(144.06,108.93)
  TOP w0.114: CN11.140 146.4,69.02 146.59,69.21 146.59,69.45 147.79,70.65 147.79,71.64 147.68,71.76 147.35,71.76 147.24,71.64 147.24,71.38 v1(147.33,71.29)
  L3_IN1 w0.076: v1(144.06,108.93) 143.85,108.72 143.68,108.72 143.47,108.51 143.47,107.79 143.75,107.51 143.75,98.93 144.29,98.38 144.29,97.65 144.29,97.65 144.29,97.58 144.28,97.57 144.28,89.97 144.56,89.69 145.14,89.69 145.24,89.6 145.24,89.25 145.16,89.18 144.75,89.18 144.57,89 144.57,88.7 144.75,88.52 145.16,88.52 145.23,88.44 145.23,88.33 144.93,88.03 144.93,87.77 145.23,87.48 145.23,87.32 145.09,87.18 145.09,86.92 145.24,86.78 145.24,86.22 145.35,86.1 145.35,80.76 145.47,80.64 145.47,76.08 146.24,75.31 146.24,73.11 146.16,73.03 145.82,73.03 145.64,72.85 145.64,72.55 145.82,72.37 146.16,72.37 146.24,72.29 146.24,71.75 146.49,71.49 146.86,71.49 146.94,71.57 147.06,71.57 v1(147.33,71.29)
MB_CS#0: length 51.3
  TOP w0.076: U26.AF11 v1(139.41,110.25)
  TOP w0.165: CN11.149 142.15,75.21 142.02,75.09 142.02,74.35 140.12,72.45 v1(139.79,72.45)
  L3_IN1 w0.076: v1(139.41,110.25) 139.88,109.78 139.88,107.61 139.52,107.26 139.52,98.55 139.11,98.13 139.11,97.48
  L3_IN1 w0.135: 139.11,97.48 139.11,95.69 136.1,92.68 136.1,90.89 136.1,90.53 136.42,90.21 136.42,90.02 136.05,89.65 136.05,89.46 136.24,89.27 136.43,89.27 136.82,89.66 136.97,89.66 137.2,89.43 137.2,89.28 136.81,88.89 136.81,88.7 137,88.51 137.19,88.51 137.59,88.91 137.72,88.91 137.95,88.68 137.95,88.38 137.74,88.17 137.74,87.99 137.95,87.78 137.95,87.59 137.81,87.46 137.26,87.46 137.13,87.32 137.13,87.05 137.26,86.92 137.81,86.92 137.95,86.79 137.95,85.97 137.84,85.86 137.84,85.58 137.95,85.47 137.95,84.73 137.8,84.59 137.8,84.33 137.95,84.19 137.95,82.42 138.21,82.16 138.41,81.96 138.41,79.56 138.41,79.55 138.41,77.29 139.48,76.22 139.48,74.21 139.28,74.01 139.28,72.85 139.69,72.45 v1(139.79,72.45)
MB_CS#1: length 49.9
  TOP w0.076: U26.AE7 v1(138.55,108.27)
  TOP w0.165: CN11.157 140.15,74.53 139.84,74.22 138.82,74.22 138.69,74.1 138.69,72.34 138.57,72.22 138.19,72.22 138.06,72.34 138.06,72.93 137.93,73.05 v1(137.45,73.05)
  L3_IN1 w0.076: 137.35,97.48 137.35,98.24 138.55,99.44 v1(138.55,108.27)
  L3_IN1 w0.135: v1(137.45,73.05) 137.45,74.23 137.32,74.36 136.61,74.36 136.4,74.57 136.4,74.67 137.04,75.31 137.04,75.5 136.85,75.69 136.66,75.69 136.39,75.42 136.2,75.42 136.07,75.55 136.07,80.77 134.91,81.93 134.91,88.06 134.29,88.68 134.29,93.35 134.36,93.42 134.36,93.61 134.25,93.71 134.25,93.91 134.44,94.1 134.63,94.1 134.74,93.99 134.93,93.99 135.12,94.18 135.12,94.37 135.01,94.49 135.01,94.68 135.2,94.87 135.39,94.87 135.5,94.75 135.69,94.75 135.88,94.94 135.88,95.13 135.77,95.25 135.77,95.44 135.96,95.63 136.15,95.63 136.26,95.52 136.45,95.52 136.64,95.71 136.64,95.9 136.52,96.02 136.52,96.21 136.71,96.4 136.9,96.4 137.02,96.28 137.22,96.28 137.35,96.41 137.35,97.48
MB_ODT0: length 48.1
  TOP w0.076: U26.AF7 v1(139.51,108.3)
  TOP w0.165: CN11.155 140.65,74.35 140.05,73.75 139.34,73.75 139.18,73.59 139.18,72.15 139.46,71.86 139.71,71.86 v1(139.79,71.78)
  L3_IN1 w0.076: v1(139.51,108.3) 139.36,108.15 139.36,98.84 138.67,98.15 138.67,97.48
  L3_IN1 w0.135: v1(139.79,71.78) 139.18,71.78 138.84,72.12 138.84,74.19 139.04,74.39 139.04,76.04 137.97,77.11 137.97,79.37 137.97,79.37 137.97,81.67 137.83,81.8 137.29,81.8 136.92,82.17 136.92,82.86 137.05,83 137.37,83 137.5,83.13 137.5,83.4 137.37,83.53 137.05,83.53 136.83,83.75 136.83,86.73 136.55,87.01 136.55,88.28 135.61,89.22 135.61,92.81 138.67,95.87 138.67,97.48
MB_ODT1: length 50.3
  TOP w0.076: U26.AE8 v1(138.55,108.93)
  TOP w0.165: v1(137.41,72.31) 136.94,72.78 136.94,72.84 136.94,72.84 136.94,73.27 136.94,73.27 136.94,73.69 137.95,74.69 138.77,74.69 139.15,75.07 CN11.161
  L3_IN1 w0.076: 136.9,97.48 136.9,98.15 138.14,99.39 138.14,108.52 v1(138.55,108.93)
  L3_IN1 w0.135: 136.9,97.48 136.9,97.26 136.69,97.05 136.5,97.05 136.33,97.22 136.09,97.22 135.95,97.09 135.95,96.84 136.12,96.67 136.12,96.48 133.81,94.17 133.81,88.54 134.47,87.87 134.47,87.59 134.24,87.37 134.24,87.05 134.47,86.83 134.47,86.52 134.24,86.29 134.24,85.98 134.47,85.75 134.47,85.44 134.24,85.21 134.24,84.9 134.47,84.67 134.47,84.36 134.24,84.14 134.24,83.82 134.47,83.6 134.47,83.23 134.17,82.92 134.17,82.73 134.47,82.43 134.47,82.23 134.08,81.85 134.08,81.66 134.33,81.41 134.75,81.41 134.89,81.28 134.89,80.83 135.02,80.69 135.5,80.69 135.63,80.55 135.63,74.72 136.43,73.92 136.82,73.92 136.95,73.79 136.95,72.88 136.6,72.53 136.6,72.09 136.74,71.95 137.06,71.95 v1(137.41,72.31)
ME_KB_ID: length 43
  TOP w0.102: v1(122.88,8.94) 121.79,8.94 v4(121.72,8.87) 121,8.16 121,6.45 120.65,6.1 R157.1 R155.2 119.76,6.05 CNKB1.30
  L6_IN2 w0.089: v1(122.88,8.94) 122.88,8.72 123.71,7.89 125.85,7.89 126.52,8.56 127.74,8.56 128.47,7.83 140.21,7.83 141.63,9.25 146.02,9.25 150.32,13.54 v1(150.32,14.81)
  BOTTOM w0.102: U5.69 149.07,16.31 150.32,15.07 v1(150.32,14.81)
ME_KB_QKEY: length 4.2
  TOP w0.102: v4(123.37,6.35) 122.63,6.35 R131.2 R125.2 121.06,5.67 120.73,5.67 120.26,5.2 CNKB1.29
ME_WE: length 51.3
  TOP w0.102: v1(116.28,7.12) R296.1 115.59,7.64 Q5.G
  L6_IN2 w0.089: v1(116.28,7.12) 121.15,7.12 122.06,6.2 133.63,6.2 134.24,5.59 138.72,5.59 139.35,6.22 143.28,6.22 144.76,7.7 145.69,7.7 148.28,10.29 158.49,10.29 160.1,11.89 v1(160.98,11.89)
  BOTTOM w0.102: U5.33 161.26,12.3 160.98,12.02 v1(160.98,11.89)
ME_WE_R: length 3.6
  TOP w0.102: R296.2 113.87,7.93 Q5.D 113.69,8.97 R284.2
MIC1_JD_SENSE#: length 24.1
  TOP w0.102: AR17.2 25.27,65.31 25.65,64.93 v1(25.78,64.93)
  BOTTOM w0.102: v1(25.78,64.93) 25.6,64.75 23.29,64.75 23.04,64.49 v3(22.07,64.49) 21.64,64.06 20.43,64.06 20.17,64.32 19,64.32 14.27,59.59 13.89,59.59 13.44,59.13 13.44,58.96 13.44,55.32 12.98,54.86 CN12.12
MIC1_L: length 9.8
  TOP w0.203: AC7.1 14.96,64.1 14.96,64.21 15.52,64.77 16.2,64.77 16.66,65.23 19.19,65.23 20.61,63.81 21.94,63.81 22.32,63.44 U7.21
MIC1_R: length 8.5
  TOP w0.203: AC6.1 15.44,63.98 15.44,64.27 15.65,64.47 16.33,64.47 16.79,64.93 19.06,64.93 20.53,63.45 21.71,63.45 21.92,63.25 U7.22
MIC1_VREF_L: length 4
  TOP w0.203: AR13.2 17.86,59.46 17.86,59.52 ; 17.86,59.52 v1(17.86,59.52) ; 17.86,59.52 19.13,59.52 19.18,59.57 U7.31
  BOTTOM w0.203: v1(17.86,59.52) 17.86,59.21 R3627.2
MIC1_VREF_R: length 1.7
  TOP w0.203: AR14.2 18.87,59.97 U7.30
MIC2_L: length 1.8
  TOP w0.203: U7.16 24.32,63.33 24.13,63.52 24.13,63.53 24.08,63.58 24.08,64.14 C140.1
MIC2_R: length 2
  TOP w0.203: U7.17 23.92,63.23 22.91,64.24 C141.1
MINI_CLKREQ0#: length 35.8
  TOP w0.089: v1(120.11,22.08) 120.11,22.08 U28.AN29
  TOP w0.102: CNWLAN1.53 92.95,15.89 v1(93.42,15.42)
  L6_IN2 w0.089: v1(93.42,15.42) 99.47,15.42 100.14,14.74 101.88,14.74 102.18,15.04 108,15.04 108.47,15.51 112.41,15.51 113.32,16.42 115.41,16.42 117.44,18.45 v1(118.72,18.45)
  BOTTOM w0.102: v1(120.11,22.08) 120.22,22.18 R343.2 119.4,22.84 v3(119.18,22.61) 118.64,22.08 118.64,18.53 v1(118.72,18.45)
MODE_1.2VS: length 2.3
  TOP w0.254: U25.14 186.54,107.02 187.1,106.46 R854.1
MODEM_CLKREQ: length 38.1
  TOP w0.089: v2(113.16,18.23) U28.BA17
  TOP w0.102: CNWLAN1.14 83.2,10.6 84.59,11.99 86.74,11.99 v3(86.89,12.14)
  L8_IN3 w0.089: v2(113.16,18.23) 113.16,16.47 111.05,14.35 111.05,13.87 107.24,10.06 88.49,10.06 88.08,10.47 88.08,10.95 v3(86.89,12.14)
MUTE: length 4.9
  TOP w0.102: U7.4 26.76,58.77 26.81,58.82 28.33,58.82 28.4,58.75 28.78,58.75 29.03,58.5 29.03,57.69 R123.1 R121.2
Net_1542: length 0.9
  TOP w0.1: 63.25,80.78 63.25,80.34 v6(62.94,80.03)
  vias: v3(62.97,80.17)
Net_1545: length 2
  TOP w0.165: v6(61.55,79.88) 62.2,80.53 62.2,81.13 62.55,81.48
  vias: v3(61.54,79.78)
Net_1547: length 0.4
  TOP w0.165: 61.85,82.18 v6(61.55,81.88)
  vias: v3(61.54,81.89)
Net_1554: length 3.1
  TOP w0.165: 63.95,80.78 63.85,80.68 63.85,78.97 63.45,78.57 v6(62.98,78.1)
  vias: v3(62.97,78.01)
Net_1584: length 1.6
  TOP w0.165: v6(64.56,80.9) 65.01,81.35 65.01,81.63 65.35,81.96 65.35,82.18
  vias: v3(64.54,81)
Net_1591: length 0.4
  TOP w0.165: 63.25,82.18 v6(62.95,81.88)
  vias: v3(62.94,81.87)
NVD_NVDS_ON_DELAY: length 7.9
  TOP w0.102: R1007.2 C413.2 79.39,46.58 D26.C 77.89,47.25 R963.1 76.35,47.07 D51.3 74.04,48.16 R977.1
NVDDS_PEX_VDD_EN: length 120.5
  TOP w0.102: Q96.4 76.42,52.55 76.66,52.78 v1(77.04,52.78) ; Q123.G 12.9,68.79 13.28,69.17 13.28,69.93 13.66,70.31 15.44,70.31 16.84,68.91 17.98,68.91 20.95,65.94 27.05,65.94 27.63,65.36 v1(28.14,65.36) ; R849.1 82.04,57.86 81.74,58.17 v1(81.63,58.17) ; Q128.2 92.91,64.6 92.66,64.34 v1(92.53,64.34)
  L3_IN1 w0.089: v1(81.63,58.17) 82.9,59.44 89.91,59.44 90.63,60.15 90.63,62.44 v1(92.53,64.34)
  L8_IN3 w0.089: v1(77.04,52.78) 76.02,53.8 75.67,53.8 72.34,57.12 72.34,60.64 71.58,61.41 71.58,62.57 68.99,65.15 64.48,65.15 63.88,65.76 52.64,65.76 52.03,66.37 30.36,66.37 29.11,67.62 28.11,67.62 28.09,67.64 27.51,68.22 v1(27.51,68.66)
  BOTTOM w0.102: 28.02,69.17 v1(27.51,68.66) ; 28.02,69.17 28.14,69.04 29.03,69.04 29.41,68.66 29.41,67.9 28.14,66.63 v1(28.14,65.36) ; 28.02,69.17 28.02,70.26 27.91,70.36 R964.2 ; v1(81.63,58.17) 78.74,58.17 77.04,56.47 v1(77.04,52.78)
  BOTTOM w0.203: U721.3 22.38,70.44 22.86,70.92 C818.1 23.7,71.78 R3722.1 24.23,72.32 25.96,72.32 R964.2
NVVDD: length 54.7
  TOP w0.102: v6(69.19,102.13) 68.85,101.79 G1.N31
  TOP w0.3: G1.BC49 v6(90.15,114.08)
  TOP w0.381: R926.2 v1(18.44,103.15) ; R2942.2 R2940.2 20.34,106.43 v1(20.01,106.76) ; R1929.2 21.74,103 v1(21.67,103.08)
  L3_IN1 w0.381: v1(27.1,132.01) 29.31,132.01 30.16,131.16 30.16,124.4 26.49,120.73 26.49,108.16 25.48,107.14 24.59,107.14 23.82,106.38 23.06,106.38 22.68,106.76 v1(20.01,106.76) 20.01,105.62 18.44,104.04 v1(18.44,103.15) 21.59,103.15 v1(21.67,103.08)
  BOTTOM w0.305: v6(84.65,90.18) v6(84.65,90.92)
  BOTTOM w0.381: v6(80.45,93.73) 80.54,93.82 C1330.2 80.54,95.04 v6(80.45,95.13) 80.54,95.22 C1246.2 ; v6(83.25,93.73) 83.15,93.84 83.15,95.03 v6(83.25,95.13) 83.15,95.24 83.15,96.38 v6(83.25,96.48) ; C1244.2 68.95,95.33 v6(69.15,95.13) ; C416.1 v1(54.05,71.33) ; C1274.2 84.61,90.14 v6(84.65,90.18)
  vias: v1(96.06,117.16) v1(96.09,116.41) v1(99.9,116.28) v1(101.17,128.65) v1(101.17,128.1) v1(101.17,127.54) v1(101.17,126.98) v1(101.17,126.42) v1(101.17,125.86) v1(101.17,125.3) v1(101.8,129.11) v1(102.44,129.11) v1(103.07,129.11) v5(36.13,148.3) v5(36.13,147.15) v5(36.14,146.13) v5(36.13,145.12) v5(36.13,136.23) v5(36.13,135.19) v5(36.13,134.17) v5(36.24,141.59) v5(36.24,140.45) v5(36.24,139.42) v5(37.15,148.3) v5(37.15,147.15) v5(37.16,146.13) v5(37.15,145.12) v5(37.15,136.23) v5(37.15,135.19) v5(37.15,134.17) v5(37.25,141.59) v5(37.25,140.45) v5(37.26,139.42) v5(38.17,148.3) v5(38.17,147.15) v5(38.18,146.13) v5(38.17,145.12) v5(38.17,136.23) v5(38.17,135.19) v5(38.17,134.17) v5(38.27,141.59) v5(38.27,140.45) v5(38.28,139.42) v5(39.18,148.3) v5(39.18,147.15) v5(39.19,146.13) v5(39.18,145.12) v5(39.18,136.23) v5(39.18,135.19) v5(39.18,134.17) v5(39.28,141.59) v5(39.28,140.45) v5(39.29,139.42) v5(40.2,148.3) v5(40.2,147.15) v5(40.21,146.13) v5(40.2,145.12) v5(40.2,136.23) v5(40.2,135.19) v5(40.2,134.17) v5(40.3,141.59) v5(40.3,140.45) v5(40.31,139.42) v5(55.07,73.74) v5(55.07,72.72) v5(56.08,73.74) v5(56.08,72.72) v5(59.13,73.74) v5(59.13,72.72) v5(60.15,73.74) v5(60.15,72.72) v5(63.19,73.74) v5(63.19,72.72) v5(64.21,73.74) v5(64.21,72.72) v5(67.26,73.74) v5(67.26,72.72) v5(68.27,73.74) v5(68.27,72.72) v5(96.9,117.81) v5(96.9,116.84) v5(96.9,115.88) v5(96.9,114.91) v5(97.87,117.81) v5(97.87,116.84) v5(97.87,115.88) v5(97.87,114.91) v5(100.02,122.94) v5(100.02,121.97) v5(100.02,121.01) v5(100.02,120.04) v5(100.02,119.08) v5(100.02,118.11) v5(100.05,117.17) v5(101.01,123.9) v5(101.01,122.94) v5(101.01,121.97) v5(101.01,121.01) v5(101.01,120.04) v5(101.01,119.08) v5(101.01,118.11) v5(101.01,117.17) v5(102.01,128.32) v5(102.01,127.36) v5(102.01,126.39) v5(102.01,125.43) v5(101.98,123.9) v5(101.98,122.94) v5(101.98,121.97) v5(101.98,121.01) v5(101.98,120.04) v5(101.98,119.08) v5(101.98,118.11) v5(101.98,117.17) v5(102.95,123.9) v5(102.95,122.94) v5(102.95,121.97) v5(102.95,121.01) v5(102.95,120.04) v5(102.95,119.08) v5(102.95,118.11) v5(102.95,117.17) v5(102.97,128.32) v5(102.97,127.36) v5(102.97,126.39) v5(102.97,125.43) v6(40.46,149.3) v6(70.54,103.53) v6(70.54,102.13) v6(70.55,100.78) v6(70.56,96.47) v6(71.95,107.03) v6(71.94,106.33) v6(71.94,104.93) v6(71.94,103.53) v6(71.94,102.13) v6(71.94,100.73) v6(71.95,100.03) v6(71.95,98.63) v6(71.95,97.23) v6(71.95,96.53) v6(71.95,92.33) v6(71.95,90.93) v6(71.95,90.23) v6(73.34,103.53) v6(73.34,102.13) v6(73.35,100.78) v6(73.35,96.48) v6(73.35,95.13) v6(73.35,93.73) v6(74.74,107.02) v6(74.75,106.33) v6(74.75,104.93) v6(74.74,103.53) v6(74.74,102.13) v6(74.75,100.73) v6(74.7,100.03) v6(74.7,98.63) v6(74.75,97.23) v6(74.7,96.53) v6(74.75,95.13) v6(74.75,94.43) v6(74.75,93.73) v6(74.75,92.33) v6(74.75,90.93) v6(74.75,90.23) v6(76.14,103.53) v6(76.14,102.13) v6(76.15,100.78) v6(76.15,96.48) v6(76.1,95.13) v6(76.1,94.43) v6(76.1,93.73) v6(77.52,107.03) v6(77.52,106.33) v6(77.55,100.73) v6(77.5,100.03) v6(77.5,98.63) v6(77.5,97.23) v6(77.55,96.53) v6(77.55,92.33) v6(77.54,90.92) v6(77.54,90.23) v6(79.05,107.03) v6(79.05,106.33) v6(79.05,104.93) v6(79.05,100.73) v6(79.05,100.03) v6(79.05,98.63) v6(79.05,97.23) v6(79.05,96.53) v6(80.21,148.67) v6(80.5,103.53) v6(80.47,102.83) v6(80.5,102.13) v6(81.85,107.03) v6(81.85,106.33) v6(81.85,104.93) v6(81.85,103.53) v6(81.85,102.13) v6(81.85,100.73) v6(81.85,100.03) v6(81.85,98.63) v6(81.85,97.23) v6(81.85,96.53) v6(81.85,92.33) v6(81.85,90.93) v6(81.85,90.23) v6(81.88,102.83) v6(81.85,95.13) v6(81.85,93.73) v6(83.25,103.53) v6(83.25,102.13) v6(83.25,100.78) v6(84.65,107.03) v6(84.65,106.33) v6(84.65,104.93) v6(84.65,100.73) v6(84.65,100.03) v6(84.65,98.63) v6(84.65,97.23) v6(84.65,96.53) v6(84.65,95.13) v6(84.65,93.73) v6(84.65,92.33) v6(85.35,108.43) v6(86.04,100.78) v6(86.05,96.48) v6(86.05,95.13) v6(86.05,93.73) v6(86.75,109.83) v6(86.69,108.51) v6(88.15,112.68) v6(88.19,109.78) v6(88.85,110.53) v6(88.85,108.79) v6(88.8,106.43) v6(88.98,108.16) v6(89.55,109.83) v6(90.25,111.93) v6(90.95,112.63) v6(90.95,108.48) v6(91.65,111.93) v6(92.35,112.63) v6(93.05,111.93) v6(93.75,114.03) v6(94.45,114.73) v6(95.15,114.03) v6(96.55,114.03) v7(79.62,90.94) v7(79.64,90.23)
NVVDD_ADJ: length 2.3
  TOP w0.254: U722.6 16.46,114.51 15.7,113.74 R1932.2
NVVDD_REFIN: length 4.1
  TOP w0.254: U722.7 17.73,112.98 17.42,112.68 C799.1 R975.2 R974.2
NVVDD_VIN: length 14
  TOP w0.508: R971.1 18.87,110.01 18.36,109.5 C2821.1 18.29,109.3 v1(17.75,109.3)
  L6_IN2 w0.508: v5(11.12,118.44) 14.05,115.52 14.05,113.01 v1(17.75,109.3)
  vias: v5(4.39,139.4) v5(5.41,139.4) v5(5.79,160.33) v5(5.79,159.36) v5(5.79,158.45) v5(5.79,157.53) v5(5.79,156.54) v5(5.83,119.16) v5(5.79,118.19) v5(6.04,138.38) v5(6.04,137.37) v5(6.04,136.35) v5(6.04,135.33) v5(6.04,134.19) v5(6.17,132.29) v5(9.09,158.32) v5(9.09,120.48) v5(9.09,119.46) v5(9.09,118.44) v5(10.11,160.48) v5(10.11,158.19) v5(10.11,120.48) v5(10.11,119.46) v5(10.11,118.44) v5(11.12,158.19) v5(11.12,120.48) v5(11.12,119.46) v5(13.66,158.58) v5(14.45,131.35) v5(14.68,158.58) v5(15.06,132.21) v5(15.42,131.07) v5(16.05,131.91)
NVVDD_VSNS: length 4.3
  TOP w0.254: R992.2 R994.2 R996.2 20.9,111.84 19.76,112.98 U722.11
NVVDDS: length 69.3
  TOP w0.381: R2939.2 100.61,113.41 v1(100.28,113.74)
  TOP w0.508: v1(14.68,73.36) 14.3,73.36 13.71,72.77 C801.2 R927.2 12.72,72.01 12.75,71.99 12.75,71.96 12.8,71.91 v1(12.83,71.91)
  L6_IN2 w0.381: v1(100.28,113.74) 100.28,110.82 96.6,107.14 88.59,107.14 v1(88.21,107.52)
  L6_IN2 w0.508: v1(14.68,73.36) 14.71,73.33 16.2,73.33 17.12,74.25 19.63,74.25 21.03,75.64 v1(21.16,75.64)
  BOTTOM w0.3: v6(73.35,92.33) 73.25,92.24 C1299.2 73.25,91.03 v6(73.35,90.93) 73.35,90.26 v6(73.37,90.24) ; v6(70.55,92.33) 70.61,92.27 C1292.2 70.55,91.54 v6(70.55,90.93) v6(70.55,90.23) 70.55,89.83 C1341.2 ; v6(86.02,90.23) 86.08,90.29 v6(86.08,90.93) 85.85,91.16 C1285.2 85.85,92.11 v6(86.08,92.33) ; v6(83.25,104.93) 83.18,104.99 C1289.2 83.18,106.27 v6(83.25,106.33) v6(83.25,107.03) ; v6(73.35,104.93) 73.35,105.03 73.1,105.28 73.1,106.11 v6(73.32,106.33) 73.32,107 v6(73.35,107.03) ; v6(86.05,97.23) 86.05,97.39 ; C1356.1 86.05,98.62 v6(86.05,98.63) ; v6(76.15,104.93) 76.35,105.14 C1291.2 76.35,106.13 v6(76.15,106.33) v6(76.15,107.03) 76.15,107.44 ; v6(80.45,96.58) v6(80.45,97.23) 80.45,97.31 ; v6(80.45,107.03) 80.51,107.09 C1264.2 ; v6(70.5,98.63) 70.5,99.12 ; 70.51,106.33 v6(70.52,106.33) ; v6(76.15,100.03) 76.15,99.94 76.36,99.73 ; v6(76.15,90.23) v6(76.15,90.93) 76.15,91.45 C1298.2 75.94,92.13 v6(76.15,92.33) ; 76.15,98.69 v6(76.15,98.63) ; v6(83.25,90.23) 83.28,90.26 v6(83.28,90.93) 83.31,90.97 C1342.2 83.31,92.27 v6(83.25,92.33) ; v6(70.52,104.93) 70.51,104.94 C1267.2 ; v6(78.35,104.93) 78.35,105.58 C1266.2 78.38,106.33 v6(78.4,106.34) 78.38,106.36 v6(78.38,107.04)
  BOTTOM w0.305: v6(83.25,97.23) 83.25,97.3 C1169.2 83.25,98.57 v6(83.25,98.63) ; v6(80.45,98.63) 80.45,98.57 C1288.2 80.45,97.31 ; v6(80.45,92.33) 80.54,92.43 C421.1 ; v6(80.45,107.03) v6(80.45,106.33) ; C1356.1 86.05,98 86.05,97.39 ; v6(70.55,100.03) 70.55,99.31 C1286.2 70.5,99.12 ; v6(83.25,107.03) 83.2,107.08 C1265.2 ; 76.15,98.69 76.15,98.69 C1268.2 76.36,99.73 76.36,99.73 ; C1283.2 69.93,107.65 v6(70.55,107.03) 70.55,106.36 v6(70.52,106.33) ; C1267.2 70.51,106.33 ; C1284.2 76.15,107.44
  BOTTOM w0.381: C1340.2 80.35,89.64 80.35,90.08 v6(80.46,90.19) 80.46,90.89 v6(80.5,90.93) 80.5,91.56 C1339.2 v6(80.45,92.33) ; C1355.1 88.21,106.9 v1(88.21,107.52)
  BOTTOM w0.508: R2941.2 12.83,71.22 v1(12.83,71.91)
  vias: v5(20.52,81.61) v5(20.52,80.6) v5(20.52,79.58) v5(20.52,78.57) v5(21.54,81.61) v5(21.54,80.6) v5(22.55,81.61) v5(22.55,80.6) v5(23.57,81.61) v5(23.57,80.6) v5(25.6,76.03) v5(25.6,75.01) v5(26.62,76.03) v5(26.62,75.01) v5(27.63,76.03) v5(27.63,75.01) v5(31.06,69.8) v5(31.06,68.79) v5(32.08,69.8) v5(32.08,68.79) v5(33.1,69.8) v5(33.1,68.79) v5(34.11,69.8) v5(34.11,68.79) v5(35.13,69.8) v5(35.13,68.79) v5(36.07,69.8) v5(36.07,68.79) v5(37.03,69.8) v5(37.03,68.79) v5(56.08,68.15) v5(56.08,67.14) v5(57.1,68.15) v5(57.1,67.14) v5(59.26,68.15) v5(59.26,67.14) v5(60.27,68.15) v5(60.27,67.14) v5(63.83,68.15) v5(63.83,67.14) v5(64.85,68.15) v5(64.85,67.14) v5(67.89,68.15) v5(67.89,67.14) v5(68.91,68.15) v5(68.91,67.14) v6(70.5,97.23) v6(73.35,100.03) v6(73.35,98.63) v6(73.35,97.23) v6(76.15,97.23) v6(78.25,97.23) v6(78.25,92.33) v6(78.25,90.93) v6(78.25,90.23) v6(78.35,100.03) v6(80.45,104.93) v6(80.45,100.68) v6(80.45,100.03) v6(83.25,100.03) v6(86.05,106.33) v6(86.05,100.03) v6(86.67,107.73)
NVVDDS_VIN: length 3.4
  TOP w0.254: R1093.2 5.07,58.92 5.07,58.56 4.75,58.25 3.63,58.25 3.38,58.5 R387.1
  vias: v5(1.85,62.69) v5(1.85,61.67) v5(1.85,60.66) v5(1.85,59.64) v5(3.5,62.44) v5(3.5,61.42) v5(3.76,80.34) v5(3.76,79.33) v5(4.77,80.34) v5(4.77,79.33) v5(5.28,81.33) v5(6.3,81.36)
ON1_1V8_AON: length 4
  TOP w0.203: C3912.1 74.5,58.42 74.5,59.64 74.61,59.75 U107.3
  TOP w0.254: D4.3 74.07,56.92 C3912.1
OVERT_GPU#: length 121.8
  TOP w0.1: v6(92.35,83.28) G1.BG5
  TOP w0.102: Q63.S 164.22,25.09 164.54,25.4 v1(164.54,26.37) ; R845.2 92.53,77.42 92.79,77.68 v1(92.79,78.06)
  L3_IN1 w0.089: v1(164.54,26.37) 164.16,26.75 164.16,29.04 163.94,29.26 163.94,32.53 160.11,36.35 160.11,43.11 160.1,43.13 160.1,45.06 v1(156.92,48.24)
  L8_IN3 w0.089: 94.03,72.44 93.57,72.44 93.31,72.71 93.31,74 93.1,74.21 93.1,77.11 92.79,77.42 v1(92.79,78.06) 92.28,78.57 92.28,82.02 91.9,82.4 91.9,82.81 92.35,83.26 v6(92.35,83.28) ; 95.21,72.71 96.87,71.05 96.87,65.5 95.71,64.34 95.71,63.71 96.72,62.69 96.72,61.26 96.78,61.2 v1(96.78,60.03)
  L8_IN3 w0.102: 95.21,72.71 95.07,72.85 94.44,72.85 94.03,72.44
  BOTTOM w0.102: v1(96.78,60.03) 96.85,60.03 97.24,60.42 98.23,60.42 98.49,60.16 100.92,60.16 102.45,58.63 106.78,58.63 107.6,57.81 127.75,57.81 137.29,48.28 156.86,48.28 156.89,48.24 v1(156.92,48.24)
PANEL_3.3V_ON: length 356.7
  TOP w0.089: U28.AV44 v2(126.85,18.73)
  TOP w0.102: v1(77.29,168.1) 76.28,168.1 75.26,167.08 74.62,167.08 71.96,164.42 71.96,163.53 71.58,163.15 70.69,163.15 70.05,162.51 70.05,160.07 69.67,159.69 69.67,158.83 69.26,158.42 68.73,158.42 68.32,158.83 R986.1
  L3_IN1 w0.089: v1(178.31,36.54) 178.31,36.64 181.52,39.85 182.52,39.85 183.85,38.52 189.34,38.52 189.52,38.7 189.52,38.71 189.96,39.14 189.96,43.26 186.41,46.81 186.41,57.69 193.07,64.35 193.07,75.71 193.76,76.39 193.76,92.32 194.51,93.08 194.51,101.33 195.15,101.97 195.15,137.43 194.08,138.5 194.08,161.97 188.08,167.97 172.67,167.97 170.96,169.68 162.51,169.68 156.6,175.59 144.35,175.59 142.21,173.46 122.66,173.46 121.83,174.29 115.53,174.29 114.64,173.4 112.21,173.4 111.72,172.9 106.99,172.9 105.81,174.09 104.43,174.09 103.4,173.06 103.4,168.62 101.34,166.55 94.99,166.55 94.4,165.96 77.89,165.96 77.29,166.55 v1(77.29,168.1)
  L6_IN2 w0.089: v1(178.31,36.54) 178.31,36.07 176.76,34.51 172.29,34.51 171.82,34.97 153.85,34.97 152.25,33.38 v1(152.09,33.38) 151.81,33.38 144,25.57 142.54,25.57 137.92,20.96 134.66,20.96 132.58,18.88 128.66,18.88 127.81,18.03 127.8,18.03 127.54,18.03 v2(126.85,18.73)
  BOTTOM w0.102: v1(152.09,33.38) 152.09,33.35 151.71,32.97 151.71,31.7 152.42,31 U5.106
PCH_2_CPU_TRIGGER: length 114
  TOP w0.102: v1(125.9,120.58) 125.9,120.56 U26.H23
  L8_IN3 w0.089: v1(111.3,25.15) 111.2,25.25 111.2,28.2 112.34,29.34 112.34,30.05 113.11,30.81 113.11,31.96 114.5,33.35 115.01,33.35 115.92,34.27 115.92,41.89 116.69,42.65 116.69,44.45 117.04,44.81 117.04,64.34 116.53,64.85 116.53,66.88 116.92,67.26 116.92,70.18 116.15,70.95 116.15,78.37 115.14,79.39 115.14,79.63 115.15,79.64 115.15,79.97 115.14,79.98 115.14,80.09 115.77,80.72 115.77,89.12 113.99,90.9 113.99,104.09 116.28,106.38 116.28,108.79 118.31,110.82 118.31,117.81 123.12,122.61 123.48,122.61 124.1,122 124.74,122 124.75,121.99 125.31,121.99 125.9,121.39 v1(125.9,120.58)
  BOTTOM w0.102: R383.1 110.51,22.81 110.51,24.36 v1(111.3,25.15)
