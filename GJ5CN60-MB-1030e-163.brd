# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBVDDQ_MEM_VIN:
  vias: v5(3.5,93.42) v5(3.5,92.41) v5(6.3,94.44) v5(6.3,93.42) v5(6.3,92.41)
FBVDDQ_PG_1V8AON_GC6: length 82
  TOP w0.076: U28.BE23 116.36,16.02 116.56,15.82 116.56,15.49 116.5,15.44 116.5,14.06 v1(116.14,13.69)
  TOP w0.102: v1(80.85,46.94) 80.85,49.89 R365.1 81.05,51.01 D52.3
  L3_IN1 w0.089: v1(116.14,13.69) 116.1,13.65 116.1,13.43 114.96,12.29 109.86,12.29 107.71,10.14 86.28,10.14 82.88,13.54 82.88,15.14 84.86,17.12 84.86,29.53 85.04,29.7 85.04,43.75 83.5,45.29 82.27,45.29 80.85,46.71 v1(80.85,46.94)
FBVDDQ_SENSE: length 136.3
  TOP w0.2: v1(64.71,122.89) 64.71,122.25 62.65,120.18 62.65,118.73 63.21,118.17 63.21,116.52 G1.E52
  TOP w0.254: v1(2.49,102.19) 2.87,102.57 R127.1 R812.2 2.06,103.33 2.11,103.33 2.36,103.58 2.36,104.47 1.9,104.93 C151.1
  L3_IN1 w0.203: v1(2.49,102.19) 4.39,104.09 8.63,104.09 9.65,103.08 15.82,103.08 16.51,102.39 23.8,102.39 26.77,105.36 v1(27,105.36)
  L6_IN2 w0.203: v1(64.95,127.21) 64.95,127.43 63.73,128.65 63.73,147.37 62.43,148.67 48.13,148.67 44.53,145.06 44.53,132.67 41.1,129.24 34.62,129.24 28.35,122.96 28.35,106.71 v1(27,105.36)
  BOTTOM w0.203: v1(64.95,127.21) R132.1 64.95,123.37 64.71,123.13 v1(64.71,122.89)
G_HDR1: length 4.3
  BOTTOM w0.203: 22.76,72.27 22.76,71.43 22.17,70.84 U721.2
  BOTTOM w0.508: 22.76,72.27 23.95,73.46 R918.2
G_HDR1_R: length 17.1
  TOP w0.508: v1(11.76,80.06) 11.76,81.03 R980.2 10.72,81.11 PQ44.1
  BOTTOM w0.508: v1(11.76,80.06) 13.56,80.06 17.09,76.53 22.55,76.53 23.95,75.14 R918.1
G_LDR1: length 13.6
  TOP w0.508: R2879.1 20.65,73.1 v1(20.52,73.23) ; PQ44.8 10.19,74.83 C546.1 v1(12.34,74.83)
  L3_IN1 w0.508: v1(12.34,74.83) 12.93,75.42 15.42,75.42 16.97,73.87 19.89,73.87 v1(20.52,73.23)
  BOTTOM w0.203: U721.19 20.41,72.62 20.52,72.72 v1(20.52,73.23)
G_LDR2: length 1.9
  TOP w0.381: v1(19.25,73.1) 19.38,72.98 R954.1
  BOTTOM w0.203: v1(19.25,73.1) 19.25,72.85 19.61,72.49 U721.17
G_SMBCLK0: length 92
  TOP w0.102: G1.BJ8 v6(93.65,85.29)
  L8_IN3 w0.089: v1(96.28,59.72) 96.37,59.63 96.96,59.63 97.23,59.9 97.23,61.04 97.08,61.19 97.08,62.72 96.63,63.17 96.63,64.12 97.07,64.56 97.07,70.06 97.48,70.47 97.48,73.77 98.72,75.01 99.39,75.01 99.64,75.26 99.64,75.77 99.39,76.03 98.5,76.03 97.08,77.44 97.08,79.11 96.85,79.34 96.85,81 96.13,81.72 96.13,83.98 95.78,84.33 93.93,84.33 93.65,84.6 v6(93.65,85.29)
  BOTTOM w0.102: v1(96.28,59.72) 96.37,59.81 96.37,60.68 97.15,61.47 100.87,61.47 101.57,60.76 106.09,60.76 107.99,58.85 128.32,58.85 131.97,55.2 147.8,55.2 R486.1 149.34,53.54 Q58.1
G_SMBDAT0: length 85.7
  TOP w0.102: G1.BH8 v6(93.69,86.02)
  L8_IN3 w0.089: v6(93.69,86.02) 94.16,85.55 95.71,85.55 96.34,84.92 96.34,81.78 97.04,81.08 97.04,79.44 97.28,79.2 97.28,77.62 98.68,76.23 99.47,76.23 99.87,75.83 99.87,75.2 99.42,74.76 98.75,74.76 97.69,73.69 97.69,70.39 97.27,69.97 97.27,64.44 96.83,64 96.83,63.25 97.28,62.8 97.28,62.26 98.37,61.17 98.63,61.17 v1(98.75,61.04)
  BOTTOM w0.102: v1(98.75,61.04) 98.88,61.04 99.1,61.26 100.78,61.26 101.49,60.56 106,60.56 107.93,58.63 128.26,58.63 136.69,50.19 145.49,50.19 R483.1 146.02,50.73 146.94,50.73 147.23,51.02 Q58.4
GFX_CLKREQ: length 109.6
  TOP w0.076: 120.44,16.3 120.08,15.94 120.08,15.59 120.33,15.33 v1(120.33,15.31)
  TOP w0.089: 120.44,16.3 U28.BE31
  TOP w0.102: v1(104.01,61.24) 104.04,61.27 104.04,63.05 104.9,63.91 R764.1 106.7,63.91 Q78.D
  L3_IN1 w0.089: v1(120.33,15.31) 115.66,15.31 115.19,14.84 115.19,13.52 114.56,12.89 109.61,12.89 109.48,12.75 109.47,12.75 107.72,11 v1(107.26,11)
  L6_IN2 w0.089: v1(104.01,61.24) 103.55,60.79 101.42,60.79 101.17,60.53 101.17,58.25 99.67,56.75 92.25,56.75 91.14,55.64 89.93,55.64 87.35,53.06 87.35,49.63 84.5,46.79 84.5,23.17 86.56,21.12 86.56,15.03 87.02,14.57 87.02,12.7 88.21,11.51 88.21,9.99 89.05,9.15 96.31,9.15 96.56,9.41 105.8,9.41 107.26,10.87 v1(107.26,11)
GPIO0_NVVDD_PWM_GPU: length 14.1
  TOP w0.1: G1.BD6 v6(90.25,84.58)
  TOP w0.102: v1(88.21,72.72) 88.01,72.93 R2938.1
  L8_IN3 w0.089: v6(90.25,84.58) 89.36,83.69 89.36,79.45 88.57,78.67 88.57,74.65 88.85,74.37 88.85,73.36 v1(88.21,72.72)
GPIO1_GC6FBEN: length 41.6
  TOP w0.102: v6(88.82,83.26) 88.83,83.26 G1.BB5 ; v1(91.26,60.28) 91.64,60.28 92.68,59.24 95.86,59.24 96.37,58.73 97.97,58.73 98.5,59.26 R2798.2 98.98,59.49 99.52,60.02 Q92.2
  L8_IN3 w0.089: v6(88.82,83.26) 89.15,82.93 89.15,79.63 88.31,78.79 88.31,74.15 88.59,73.87 88.59,73.57 88.26,73.23 88.09,73.23 87.83,72.98 87.83,72.22 89.9,70.15 93.99,70.15 95.45,68.69 95.45,66.21 94.98,65.74 94.98,65.74 92.99,63.75 92.99,61.77 92.15,60.93 91.91,60.93 v1(91.26,60.28)
GPIO2_GPUEVENT*: length 9.3
  TOP w0.102: D23.A R2809.2 90.5,74.36 90.91,74.77 90.91,77.1 91.97,78.17 91.97,79.34 90.55,80.77 G1.BD1
GPIO4_1V8MAIN_ON: length 32.6
  TOP w0.102: Q104.3 94.55,60.64 94.18,60.28 R834.2 93.5,60.46 93.27,60.68 90.27,60.68 90.12,60.53 v1(89.74,60.53) ; v1(80.21,59.64) 79.96,59.39 Q130.2 79.96,58.25 79.58,57.86 78.69,57.86 78.31,57.48 78.31,55.2 77.98,54.87 R966.1 76.83,54.87 76.4,54.43 D27.A 76.8,53.8 77.55,53.8 77.67,53.93 78.82,53.93 78.94,53.8 78.94,52.15 78.69,51.9 78.69,50.45 78.89,50.24 78.97,50.24 79.83,49.39 R1007.1
  L3_IN1 w0.089: v1(80.21,59.64) 80.67,59.19 81.79,59.19 82.24,59.64 89.31,59.64 89.74,60.07 v1(89.74,60.53)
GPIO4_1V8MAINEN: length 25.5
  TOP w0.102: v1(92.28,73.49) 92.28,73.54 R2808.2 92.1,74.58 92.1,77.41 92.4,77.71 92.4,79.67 91.3,80.78 G1.BE1 ; Q104.2 94.16,61.29 94.06,61.39 v1(94.06,61.65)
  L8_IN3 w0.089: v1(92.28,73.49) 92.28,72.22 93.52,70.98 95.76,70.98 96.26,70.48 96.26,66.13 93.65,63.52 93.65,62.06 v1(94.06,61.65)
GPIO5_FRM_LOCK: length 6.5
  TOP w0.102: R2814.2 96.34,78.15 95.32,79.17 94.31,79.17 92.99,80.5 92.99,81.03 92.65,81.37 G1.BG2
GPIO6_NVVDD_PSI*: length 180.5
  TOP w0.102: G1.BD2 90.55,81.28 90.22,80.96 90.22,79.61 90.35,79.48 90.35,77.27 R2811.2 90.58,77.12 91.57,78.11 v1(91.57,78.44) ; R943.1 13.03,116.41 11.89,115.27 11.89,110.5 12.35,110.04 13.75,110.04 13.97,109.82 13.97,106.36 14.18,106.15 16.03,106.15 16.53,105.64 v1(16.53,103.71)
  L8_IN3 w0.089: v1(16.53,103.71) 16.53,103.53 16.08,103.08 15.32,103.08 14.29,102.05 14.29,79.22 11.73,76.66 11.73,73.31 12.14,72.9 12.14,71.61 12.53,71.22 13.82,71.22 13.94,71.35 20.86,71.35 22.62,69.59 27.08,69.59 v1(27.38,69.29) 27.51,69.29 27.91,68.89 27.91,68.11 28.2,67.82 29.2,67.82 30.44,66.58 52.11,66.58 52.73,65.96 63.96,65.96 64.56,65.36 69.08,65.36 71.78,62.65 71.78,61.5 72.55,60.73 72.55,57.21 75.43,54.33 76.23,54.33 77.51,53.04 81.34,53.04 82.14,53.85 86.77,53.85 88.52,55.6 88.52,56.45 89.53,57.46 90.94,57.46 91.91,58.43 93.97,58.43 94.46,58.92 94.46,61.89 95.09,62.52 95.09,64.33 96.46,65.7 96.46,70.56 95.84,71.18 93.6,71.18 92.79,72 92.79,73.61 92.02,74.38 92.02,77.3 91.57,77.75 v1(91.57,78.44)
  BOTTOM w0.102: R944.1 26.77,70.46 27.38,69.85 v1(27.38,69.29)
GPIO7_LCD_BL_PWM: length 1.7
  TOP w0.102: G1.BD7 90.49,85.04 90.37,85.04 90.25,85.17 v6(89.99,85.17)
  BOTTOM w0.102: v6(89.99,85.17) 90.04,85.12 R2806.2
GPIO8_MEM_VDD_CTL: length 187.7
  TOP w0.1: G1.BH4 v6(93.05,83.18)
  TOP w0.102: v1(15.95,103.58) 15.95,103.71 16.33,104.09 16.33,105.56 15.94,105.95 14.1,105.95 13.77,106.28 13.77,109.73 13.66,109.83 12.26,109.83 11.63,110.46 11.63,114.51 11.38,114.76 4.39,114.76 3.55,113.92 R850.2
  TOP w0.254: R850.2 R867.1 2.56,113.12 Q129.G
  L8_IN3 w0.089: v6(93.05,83.18) 92.99,83.18 92.53,83.65 92.15,83.65 91.39,82.88 91.39,81.74 92.02,81.11 92.02,77.68 92.91,76.79 92.91,74.13 93.04,73.99 93.04,72.03 93.69,71.38 96.03,71.38 96.67,70.75 96.67,65.61 95.29,64.24 95.29,62.44 94.66,61.8 94.66,58.83 94.05,58.23 91.99,58.23 90.11,56.34 89.55,56.34 86.86,53.65 82.23,53.65 81.42,52.84 77.73,52.84 77.27,52.38 76.8,52.38 72.14,57.04 72.14,60.47 71.37,61.24 71.37,62.49 68.91,64.95 64.4,64.95 63.79,65.55 52.56,65.55 51.95,66.16 50.96,66.16 50.95,66.17 30.27,66.17 29.03,67.41 28.03,67.41 28,67.44 26.05,69.39 19.16,69.39 17.52,71.02 12.44,71.02 11.93,71.54 11.93,72.67 11.47,73.13 11.47,76.68 14.09,79.3 14.09,102.23 15.44,103.58 v1(15.95,103.58)
GPIO10_MEM_REF_CTL: length 286
  TOP w0.102: Q59.G 72.4,147.34 70.43,149.3 46,149.3 44.59,147.9 44.59,123.53 43.64,122.57 42.12,124.08 40.64,124.08 39.62,123.07 28.95,123.07 26.36,120.48 26.36,102.95 v1(26.49,102.82) ; v1(30.18,89.13) 30.18,88.21 30.36,88.03 Q64.G ; v1(89.89,77.8) 89.89,77.65 R2836.1 89.1,77.37 89.1,77.68 89.95,78.52 89.95,81.03 90.2,81.28 90.2,81.68 90.55,82.03 G1.BD3
  L3_IN1 w0.089: v1(26.49,102.82) 26.49,100.04 28.95,97.58 28.95,90.36 v1(30.18,89.13)
  L8_IN3 w0.089: v1(89.89,77.8) 89.89,77.45 89.36,76.91 89.36,76.29 89.54,76.11 89.54,73.16 89.1,72.72 89.1,71.45 90.2,70.35 94.08,70.35 95.73,68.7 95.73,66.18 93.2,63.64 93.2,61.65 91.37,59.82 91.37,58.99 90.5,58.12 90.33,58.12 89.32,58.12 87.91,56.7 86.09,56.7 84.19,54.8 82.23,54.8 81.08,53.65 77.97,53.65 76.32,55.31 75.31,55.31 74.29,56.32 74.29,60.61 73.75,61.15 72.99,61.15 72.39,61.75 72.39,66.03 69.56,68.86 55.59,68.86 55.21,68.48 54.48,68.48 53.19,67.19 30.69,67.19 28.51,69.37 28.31,69.37 27.68,70 22.79,70 21.03,71.76 14.24,71.76 13.26,72.74 13.26,77.61 14.7,79.05 14.7,101.7 14.93,101.93 15.7,101.93 16.71,102.95 16.71,103.08 17.35,103.71 20.27,103.71 21.28,104.73 24.59,104.73 v1(26.49,102.82)
GPIO11_LCD_VDD: length 8
  TOP w0.102: v1(93.72,75.67) 93.55,75.85 R2801.2 ; G1.BH3 v1(93.04,81.87)
  L8_IN3 w0.089: v1(93.72,75.67) 93.72,77.96 94.11,78.35 94.11,79.25 92.91,80.45 92.91,81.75 v1(93.04,81.87)
GPIO12_AC_DETECT: length 19.5
  TOP w0.102: G1.BE6 91.25,84.41 90.9,84.75 90.9,85.71 90.49,86.12 v1(90.46,86.12) ; v1(88.09,73.61) 88.72,73.61 89.28,74.17 R2813.2 89.61,73.34 D24.A
  L8_IN3 w0.089: v1(88.09,73.61) 88.09,79.33 88.39,79.63 88.39,83.82 88.75,84.18 88.75,84.94 88.85,85.04 88.85,85.08 89.66,85.89 89.7,85.89 89.92,86.12 v1(90.46,86.12)
GPIO13_LCD_BLEN: length 4.4
  TOP w0.102: R2803.2 87.45,78.31 89.15,80.01 G1.BB1
GPIO14_IFPA_HPD#: length 12.4
  TOP w0.102: v1(93.74,72.91) 92.66,73.99 R439.2 ; v1(92.33,82.55) 92.33,82.6 92.61,82.88 G1.BG4
  L8_IN3 w0.089: v1(92.33,82.55) 92.53,82.35 92.53,79.45 93.2,78.78 93.2,78.15 93.29,78.06 93.29,74.29 93.7,73.87 93.7,72.95 v1(93.74,72.91)
GPIO15_IFPB_HPD#: length 8.8
  TOP w0.102: G1.BG1 92.65,80.46 94.13,78.97 95.23,78.97 95.93,78.27 95.93,74.58 R440.2
GPIO17_IFPD_HPD#: length 5.8
  TOP w0.102: R437.2 97.23,77.55 95.4,79.38 94.51,79.38 93.35,80.54 G1.BH1
GPIO18_IFPE_HPD#: length 253.4
  TOP w0.102: v1(46.56,165.69) 47.45,166.58 Q53.C ; v1(97.23,63.83) 97.23,64.85 96.72,65.36 96.72,68.02 96.34,68.41 96.34,70.82 95.45,71.71 95.45,72.56 94.06,73.96 94.06,74.76 93.72,75.09 R438.2 93.04,75.59 93.04,77.68 93.19,77.83 93.19,79.17 92.02,80.34 92.02,80.85 91.64,81.23 91.64,81.51 91.42,81.74 91.4,81.74 91.25,81.9 G1.BE3
  L8_IN3 w0.089: v1(46.56,165.69) 46.36,165.69 30.65,149.97 30.65,125.72 27.35,122.42 27.35,115.12 27.79,114.67 27.79,111.36 25.79,109.36 23.81,109.36 22.34,107.89 22.34,107 20.18,104.83 15.61,104.83 13.48,102.7 13.48,79.55 10.86,76.94 10.86,72.59 10.62,72.34 10.62,71.92 12.15,70.38 15.72,70.38 17.02,69.08 18.45,69.08 18.75,68.78 25.8,68.78 27.77,66.81 28.78,66.81 30.03,65.55 51.69,65.55 52.3,64.94 62.18,64.94 62.78,64.34 68.66,64.34 70.76,62.23 70.76,60.99 71.53,60.22 71.53,56.79 77.46,50.85 85.08,50.85 85.61,51.39 89.97,51.39 90.37,51.78 90.37,52.59 90.33,52.63 90.33,53.19 90.37,53.23 90.42,53.29 90.42,54.39 92.64,56.61 94.7,56.61 96.46,58.37 98.69,58.37 99.15,58.84 99.15,61.66 98.75,62.06 98.02,62.06 97.48,62.59 97.48,62.89 97.21,63.16 97.21,63.81 v1(97.23,63.83)
GPIO24_IFPF_HPD#: length 8
  TOP w0.102: R441.2 88.47,77.8 v1(89.36,78.69) ; G1.BD5 90.55,83.6 v1(90.25,83.9)
  L8_IN3 w0.089: v1(90.25,83.9) 89.61,83.26 89.61,78.95 v1(89.36,78.69)
GPIO27_IFPC_HPD#: length 6.9
  TOP w0.1: 88.77,82.55 G1.BA4
  TOP w0.102: R436.2 86.31,77.68 88.77,80.14 88.77,82.55
GPIO28_OC_WARN: length 93.9
  TOP w0.102: v1(14.68,73.99) 14.63,73.94 14.17,73.94 13.33,73.1 11.28,73.1 10.67,72.49 9.63,72.49 9.35,72.22 9.35,71.83 8.58,71.07 7.7,71.07 7.43,70.81 U1.9 7.96,70.56 8.46,70.06 8.46,69.53 U1.8 ; R2949.2 v1(87.45,73.61)
  L8_IN3 w0.089: v1(14.68,73.99) 17.35,73.99 18.77,72.57 21.37,72.57 23.12,70.82 28.02,70.82 28.65,70.18 28.85,70.18 31.03,68.01 52.85,68.01 54.14,69.29 54.87,69.29 55.25,69.68 71.14,69.68 72.03,68.79 75.96,68.79 78.63,66.12 83.26,66.12 87.18,70.04 87.18,73.34 v1(87.45,73.61)
GPIO28_OCWARN: length 9.5
  TOP w0.102: R2949.1 R2812.2 88.34,75.39 87.96,75.77 87.96,78.06 89.47,79.57 89.47,82.55 G1.BB4
GPP_A11: length 3.9
  TOP w0.089: v1(121.89,13.67) 122.25,14.03 122.25,14.66 122.9,15.31 122.9,15.83 123.14,16.06 U28.BE36
  BOTTOM w0.102: v1(121.89,13.67) 122.25,14.03 TP18.1
GPP_B18: length 4.8
  TOP w0.076: v1(120.57,14.68) 120.48,14.68 120.47,14.68 120.32,14.68 119.91,15.09 119.91,16.24 U28.BE30
  BOTTOM w0.102: v1(120.57,14.68) 121.36,13.89 121.36,13.29 120.93,12.86 R361.2
GPP_H12: length 8.5
  TOP w0.076: 131.14,31.96 130.38,31.19 130.38,27.9 129.74,27.27 128.59,27.27 128.3,27.56 U28.AB47
  TOP w0.102: 131.14,31.96 131.52,32.34 R76.1
GPP_H15: length 7.9
  TOP w0.076: 131.14,30.94 130.63,30.43 130.63,27.77 129.97,27.1 128.52,27.1 128.47,27.06 U28.AC47
  TOP w0.102: 131.14,30.94 131.65,31.45 R73.1
GPP_J9: length 1.4
  TOP w0.089: v2(109.47,19.28) 109.47,19.3 109.64,19.46 U28.AU9
  BOTTOM w0.102: v2(109.47,19.28) 109.46,19.27 109.46,19.23 109.36,19.13 R355.2
GPU_ADAPTOR_IN: length 105.2
  TOP w0.102: 94.8,66.26 96.07,66.26 96.52,65.81 96.52,65.05 96.82,64.75 96.82,63.22 97.99,62.06 97.99,61.48 97.59,61.07 97.59,60.68 98.09,60.18 98.09,59.69 v1(97.89,59.49) ; 94.8,66.26 v1(94.44,66.63) ; 94.8,66.26 Q4.3 ; D24.C v1(88.98,69.42)
  L3_IN1 w0.089: v1(156.79,47.2) 156.79,46.18 156.17,45.55 156.17,37 159.73,33.43 159.73,32.23 v1(159.71,32.21)
  L8_IN3 w0.089: v1(88.98,69.42) 89.74,68.66 91.9,68.66 92.8,69.57 93.64,69.57 93.72,69.48 93.72,67.34 v1(94.44,66.63)
  BOTTOM w0.102: v1(97.89,59.49) 98.02,59.49 98.12,59.39 101.11,59.39 102.28,58.22 106.61,58.22 107.43,57.41 127.59,57.41 137.21,47.78 142.47,47.78 142.95,47.3 156.69,47.3 v1(156.79,47.2) ; v1(159.71,32.21) 159.46,31.96 159.46,29.67 159.22,29.43 U5.123
GPU_BUFRST#: length 1.1
  TOP w0.125: G1.BF9 v6(92.25,86.68)
  BOTTOM w0.102: v6(92.25,86.68) 92.23,86.66 R2878.2
GPU_EVENT#_GC6: length 116.3
  TOP w0.076: U28.BE21 115.67,16.06 115.9,15.83 115.9,15.42 115.72,15.24 115.52,15.24 115.34,15.06 115.34,14.86 115.01,14.53 115.01,13.9
  TOP w0.089: 115.01,13.9 114.63,13.52 114.63,11.26 114.38,11 114.25,11 113.33,10.09 113.33,9.86 v1(113.28,9.81)
  TOP w0.102: D23.C v1(90.5,69.17)
  L6_IN2 w0.089: v1(113.28,9.81) 113.16,9.81 111.5,8.16 103.63,8.16 102.03,6.56 97.96,6.56 97.27,7.25 92.73,7.25 92.13,7.85 87.3,7.85 84.9,10.25 84.9,16.72 83.41,18.21 83.41,22.41 83.3,22.52 83.3,34.78 83.21,34.87 77.26,40.82 77.26,45.16 83.72,51.62 83.72,53.93 85.74,55.96 87.45,55.96 89.99,58.5 90.12,58.5 v1(90.25,58.63)
  L8_IN3 w0.089: v1(90.25,58.63) 90.25,59.9 91.48,61.13 92.07,61.13 92.79,61.86 92.79,63.84 95.2,66.24 95.2,68.53 93.8,69.93 91.26,69.93 v1(90.5,69.17)
GPU_NVVDD_FBRTN: length 188.5
  TOP w0.147: G1.BL45 95.65,111.58 95.97,111.91 96.15,111.91 96.33,112.09
  TOP w0.203: 96.33,112.09 97.23,112.09 100.65,115.52 v1(101.42,115.52)
  TOP w0.254: 18.62,107.01 16.33,107.01 15.62,107.72 R948.1 R998.1 ; 18.62,107.01 18.85,107.24 18.85,108.72 R987.1 19.43,109.3 19.43,111 19.96,111.53 C2550.2 20.01,112.09 19.25,112.86 U722.10 ; 18.62,107.01 19.89,105.74 21.67,105.74 v1(22.05,105.36)
  L8_IN3 w0.203: v1(22.05,105.36) 22.05,105.75 23.01,106.72 23.01,107.2 23.28,107.47 23.66,107.47 23.67,107.46 25.47,107.46 26.55,108.54 26.55,109.18 28.46,111.08 28.46,114.95 28.02,115.4 28.02,122.13 31.32,125.43 31.32,149.69 35.32,153.68 102.81,153.68 104.71,151.78 104.71,131.34 104.02,130.66 104.02,116.6 103.2,115.78 101.68,115.78 v1(101.42,115.52)
GPU_NVVDD_SENSE: length 173.4
  TOP w0.147: 95.99,112.3 95.92,112.3 95.56,111.93 95.1,111.93 G1.BK45
  TOP w0.203: v1(23.47,107.01) 23.14,107.34 C550.1 ; 95.99,112.3 96.17,112.47 97.1,112.47 100.79,116.16 v1(101.42,116.16)
  TOP w0.381: R952.1 22.68,108.21 C550.1 R2942.1 R2940.1
  L8_IN3 w0.203: v1(23.47,107.01) 23.57,107.01 23.7,107.14 25.6,107.14 26.87,108.41 26.87,109.05 28.78,110.95 28.78,115.08 28.37,115.49 28.37,121.97 31.7,125.3 31.7,149.56 35.51,153.37 102.68,153.37 104.39,151.65 104.39,131.47 103.71,130.79 103.71,116.79 103.07,116.16 v1(101.42,116.16)
GPU_NVVDDS_FBRTN: length 222.7
  TOP w0.203: G1.BM44 96.48,111.21 97.49,111.21 98.5,112.22 99.62,112.22 R946.1 100.23,112.09 100.27,112.05 101.05,112.05 101.47,112.47 101.47,113.74 101.04,114.18 v1(101.04,114.38)
  L6_IN2 w0.203: v1(25.32,66.37) 22.55,66.37 20.83,68.1 17.5,68.1 v1(17.47,68.08) 16.13,69.42 13.46,69.42 11.91,70.97 11.91,73.26 10.26,74.91 10.26,75.2 10.26,75.43 10.26,79.81 13.79,83.34 13.79,97.11 15.77,99.09 19.91,99.09 27.81,106.99 27.81,123.19 34.49,129.87 40.72,129.87 44.17,133.33 44.17,146.47 44.14,146.5 44.14,146.64 46.81,149.3 98.37,149.3 100.35,147.32 100.35,138.25 97.43,135.33 97.43,132.16 98.5,131.09 98.5,116.41 100.33,114.58 100.83,114.58 100.85,114.56 100.86,114.56 v1(101.04,114.38)
  BOTTOM w0.203: U721.10 19.21,68.62 19.13,68.53 18.11,68.53 17.47,69.17 C2555.2 R947.2 16.97,68.1 17.45,68.1 v1(17.47,68.08) ; R962.1 C796.2 23.34,65.89 R965.2 C798.2 25.22,66.27 v1(25.32,66.37)
GPU_NVVDDS_SENSE: length 209
  TOP w0.203: v1(12.62,69.45) 12.62,69.65 13.66,70.69 15.19,70.69 15.57,71.07 C802.1 ; v1(101.04,115.01) 100.68,114.65 100.68,114.63 100.61,114.56 100.61,114.18 101.17,113.62 101.17,112.6 100.92,112.36 100.4,112.36 99.77,112.98 R2939.1 99.24,112.53 98.37,112.53 97.37,111.52 96.21,111.52 G1.BM45
  L6_IN2 w0.203: v1(101.04,115.01) 100.91,114.89 100.46,114.89 98.8,116.54 98.8,131.22 97.74,132.29 97.74,135.21 100.66,138.13 100.66,147.53 98.58,149.61 46.68,149.61 43.84,146.76 43.84,146.62 43.84,146.37 43.86,146.34 43.86,133.45 40.59,130.18 34.37,130.18 27.51,123.32 27.51,107.11 19.79,99.39 15.65,99.39 13.49,97.23 13.49,83.47 9.96,79.94 9.96,75.43 9.96,75.33 9.96,75.33 9.96,74.78 11.61,73.13 11.61,70.84 12.67,69.78 12.67,69.49 v1(12.62,69.45)
  BOTTOM w0.203: R959.2 R2941.1 C548.1 12.14,69.93 v1(12.62,69.45)
H-PECI: length 200.4
  TOP w0.076: v1(105.36,25.86) 105.36,25.64 105.82,25.18 U28.AF2 ; 163.59,128.73 162.62,127.76 U26.BT34
  TOP w0.102: 163.59,128.73 165.28,130.42 167.09,130.42 R3129.2 168.12,130.61 173.71,130.61 175.97,128.35 176.76,128.35 v1(176.89,128.48)
  L3_IN1 w0.089: v1(105.36,25.86) 105.36,25.73 106.24,24.85 107.59,24.85 107.59,24.86 109.05,24.86 111.22,27.03 112.54,27.03 113.1,27.58 113.1,28.65 114.28,29.83 118.56,29.83 118.81,29.58 122.11,29.58 122.78,28.91 122.78,28.6 123.24,28.15 125.55,28.15 126.82,26.88 130.91,26.88 132.7,28.67 132.7,46.78 146.32,60.4 166.65,60.4 170.13,63.88 181.89,63.88 185.04,67.04 185.04,73.59 183.65,74.99 183.65,81.53 184.52,82.41 184.52,86.03 182.91,87.65 182.91,96.92 182.42,97.41 182.42,106.08 184.73,108.39 184.73,125.17 181.18,128.73 177.14,128.73 v1(176.89,128.48)
H_A20GATE: length 5.7
  TOP w0.102: v1(157.43,25.35) 157.3,25.23 R3290.2
  BOTTOM w0.102: U5.126 160.42,27.45 158.32,25.35 v1(157.43,25.35)
H_RCIN#: length 53
  TOP w0.076: U28.BE39 124.31,16.15 124.18,16.02 124.18,15.35 123.99,15.16 123.99,14.64 123.99,14.63 123.99,14.21 124.15,14.05 124.38,14.05 v1(124.41,14.02) 124.28,13.9 124.28,13.59 124.11,13.41
  TOP w0.102: 124.11,13.41 123.77,13.08 123.77,11.84 123.72,11.79 R321.1
  L6_IN2 w0.089: v1(124.41,14.02) 125.7,12.73 127.28,12.73 128.5,13.95 132.89,13.95 133.96,12.88 143.52,12.88 146.6,15.95 146.6,16.97 147.92,18.29 147.92,18.91 148.65,19.64 149.3,19.64 151.46,21.8 153.42,21.8 153.94,22.32 v1(155.9,22.32)
  BOTTOM w0.102: v1(155.9,22.32) 155.9,24.21 156.48,24.78 158.63,24.78 159.76,25.91 U5.4
H_THERMTRIP_N: length 133.6
  TOP w0.102: Q51.E 96.85,27.77 97.48,27.13 v1(101.29,27.13) 101.55,27.38 R94.1 ; U26.J31 127.02,126.5 v1(127.02,127.11)
  L3_IN1 w0.089: v1(120.34,122.3) 120.29,122.25 120.29,121.69 118.46,119.86 118.46,111.21 111.53,104.28 111.53,90.15 110.08,88.7 110.08,83.15 110.97,82.26 110.97,61.59 114.65,57.9 114.65,39.45 112.24,37.04 107.96,37.04 107.03,36.1 107.03,31.99 102.17,27.13 v1(101.29,27.13)
  L8_IN3 w0.089: v1(120.34,122.3) 120.34,122.63 120.72,123.01 124.29,123.01 124.92,122.38 126.19,122.38 127.08,123.27 128.35,123.27 128.85,123.78 128.85,124.67 127.02,126.49 v1(127.02,127.11)
  BOTTOM w0.203: R98.2 118.52,122.89 119.76,122.89 v1(120.34,122.3)
HDMI1_CLK_DN: length 116.3
  TOP w0.102: v1(93.05,89.5) 92.67,89.88 G1.BG14 ; v1(63.64,166.07) 63.75,166.18 63.75,167.28 C365.1
  L6_IN2 w0.076: v1(63.64,166.07) 63.81,165.9 63.81,164.91 66.72,162 70.18,162 73.66,158.52 73.66,158.52 75.34,156.84 81.23,150.96 98.04,150.96 106.06,142.94 106.06,129.21 104.08,127.22 104.08,126.98 104.08,113.76 101.04,110.72 101.04,102.73 95.04,96.73 94.15,96.73 91.34,93.91 91.34,90.68 92.02,90 93.13,90 93.22,89.91 93.22,89.58 93.14,89.5 v1(93.05,89.5)
HDMI1_CLK_DP: length 116.3
  TOP w0.102: C404.1 64.18,167.29 64.18,166.23 v1(64.34,166.07) ; G1.BH14 93.67,89.55 v1(93.67,89.49)
  L6_IN2 w0.076: v1(64.34,166.07) 64.31,166.07 64.1,165.86 64.1,165.03 66.84,162.3 70.3,162.3 73.95,158.64 75.41,157.19 81.35,151.25 98.16,151.25 106.35,143.06 106.35,129.08 104.37,127.1 104.37,113.64 101.33,110.6 101.33,102.61 95.16,96.43 94.27,96.43 91.63,93.79 91.63,90.8 92.14,90.29 93.26,90.29 93.51,90.03 93.51,89.65 v1(93.67,89.49)
HDMI1_TX0_DN: length 114.9
  TOP w0.102: C408.1 71.33,167.31 71.33,166.53 v1(71.04,166.23) ; v1(92.25,89.49) 91.95,89.79 G1.BF14
  L6_IN2 w0.076: v1(71.04,166.23) 71.04,166.25 71.11,166.32 71.37,166.32 71.45,166.25 71.45,165.22 71.84,164.84 74.81,164.84 74.97,164.67 74.97,164.39 75.13,164.23 75.42,164.23 75.58,164.06 75.58,163.78 75.74,163.61 76.03,163.61 76.19,163.45 76.19,163.17 76.35,163 76.64,163 78.54,161.1 78.54,160.5 82.64,156.4 82.64,155.9 85.56,152.97 98.87,152.97 108.08,143.77 108.08,128.37 106.09,126.39 106.09,112.92 103.4,110.23 103.4,102.04 95.71,94.35 95.71,89.01 95.04,88.34 92.66,88.34 92.09,88.91 92.09,89.41 92.17,89.49 v1(92.25,89.49)
HDMI1_TX0_DP: length 114.9
  TOP w0.102: C409.1 71.77,167.26 71.77,166.39 v1(71.96,166.2) ; v1(91.64,89.49) 91.25,89.88 G1.BE14
  L6_IN2 w0.076: v1(71.96,166.2) 71.74,165.98 71.74,165.34 71.96,165.13 74.93,165.13 78.84,161.22 78.84,160.62 82.93,156.52 82.93,156.02 85.68,153.27 99,153.27 108.37,143.89 108.37,128.25 106.39,126.27 106.39,112.8 103.69,110.11 103.69,101.92 96,94.22 96,88.89 95.16,88.05 94.92,88.05 92.54,88.05 91.8,88.79 91.8,89.33 v1(91.64,89.49)
HDMI1_TX1_DN: length 112.1
  TOP w0.102: C403.1 66.39,167.3 66.39,166.68 v1(66.17,166.45) ; G1.BF15 v1(92.29,90.92)
  L6_IN2 w0.076: v1(92.29,90.92) 92.37,91 92.37,91.87 93.7,93.2 93.7,94.24 102.06,102.6 102.06,110.79 104.75,113.48 104.75,126.95 106.73,128.93 106.73,143.21 98.32,151.63 81.7,151.63 77.63,155.69 77.63,155.93 77.63,157.82 76.79,158.66 75.93,158.66 71.85,162.74 70.93,162.74 69.27,164.4 67.06,164.4 66.45,165.01 66.45,166.16 v1(66.17,166.45)
HDMI1_TX1_DP: length 112.1
  TOP w0.102: v1(66.89,166.46) 66.83,166.52 66.83,167.27 C369.1 ; G1.BG15 v1(93.04,90.97)
  L6_IN2 w0.076: v1(93.04,90.97) 92.66,91.36 92.66,91.75 93.99,93.08 93.99,94.12 102.35,102.48 102.35,110.67 105.04,113.36 105.04,126.82 107.02,128.81 107.02,143.34 98.44,151.92 81.82,151.92 77.93,155.81 77.93,157.94 76.91,158.96 76.05,158.96 71.97,163.04 71.05,163.04 69.39,164.7 67.18,164.7 66.74,165.13 66.74,166.32 v1(66.89,166.46)
HDMI1_TX2_DN: length 112.1
  TOP w0.102: v1(93.04,91.6) 92.85,91.78 92.85,91.78 G1.BG17 ; v1(68.2,166.45) 68.45,166.2 68.66,166.2 69.05,166.59 69.05,167.5 68.95,167.6 68.68,167.6 C411.1
  L6_IN2 w0.076: v1(68.2,166.45) 68.47,166.18 69.05,166.18 71.32,163.91 73.48,163.91 84.8,152.59 98.72,152.59 107.69,143.62 107.69,128.53 105.71,126.55 105.71,113.08 103.02,110.39 103.02,102.2 94.93,94.11 94.93,91.3 94.52,90.88 93.65,90.88 93.29,91.25 93.29,91.35 v1(93.04,91.6)
HDMI1_TX2_DP: length 112.1
  TOP w0.102: v1(68.2,165.77) 68.84,165.77 69.48,166.42 C414.1 ; G1.BH17 93.7,91.63 v1(93.7,91.62)
  L6_IN2 w0.076: v1(93.7,91.62) 93.62,91.54 93.62,91.33 93.77,91.18 94.4,91.18 94.64,91.42 94.64,91.65 94.44,91.85 94.44,92.08 94.64,92.28 94.64,92.51 94.44,92.71 94.44,92.94 94.64,93.14 94.64,94.23 102.73,102.32 102.73,110.51 105.42,113.2 105.42,126.67 107.4,128.65 107.4,143.49 98.6,152.3 84.68,152.3 84.51,152.46 84.23,152.46 84.07,152.62 84.07,152.91 83.9,153.07 83.62,153.07 83.45,153.24 83.45,153.52 83.29,153.68 83.01,153.68 82.84,153.85 82.84,154.13 80.1,156.87 79.82,156.87 79.65,157.04 79.65,157.32 79.49,157.48 79.21,157.48 79.04,157.65 79.04,157.93 78.88,158.1 78.59,158.1 78.43,158.26 78.43,158.55 78.27,158.71 77.98,158.71 77.82,158.87 77.82,159.16 73.36,163.62 71.2,163.62 68.93,165.89 68.31,165.89 v1(68.2,165.77)
HDMI_CLK: length 32
  TOP w0.102: v1(54.18,162.77) 54.3,162.89 54.3,163.35 54.2,163.45 R495.1 53.67,162.94 53.67,161.37 53.92,161.12 54.81,161.12 54.94,160.99 54.94,160.73 55.59,160.08 Q114.6 ; D59.1 62.12,175.4 v1(61.92,175.59)
  L8_IN3 w0.089: CN26.15 61.64,179.91 60.4,179.91 59.77,179.28 59.77,177.5 60.78,176.48 62.05,176.48 62.18,176.36 62.18,176.1 61.92,175.85 v1(61.92,175.59) 61.92,175.25 61.59,174.91 60.22,174.91 55.45,170.13 55.45,168.48 54.18,167.21 v1(54.18,162.77)
HDMI_DAT: length 28.4
  TOP w0.102: Q114.3 54.29,162.3 54.58,162.6 54.58,162.97 R494.2 v1(55.07,162.77) ; D59.2 v1(62.49,175.66)
  L8_IN3 w0.089: CN26.16 61.8,179.27 61.37,179.71 60.48,179.71 60.01,179.23 60.01,177.54 60.87,176.69 62.14,176.69 62.38,176.44 62.38,175.77 v1(62.49,175.66) 62.49,175.53 61.67,174.7 60.31,174.7 55.65,170.05 55.65,168.4 54.38,167.13 54.38,163.45 v1(55.07,162.77)
HDMIOUT_CLK+: length 3.2
  TOP w0.102: CN26.10 64.72,179.03 64.54,178.84 64.54,177.6 64.21,177.27 64.21,176.43 R519.2
HDMIOUT_CLK-: length 3.2
  TOP w0.102: CN26.12 63.88,179.03 64.11,178.79 64.11,177.78 63.78,177.45 63.78,176.38 R537.2
HDMIOUT_D0+: length 9.8
  TOP w0.102: v1(71.53,178.13) 71.32,177.93 71.32,177.5 71.86,176.96 71.86,176.41 R504.2
  L3_IN1 w0.076: v1(71.53,178.13) 71.26,178.4 71.26,179.34 70.75,179.85 66.23,179.85 66.03,180.05 66.03,180.3 CN26.7
HDMIOUT_D0-: length 9.8
  TOP w0.102: R502.2 71.42,176.41 71.42,176.79 70.89,177.32 70.89,178.01 v1(70.76,178.13)
  L3_IN1 w0.076: CN26.9 65.73,180.15 65.73,179.93 66.11,179.55 70.62,179.55 70.95,179.21 70.95,178.32 v1(70.76,178.13)
HDMIOUT_D1+: length 3.4
  TOP w0.102: CN26.4 67.51,178.74 67.51,178.03 66.75,177.27 66.75,176.43 R516.2
HDMIOUT_D1-: length 3.4
  TOP w0.102: CN26.6 67.08,178.74 67.08,178.21 66.32,177.45 66.32,176.38 R507.2
HDMIOUT_D2+: length 5.2
  TOP w0.102: CN26.1 69.27,180.57 69.04,180.34 69.04,180.17 69.93,179.28 69.93,178.39 69.32,177.78 69.32,176.41 R517.2
HDMIOUT_D2-: length 5.2
  TOP w0.102: CN26.3 68.6,180.27 68.6,179.99 69.49,179.1 69.49,178.57 68.88,177.96 68.88,176.41 R518.2
HDRV_CHG: length 33.4
  TOP w0.203: v1(61.92,41.23) 62.03,41.34 U97.26
  TOP w0.508: PQ37.1 v1(43.18,62.51)
  L6_IN2 w0.508: v1(43.18,62.51) 43.56,62.51 51.51,54.56 51.51,51.01 55.96,46.56 55.96,44.02 59.13,40.85 61.54,40.85 v1(61.92,41.23)
HOLD#_DGPU: length 2.1
  TOP w0.102: U83.7 105.46,74.09 104.9,73.54 R2881.1
HP_JD_SENSE#: length 25.4
  TOP w0.102: AR5.2 26.44,65.31 v1(26.9,64.85)
  BOTTOM w0.102: CN12.11 12.83,54.36 13.64,55.17 13.64,59.05 13.98,59.39 14.45,59.39 14.55,59.49 19.18,64.11 20.09,64.11 20.34,63.86 22.2,63.86 22.5,64.16 v3(23.49,64.16) 23.75,64.42 26.47,64.42 v1(26.9,64.85)
HP_L: length 4.2
  TOP w0.203: AR12.2 16.86,58.05 17.03,58.05 17.04,58.07 17.18,58.07 17.66,58.55 18.82,58.55 19.5,59.23 20.26,59.23 U7.32
HP_R: length 4.3
  TOP w0.203: U7.33 19.69,58.77 19.01,58.09 17.85,58.09 17.37,57.61 17.04,57.61 AR11.2
HPD_HDMI: length 373.7
  TOP w0.102: Q37.S 55.13,170.53 R259.2 R674.2 53.36,169.62 49.86,169.62 46.05,165.81 46.05,165.56 v1(46.56,165.05)
  L6_IN2 w0.089: v1(166.95,12.53) 167.61,11.87 169.09,11.87 169.49,12.27 175.11,12.27 178.79,15.95 178.79,18.77 190.47,30.44 190.47,40.6 v1(189.51,41.56)
  L8_IN3 w0.089: v1(97.23,59.26) 97.23,59.2 96.76,58.73 96.54,58.73 94.63,56.83 92.57,56.83 90.69,54.94 90.13,54.94 87.32,52.14 86.08,52.14 85,51.06 77.55,51.06 71.73,56.87 71.73,60.31 70.97,61.07 70.97,62.32 68.74,64.54 62.86,64.54 62.26,65.15 52.39,65.15 51.78,65.76 30.11,65.76 28.86,67.01 27.86,67.01 27.83,67.03 25.88,68.98 18.83,68.98 18.51,69.31 17.09,69.31 15.81,70.59 12.24,70.59 11.52,71.3 11.52,72.5 11.07,72.96 11.07,76.85 13.68,79.47 13.68,102.61 15.7,104.63 20.26,104.63 22.55,106.91 22.55,107.81 23.9,109.15 25.88,109.15 28,111.27 28,114.76 27.55,115.2 27.55,122.33 30.85,125.63 30.85,149.89 46.02,165.05 v1(46.56,165.05)
  BOTTOM w0.102: v1(189.51,41.56) 189.51,41.45 187.63,39.57 185.63,39.57 184.73,40.47 175.98,40.47 171.55,44.9 158.36,44.9 156.17,47.09 142.86,47.09 142.38,47.58 137.13,47.58 127.5,57.2 107.34,57.2 106.53,58.02 102.19,58.02 101.03,59.19 98.42,59.19 98.25,59.01 97.48,59.01 v1(97.23,59.26) ; R557.1 166.93,12.85 166.93,12.55 v1(166.95,12.53)
HYB_ON#: length 136.7
  TOP w0.102: v1(76.91,34.41) 76.91,36.27 75.79,37.39 75.79,40.21 75.16,40.85 75.16,42.73 71.12,46.76 R3332.2
  TOP w0.203: R3332.2 R3335.2
  L8_IN3 w0.089: v1(148.62,27.38) 148.67,27.34 148.67,25.86 151.62,22.91 151.62,19.29 147.3,14.96 145.07,14.96 140.96,10.85 140.96,8.39 138.36,5.79 125.39,5.79 124.78,5.18 119.12,5.18 117.88,3.95 110.12,3.95 109.46,3.29 99.1,3.29 98.54,3.85 87.29,3.85 81.25,9.89 81.25,12.57 80.05,13.77 80.05,32.35 77.99,34.41 v1(76.91,34.41)
  BOTTOM w0.102: v1(148.62,27.38) 149.22,27.98 U5.98
I2C0_SCL: length 17.2
  TOP w0.076: 115.11,13.41 116.15,14.46 116.15,15.12 116.07,15.19 116.07,16.56 115.95,16.69 U28.BC22
  TOP w0.102: v1(114.49,10.14) 114.49,10.35 115.06,10.93 115.06,13.37 115.11,13.41 ; v1(109.3,7.32) 108.85,6.87 CN17.3
  BOTTOM w0.102: R484.1 109.8,6.81 v1(109.3,7.32) 109.3,7.7 109.42,7.83 113.18,7.83 v3(114.48,9.12) 114.49,9.13 v1(114.49,10.14)
I2C0_SDA: length 16.6
  TOP w0.076: 115.39,13.36 115.39,13.46 116.33,14.4 116.33,15.66 U28.BF23
  TOP w0.102: CN17.4 108.35,7.01 v1(108.66,7.32) ; v1(113.99,9.86) 114.12,9.73 114.88,9.73 115.26,10.11 115.26,13.24 115.39,13.36
  BOTTOM w0.102: R485.1 108.91,7.06 v1(108.66,7.32) 108.66,7.45 109.24,8.03 112.93,8.03 113.16,8.26 v3(113.16,8.59) 113.99,9.43 v1(113.99,9.86)
I2CB_SCL_G: length 14.5
  TOP w0.102: v1(92.28,85.32) 92.29,85.32 G1.BG8 ; R2924.2 91.69,72.47 91.49,72.47 v1(91.36,72.6)
  L8_IN3 w0.089: v1(92.28,85.32) 92.07,85.12 92.07,83.95 91.16,83.04 91.16,72.8 v1(91.36,72.6)
I2CB_SDA_G: length 15.2
  TOP w0.102: R2849.2 91.82,71.96 v1(91.26,71.96) ; G1.BF8 91.95,85.64 91.62,85.32 v1(91.62,85.32)
  L8_IN3 w0.089: v1(91.62,85.32) 91.88,85.05 91.88,84.03 90.96,83.11 90.96,72.26 v1(91.26,71.96)
I2CC_SCL: length 106.1
  TOP w0.102: U1.6 8.92,68.23 9.63,68.94 10.08,68.94 10.35,68.67 v1(10.35,68.53) ; Q122.6 94.07,69.82 93.42,69.17 93.42,68.02 93.8,67.64 R2850.2 93.34,67.47 v1(93.17,67.64)
  L6_IN2 w0.102: v1(10.35,68.53) 10.35,68.65 10.51,68.81 11.23,68.81 12.27,67.77 13.71,67.77 13.92,67.77 14.65,67.03 15.97,67.03 18.87,64.13 18.87,63.58 19.25,63.2 54.69,63.2 54.97,62.92 55.58,62.92 66.32,52.17 77.34,52.17 84.55,59.39 89.25,59.39 90.75,60.89 90.75,66.61 91.64,67.49 93.01,67.49 v1(93.17,67.64)
I2CC_SCL_G: length 20.7
  TOP w0.102: v6(93.05,86.78) 92.65,86.38 G1.BG9 ; Q122.1 92.34,70.55 R2848.2 v1(91.26,70.95)
  L8_IN3 w0.089: v1(91.26,70.95) 91.25,70.95 90.36,71.83 90.36,83.4 90.97,84 90.97,85.5 91.52,86.05 92.78,86.05 93.21,86.49 93.21,86.61 v6(93.05,86.78)
I2CC_SDA: length 105.6
  TOP w0.102: Q122.3 92.68,68.52 92.79,68.42 92.79,67.97 R2925.2 92.66,67.08 v1(93.17,67.08) ; R201.2 10.91,68.01 v1(10.91,68.41) 10.91,68.62 10.36,69.17 9.35,69.17 9.06,68.88 U1.7
  L6_IN2 w0.102: v1(10.91,68.41) 11.27,68.41 12.16,67.52 13.81,67.52 14.55,66.78 15.86,66.78 18.62,64.03 18.62,63.47 19.15,62.94 54.59,62.94 54.87,62.66 55.47,62.66 66.22,51.92 77.44,51.92 84.66,59.13 89.36,59.13 91.01,60.79 91.01,66.5 91.74,67.24 93.01,67.24 v1(93.17,67.08)
I2CC_SDA_G: length 26.7
  TOP w0.102: v6(93.68,86.69) 93.65,86.67 93.65,86.67 93.62,86.64 93.61,86.64 G1.BH9 ; R2921.2 95.58,70.64 v1(95.58,70.18) 95.58,69.04 95.06,68.52 Q122.4
  L8_IN3 w0.089: v6(93.68,86.69) 93.55,86.69 93.4,86.55 93.4,86.41 92.86,85.86 91.6,85.86 91.16,85.42 91.16,83.92 90.58,83.34 90.58,71.89 91.12,71.35 92,71.35 92.79,70.56 95.2,70.56 v1(95.58,70.18)
I_NVVDD_N: length 61.5
  TOP w0.254: R1092.1 v1(3.12,117.94) ; v1(3,63.58) 2.62,63.58 2.13,64.07 2.13,64.11 R185.1
  L8_IN3 w0.254: v1(3,63.58) 2.25,64.33 2.25,65.53 3.12,66.4 3.12,70.15 1.85,71.42 1.85,80.37 3.89,82.41 3.89,85.65 2.11,87.42 2.11,100.57 3.12,101.58 3.12,103.17 2.11,104.19 2.11,110.6 2.62,111.11 2.62,115.24 2.11,115.75 2.11,117.3 2.36,117.55 2.74,117.55 v1(3.12,117.94)
I_NVVDD_P: length 59
  TOP w0.254: R1084.1 v1(3.12,117.05) ; v1(3.1,64.2) 2.96,64.06 2.64,64.06 2.49,64.21 R182.1
  L8_IN3 w0.254: v1(3.1,64.2) 3.09,64.2 2.62,64.67 2.62,65.36 3.5,66.25 3.5,70.31 2.23,71.58 2.23,80.22 4.27,82.25 4.27,85.8 2.49,87.58 2.49,100.41 3.5,101.43 3.5,103.33 2.49,104.35 2.49,110.44 3,110.95 3,115.4 2.49,115.9 2.49,116.79 2.74,117.05 v1(3.12,117.05)
I_NVVDDS_N: length 3.1
  TOP w0.254: R204.1 4.9,61.85 4.9,61.04 5.2,60.74 5.2,59.69 5.03,59.52 R1093.1
I_NVVDDS_P: length 3.1
  TOP w0.254: R1085.1 5.66,59.52 5.56,59.62 5.56,60.89 5.28,61.17 5.28,61.85 R208.1
I_VIN_N: length 23.9
  TOP w0.254: v1(3,73.36) 2.54,73.36 R181.1
  L3_IN1 w0.254: v1(11.63,60.91) 11.38,61.17 11.38,61.79 9.58,63.58 8.2,63.58 7.57,64.21 7.57,64.98 8.95,66.36 8.95,72.55 8.74,72.77 8.41,73.09 3.52,73.09 3.25,73.36 v1(3,73.36)
  BOTTOM w0.254: R1083.1 11.38,60.66 v1(11.63,60.91)
I_VIN_P: length 23.2
  TOP w0.254: R177.1 2.67,72.72 v1(3,72.72)
  L3_IN1 w0.254: v1(3,72.72) 8.26,72.72 8.58,72.4 8.58,66.63 7.19,65.23 7.19,64.07 8.06,63.2 9.44,63.2 11.01,61.63 11.01,61.05 v1(10.87,60.91)
  BOTTOM w0.254: v1(10.87,60.91) 11,60.79 11,59.82 R1091.1
IACM: length 2.2
  TOP w0.203: R3298.1 62.69,38.43 63.19,38.94 63.45,38.94 63.9,39.39 U97.1
IACP: length 1.9
  TOP w0.203: R3295.1 63.58,38.56 64.3,39.28 U97.2
IADAPTER_I BAT: length 120.8
  TOP w0.102: v1(75.14,35.15) 75.13,35.15 75.13,36.15 73.46,37.82 73.35,37.93 72.39,37.93 71.8,38.51 70,38.51 69.47,39.04 C3537.2
  TOP w0.203: U97.7 66.3,39.52 66.5,39.32 69.34,39.32 C3537.2
  L8_IN3 w0.089: v1(145.11,16.97) 144.73,17.35 144.09,17.35 143.46,16.72 140.92,16.72 140.14,15.94 140.14,8.73 139,7.58 137.61,7.58 136.63,6.61 125.05,6.61 124.44,6 117.94,6 116.75,4.81 109.83,4.81 109.12,4.1 100.7,4.1 100.07,4.73 98.08,4.73 98.01,4.67 87.63,4.67 82.72,9.57 82.72,11.05 82.07,11.7 82.07,12.97 80.87,14.17 80.87,32.75 77.99,35.62 75.62,35.62 v1(75.14,35.15)
  BOTTOM w0.102: v1(145.11,16.97) 144.68,17.4 C182.1 145.33,17.73 145.56,17.51 U5.72
ICHM: length 2.4
  TOP w0.203: R3318.1 C3574.1 64.7,44.37 U97.19
ICHP: length 3.6
  TOP w0.203: U97.20 64.3,44.24 63.96,44.58 63.58,44.58 C3574.2 62.67,45.04 61.87,45.83 R3307.1
ID_DET: length 460.5
  TOP w0.102: v1(182.07,166.32) 182.07,166.64 181.3,167.4 R245.2 181.61,167.72 187.15,167.72 187.81,167.06 Q49.G ; CN9.5 165,8.08 R3585.2 164.11,9.07 v4(164.11,9.17) 163.91,9.38 Q48.G 163.91,10.87 v1(163.4,11.38)
  L3_IN1 w0.089: v1(188.69,43.4) 188.69,44.24 186.18,46.75 186.18,57.75 192.87,64.44 192.87,75.79 193.55,76.48 193.55,92.43 194.31,93.19 194.31,94.59 194.31,101.53 194.95,102.18 194.95,136.29 193.73,137.51 193.73,138.11 193.88,138.26 193.88,160.73 188.77,165.84 182.55,165.84 v1(182.07,166.32)
  L6_IN2 w0.089: v1(153.53,17.26) 154.83,15.95 154.89,15.95 155.89,14.96 165.03,14.96 165.54,14.45 165.54,13.17 165.54,13.1 165.54,13.01 163.91,11.38 v1(163.4,11.38) 163.14,11.13 163.14,7 165.9,4.24 178.29,4.24 179.61,5.56 179.61,18.64 190.96,29.98 190.96,41.23 188.78,43.4 v1(188.69,43.4)
  L8_IN3 w0.089: v1(151.22,19.58) 151.22,19.52 146.86,15.17 144.92,15.17 140.75,11 140.75,8.48 139.21,6.94 137.82,6.94 136.88,6 125.3,6 124.69,5.39 119.04,5.39 117.8,4.15 110.04,4.15 109.38,3.49 99.28,3.49 98.71,4.06 87.37,4.06 81.46,9.98 81.46,12.66 80.26,13.86 80.26,32.43 77.88,34.81 76.59,34.81 76.4,34.62 75.75,34.62 75.35,34.22 59.68,34.22 54.33,39.57 47.33,39.57 46.49,40.41 34.97,40.41 33.87,39.31 33.87,38.65 33.64,38.41 32.29,38.41 30.73,39.98 27.1,39.98 26.25,39.12 12.82,39.12 10.4,41.54 10.4,46.88 6.81,50.47 6.81,55.73 9.26,58.18 9.26,63.24 11.23,65.2 v1(11.23,67.16)
  BOTTOM w0.102: R3626.2 11.84,69.37 11.84,67.77 v1(11.23,67.16) ; v1(153.53,17.26) 153.33,17.45 153.15,17.45 151.22,19.38 v1(151.22,19.58) 151.22,23.28 149.22,25.28 149.22,25.77 147.84,27.16 U5.96
ID_DET_R: length 4.2
  BOTTOM w0.102: CN12.44 9.52,70.86 9.78,71.12 10.01,71.12 10.21,71.33 10.79,71.33 R3626.1 11.1,71.43 10.44,72.09 v3(10.44,72.49)
IFPAB_RSET: length 1
  TOP w0.102: G1.BD23 90.55,96.16 v6(90.24,95.85)
  BOTTOM w0.102: R202.2 90.24,95.84 v6(90.24,95.85)
IFPE_AUX_CK: length 134
  TOP w0.102: v1(94.39,86.04) G1.BK8 ; Q114.1 55.59,162.02 56.26,162.69 R493.2 56.72,163.86 v1(56.72,164.04)
  L6_IN2 w0.076: v1(94.39,86.04) 94.82,86.46 94.82,86.47 95.33,86.98 95.33,87.68 96.47,88.82 96.47,94.16 104.08,101.76 104.08,109.95 106.77,112.64 106.77,126.11 108.75,128.09 108.75,144.05 99.15,153.65 87.65,153.65 84.01,157.29 83.02,157.29 80.32,159.99 80.32,160.97 74.15,167.15 61.23,167.15 59.47,165.4 55.82,165.4 55.45,165.02 55.45,164.04 55.83,163.66 56.34,163.66 v1(56.72,164.04)
IFPE_AUX_DATA: length 140.3
  TOP w0.102: v1(53.29,163.66) 53.16,163.53 53.16,159.21 53.67,158.7 R489.2 54.29,159.15 Q114.4 ; G1.BL8 v1(95.11,86.02)
  L6_IN2 w0.076: v1(95.11,86.02) 95,86.13 95,86.24 95.62,86.86 95.62,87.56 96.76,88.7 96.76,94.03 104.37,101.64 104.37,109.83 107.06,112.52 107.06,125.99 109.04,127.97 109.04,144.17 99.27,153.94 87.77,153.94 84.13,157.58 83.14,157.58 80.62,160.11 80.62,161.09 74.27,167.44 61.1,167.44 59.35,165.69 55.7,165.69 55.15,165.14 55.16,164.83 55.16,164.13 54.69,163.66 v1(53.29,163.66)
IFPEF_RSET: length 1.2
  TOP w0.102: G1.BD17 90.55,91.97 v1(90.23,91.65)
  BOTTOM w0.089: v1(90.23,91.65) 90.35,91.77 R165.2
ILIM: length 5.3
  TOP w0.203: R3329.2 R3328.1 C3576.2 C3580.2 62.74,44.17 63.7,44.17 63.9,43.97 U97.21
INT_SERIRQ: length 60.1
  TOP w0.089: U28.AW35 v2(122.99,18.92)
  L6_IN2 w0.089: v1(157.68,24.37) 157.68,24.34 157.28,23.94 155.2,23.94 154.93,24.21 152.22,24.21 151.71,23.7 148.93,23.7 146.24,21.01 145.35,21.01 144.7,20.35 144.7,19.46 144.29,19.06 144.29,16.2 141.58,13.49 134.57,13.49 133.37,14.68 132.03,14.68 131.22,15.5 128.45,15.5 127.92,14.97 126.95,14.97 126.47,15.45 125.88,15.45 124.41,16.92 124.41,17.5 124.15,17.75 124.15,18.11 123.39,18.88 123.03,18.88 v2(122.99,18.92)
  BOTTOM w0.102: C214.1 165.33,25.51 U5.5 159.94,25.51 158.8,24.37 v1(157.68,24.37) ; R338.1 122.76,12.98 122.76,14.84 122.99,15.07 122.99,15.73 122.63,16.08 122.63,17.27 122.75,17.39 122.75,18.68 v2(122.99,18.92)
ISEN1_NVD: length 1.9
  TOP w0.254: R979.2 22.22,115.52 U722.15
ISEN2_NVD: length 2.2
  TOP w0.254: R984.2 22.68,114 22.3,114.38 22.3,114.63 21.92,115.01 U722.14
ISEN3_NVD: length 2.5
  TOP w0.254: R985.2 22.33,113.13 21.74,113.72 21.74,114.25 21.49,114.51 U722.13
ISOLATEB: length 5.5
  TOP w0.102: R1921.2 94.18,44.83 94.18,45.49 R1908.2 94.69,46 94.69,47.32 94.36,47.65 R1936.1 94.24,47.71 U1901.20
IST_TRIG_CPU: length 5.3
  TOP w0.076: U26.E3 124.14,105.35 123.21,104.42 122.76,104.42 121.88,103.53 120.66,103.53
  TOP w0.102: TP13.1 120.01,103.53 120.66,103.53
ITP_PMODE_PCH: length 6.5
  TOP w0.076: U28.AL3 106.52,23.32 106.37,23.32 106.16,23.54 103.96,23.54
  TOP w0.102: 103.96,23.54 103.33,23.54 103.21,23.42 100.76,23.42 TP37.1
JACK_HP_L: length 12.4
  TOP w0.203: v1(14.05,58.12) 14.1,58.17 C195.1 15.67,58.17 AR12.1
  BOTTOM w0.203: v1(14.05,58.12) 14.65,58.12 v3(14.81,57.97) 15.06,57.71 15.06,54.94 13.52,53.4 9.05,53.4 CN12.9
JACK_HP_R: length 10.5
  TOP w0.203: AR11.1 15.67,57.31 C194.1 14.1,57.31 v1(14.05,57.36)
  BOTTOM w0.203: CN12.10 13.33,53.86 14.43,54.95 v3(14.43,55.58) 14.6,55.76 14.6,57.13 14.4,57.34 14.18,57.34 14.16,57.36 v1(14.05,57.36)
JACK_MIC1_L: length 15
  TOP w0.203: AR8.1 15.82,58.88 v1(15.82,58.88) 17.27,58.88 AR13.1
  BOTTOM w0.203: v1(15.82,58.88) 15.72,58.78 15.72,56.59 v3(15.7,56.57) 15.72,56.54 15.72,54.71 13.87,52.86 CN12.8
JACK_MIC1_R: length 15.9
  TOP w0.203: AR14.1 17.22,60.15 16.46,59.39 v1(16.33,59.39) 16.08,59.39 15.65,59.82 AR9.1
  BOTTOM w0.203: v1(16.33,59.39) 16.33,58.19 v3(16.31,58.17) 16.31,54.66 14,52.36 CN12.7
JDREF_CODEC: length 2.1
  TOP w0.203: U7.19 23.12,63.4 22.91,63.6 22.81,63.6 AR6.1
JTAG_TCK_PCH: length 3.7
  TOP w0.076: 103.96,24.59 104.42,24.13 106.8,24.13 106.93,24 U28.AJ3
  TOP w0.102: 103.96,24.59 103.83,24.72 103.71,24.72 TP26.1
JTAG_TDI_PCH: length 4.3
  TOP w0.076: 103.96,25.61 104.47,25.1 104.47,24.88 104.84,24.51 105.18,24.51 105.23,24.46 106.2,24.46 U28.AH2
  TOP w0.102: 103.96,25.61 103.58,25.99 103.4,25.99 R291.1
JTAG_TDO_PCH: length 4.6
  TOP w0.076: 104.89,24.31 104.9,24.3 104.97,24.3 104.98,24.29 106.37,24.29 106.54,24.47 106.68,24.47
  TOP w0.089: 106.68,24.47 U28.AH3
  TOP w0.102: R298.1 103.58,25.61 104.22,24.97 104.22,24.75 104.66,24.31 104.89,24.31
JTAG_TMS_PCH: length 5.1
  TOP w0.076: U28.AJ4 107.36,24.09 107.07,23.8 106.8,23.8 106.69,23.91 104.39,23.91 103.96,24.34
  TOP w0.102: R292.1 103.28,24.34 103.96,24.34
KEY_OUT0: length 36.8
  TOP w0.102: v1(134.44,1.22) 134.26,1.4 CNKB1.1
  L6_IN2 w0.089: v1(156.12,4.87) 155.17,3.91 153.75,3.91 151.76,1.93 134.7,1.93 134.44,1.68 v1(134.44,1.22)
  BOTTOM w0.102: v1(156.12,4.87) 158.47,7.22 158.47,8.8 159.49,9.82 159.49,10.44 v3(159.97,10.93) 160.02,10.97 U5.36
KEY_OUT1: length 36.5
  TOP w0.102: CNKB1.2 v1(133.76,1.27)
  L6_IN2 w0.089: v1(155.52,4.91) 154.74,4.12 153.46,4.12 151.48,2.14 134.59,2.14 133.76,1.3 v1(133.76,1.27)
  BOTTOM w0.102: U5.37 159.62,12.3 159.28,11.97 159.28,10.95 158.44,10.11 v3(158.44,9.6) 158.19,9.35 158.19,7.57 v1(155.52,4.91)
KEY_OUT2: length 35.9
  TOP w0.102: CNKB1.3 v1(133.26,1.64)
  L6_IN2 w0.089: v1(155.52,5.54) 154.33,4.35 153.4,4.35 151.4,2.34 133.96,2.34 v1(133.26,1.64)
  BOTTOM w0.102: v1(155.52,5.54) 157.66,7.67 v3(157.66,7.95) 157.66,9.83 159.08,11.26 159.08,12.14 159.22,12.28 U5.38
KEY_OUT3: length 38.3
  TOP w0.102: CNKB1.7 v1(131.26,1.35)
  L6_IN2 w0.089: v1(155.52,6.18) 154.43,6.18 153.47,5.21 153.47,4.69 151.31,2.54 132.17,2.54 131.26,1.63 v1(131.26,1.35)
  BOTTOM w0.102: v1(155.52,6.18) 156.36,7.01 v3(156.36,7.29) 156.77,7.7 156.77,9.23 158.82,11.28 U5.39
KEY_OUT4: length 38.1
  TOP w0.102: CNKB1.9 130.26,3.12 130.5,2.87 v1(130.5,1.35)
  L6_IN2 w0.089: v1(130.5,1.35) 130.5,1.6 131.65,2.75 150.95,2.75 v1(152.73,4.52)
  BOTTOM w0.102: v1(152.73,4.52) 152.91,4.52 154.96,6.58 v3(154.96,6.66) 154.96,6.84 156.56,8.44 156.56,9.32 158.42,11.17 U5.40
KEY_OUT5: length 38.1
  TOP w0.102: v1(129.87,1.35) 129.76,1.46 CNKB1.10
  L6_IN2 w0.089: v1(129.87,1.35) 129.87,1.68 131.14,2.95 150.52,2.95 v1(152.73,5.16)
  BOTTOM w0.102: v1(152.73,5.16) 153.49,5.92 v3(153.49,6.02) 156.36,8.89 156.36,9.61 158.02,11.27 U5.41
KEY_OUT6: length 39
  TOP w0.102: v1(129.23,1.35) 129.23,2.49 128.26,3.47 CNKB1.13
  L6_IN2 w0.089: v1(129.23,1.35) 129.23,1.73 130.66,3.15 150.09,3.15 v1(152.73,5.79)
  BOTTOM w0.102: v1(152.73,5.79) 152.73,6.27 153.07,6.61 153.77,6.61 155.78,8.61 v3(155.78,9.12) 155.78,9.32 157.62,11.15 U5.42
KEY_OUT7: length 39.3
  TOP w0.102: CNKB1.16 126.76,4.28 128.6,2.44 v1(128.6,1.35)
  L6_IN2 w0.089: v1(150.7,4.52) 149.53,3.36 130.57,3.36 128.6,1.38 v1(128.6,1.35)
  BOTTOM w0.102: U5.43 157.22,11.39 154.51,8.68 v3(154.51,8.13) 154.51,7.85 153.47,6.81 152.98,6.81 152.32,6.15 152.32,5.67 151.18,4.52 v1(150.7,4.52)
KEY_OUT8: length 38.9
  TOP w0.102: v1(128.04,1.35) 128.04,2.29 126.26,4.07 CNKB1.17
  L6_IN2 w0.089: v1(128.04,1.35) 128.04,1.36 130.24,3.56 149.1,3.56 v1(150.7,5.16)
  BOTTOM w0.102: U5.44 156.82,11.28 153.82,8.28 153.82,7.98 v3(151.59,5.74) 151,5.16 v1(150.7,5.16)
KEY_OUT9: length 39
  TOP w0.102: v1(127.48,1.38) 127.48,2.47 125.76,4.19 CNKB1.18
  L6_IN2 w0.089: v1(150.7,5.79) 148.67,3.76 129.87,3.76 v1(127.48,1.38)
  BOTTOM w0.102: U5.45 156.42,11.16 153.62,8.37 153.62,8.06 152.67,7.11 v3(152.1,7.11) 152.01,7.11 v1(150.7,5.79)
KEY_OUT10: length 39
  TOP w0.102: v1(126.88,1.41) 126.88,2.66 125.26,4.28 CNKB1.19
  L6_IN2 w0.089: v1(126.88,1.41) 126.95,1.41 129.51,3.97 148.23,3.97 v1(149.55,5.29)
  BOTTOM w0.102: U5.46 156.02,11.16 153.06,8.21 v3(153.01,8.21) 152.55,7.75 152.02,7.75 v1(149.55,5.29)
KEY_OUT11: length 38.4
  TOP w0.102: CNKB1.20 124.76,4.28 126.31,2.73 v1(126.31,1.35)
  L6_IN2 w0.089: v1(149.55,5.92) 147.8,4.17 129.07,4.17 126.31,1.41 v1(126.31,1.35)
  BOTTOM w0.102: U5.51 154.02,9.98 v3(153.69,9.66) 153.64,9.66 150.79,6.81 v3(150.29,6.81) 150.29,6.66 v1(149.55,5.92)
KEY_OUT12: length 37.1
  TOP w0.102: v1(124.79,2.87) 124.79,3 124.26,3.53 CNKB1.21
  L6_IN2 w0.089: v1(124.79,2.87) 124.79,3.51 125.65,4.37 147.37,4.37 v1(149.55,6.56)
  BOTTOM w0.102: v1(149.55,6.56) 149.55,6.91 150.19,7.55 150.62,7.55 v3(151.59,8.51) 151.59,8.92 153.62,10.95 U5.52
KEY_OUT13: length 36.9
  TOP w0.102: v1(124.23,2.87) 124.23,3.18 123.76,3.65 CNKB1.22
  L6_IN2 w0.089: v1(124.23,2.87) 124.23,3.52 125.29,4.58 146.81,4.58 v1(148.03,5.79)
  BOTTOM w0.102: v1(148.03,5.79) 148.33,5.79 v3(148.74,6.2) 148.74,6.4 153.22,10.88 U5.53
KEY_OUT14: length 37.1
  TOP w0.102: CNKB1.23 123.26,3.51 123.67,3.1 v1(123.67,2.87)
  L6_IN2 w0.089: v1(123.67,2.87) 123.67,3.41 125.04,4.78 146.38,4.78 v1(148.03,6.43)
  BOTTOM w0.102: U5.54 152.82,10.78 150.34,8.31 v3(149.63,8.31) 149.63,8.09 148.28,6.74 148.28,6.68 v1(148.03,6.43)
KEY_OUT15: length 37
  TOP w0.102: v1(123.01,2.87) 123.01,3.38 122.76,3.63 CNKB1.24
  L6_IN2 w0.089: v1(123.01,2.87) 123.01,3.31 124.68,4.98 145.95,4.98 v1(148.03,7.06)
  BOTTOM w0.102: v1(148.03,7.06) 149.07,8.11 149.07,8.72 149.4,9.05 149.96,9.05 v3(150.52,9.6) 152.42,11.5 U5.55
KEYIN0: length 23.2
  TOP w0.102: CNKB1.4 132.76,5.13 132.92,5.29 v1(132.92,5.38)
  BOTTOM w0.102: v1(132.92,5.38) 134.52,6.99 140.78,6.99 141.26,7.47 145.67,7.47 v3(147.73,9.53) 148.82,10.62 150.06,10.62 151.22,11.77 U5.58
KEYIN1: length 23.8
  TOP w0.102: CNKB1.5 132.26,5.26 132.28,5.29 v1(132.28,5.38)
  BOTTOM w0.102: v1(132.28,5.38) 134.09,7.19 140.69,7.19 141.17,7.67 145.58,7.67 146.28,8.37 v3(146.28,8.97) 148.13,10.82 149.88,10.82 150.82,11.76 150.82,13.15 U5.59
KEYIN2: length 23.6
  TOP w0.102: v1(131.65,5.38) 131.65,5.29 131.76,5.17 CNKB1.6
  BOTTOM w0.102: U5.60 150.42,11.99 149.45,11.03 147.24,11.03 v3(146.66,10.44) 146.35,10.44 144.52,8.61 141.83,8.61 140.61,7.39 133.72,7.39 131.71,5.38 v1(131.65,5.38)
KEYIN3: length 24.4
  TOP w0.102: CNKB1.8 130.76,5.03 130.4,5.39 v1(130.38,5.39)
  BOTTOM w0.102: v1(130.38,5.39) 130.41,5.39 v3(130.99,5.97) 132.71,7.7 140.51,7.7 141.63,8.82 144.25,8.82 146.66,11.23 149.08,11.23 150.02,12.17 U5.61
KEYIN4: length 24.9
  TOP w0.102: CNKB1.11 129.26,5.06 129.49,5.29 v1(129.49,5.38)
  BOTTOM w0.102: v1(129.49,5.38) 131.53,7.42 v3(131.6,7.42) 132.13,7.95 140.28,7.95 141.55,9.22 144.36,9.22 146.57,11.43 148.9,11.43 149.62,12.14 U5.62
KEYIN5: length 25.3
  TOP w0.102: v1(128.85,5.38) 128.85,5.29 128.76,5.19 CNKB1.12
  BOTTOM w0.102: v1(128.85,5.38) 128.85,5.95 131.05,8.16 139.48,8.16 v3(140.42,9.09) 140.75,9.43 144.28,9.43 146.49,11.64 148.58,11.64 149.22,12.27 U5.63
KEYIN6: length 25.3
  TOP w0.102: CNKB1.14 127.76,5.18 v1(127.96,5.38)
  BOTTOM w0.102: U5.64 148.77,12.5 148.41,12.14 146.71,12.14 144.68,10.11 TP151.1 140.44,10.11 138.78,8.46 131.04,8.46 v1(127.96,5.38)
KEYIN7: length 24.6
  TOP w0.102: v1(127.33,5.38) 127.33,5.29 127.26,5.22 CNKB1.15
  BOTTOM w0.102: v1(127.33,5.38) 130.61,8.66 136.99,8.66 141.23,12.91 TP152.1 144.73,12.91 146.48,14.66 U5.65
LAN_ACT: length 2.6
  TOP w0.102: TP1903.1 97.64,50.6 97.2,51.04 U1901.27
LAN_EN: length 50.7
  TOP w0.076: v1(116.41,18.62) 116.41,18.24 116.79,17.86 117.55,17.86 117.92,17.49 U28.BB26
  TOP w0.102: R104.2 99.01,49.86 99.35,49.52 v1(99.35,49.25)
  L8_IN3 w0.089: v1(99.35,49.25) 99.35,48.37 99.94,47.79 99.94,42.03 98.13,40.22 98.13,36.8 96.6,35.28 96.6,27.13 101.8,21.93 105.88,21.93 106.99,20.82 106.99,20.61 107.22,20.38 110.28,20.38 111.19,19.47 113.85,19.47 114.7,18.62 115.01,18.62 115.31,18.92 116.11,18.92 v1(116.41,18.62)
LAN_HSON: length 2.1
  TOP w0.102: U1901.18 93.44,48.74 93.04,48.34 93.04,47.91 C266.1
LAN_HSOP: length 2.1
  TOP w0.102: C265.1 92.79,48.03 92.79,48.47 93.04,48.72 U1901.17
LAN_LINK: length 1.8
  TOP w0.102: R104.1 97.26,50.64 U1901.26
LAN_MDI0+: length 135.5
  TOP w0.102: v1(96.6,55.2) 96.6,54.84 95.84,54.08 U1901.1 ; LT2.8 87.15,162.06 87.43,161.77 87.43,161.22 87.32,161.12 v1(87.04,161.12)
  L3_IN1 w0.076: v1(96.6,55.2) 96.48,55.09 96.48,54.98 96.62,54.84 97.54,54.84 98.63,55.93 101.12,58.42 101.12,61.17 103.86,63.91 103.86,76.18 99.57,80.47 99.57,83.19 99.29,83.47 99.29,87.25 103.15,91.11 103.15,92.56 104.09,93.5 104.09,106.51 109.28,111.71 109.28,127.25 110.31,128.28 110.31,143.67 106.12,147.86 106.12,149.03 99.56,155.59 97.32,155.59 97.09,155.82 90.4,155.82 87.53,158.69 87.53,161.17 87.45,161.24 87.2,161.24 87.07,161.12 v1(87.04,161.12)
LAN_MDI0-: length 135.5
  TOP w0.102: v1(95.96,55.07) 95.96,54.82 95.44,54.29 U1901.2 ; LT2.9 88.15,161.94 87.86,161.65 87.86,161.22 87.96,161.12 v1(88.04,161.12)
  L3_IN1 w0.076: v1(95.96,55.07) 96.49,54.54 97.67,54.54 98.75,55.63 101.42,58.29 101.42,61.04 104.16,63.78 104.16,76.3 99.87,80.6 99.87,83.32 99.59,83.59 99.59,87.13 103.45,90.99 103.45,92.43 104.39,93.37 104.39,106.39 109.59,111.58 109.59,127.12 110.62,128.15 110.62,143.8 106.42,147.99 106.42,149.16 99.69,155.9 97.45,155.9 97.22,156.12 90.52,156.12 87.83,158.82 87.83,160.99 87.96,161.12 v1(88.04,161.12)
LAN_MDI1+: length 135.8
  TOP w0.102: U1901.4 94.64,54.58 v1(94.69,54.64) ; LT2.11 90.15,161.98 90.43,161.69 90.43,161.28 90.33,161.18 90.12,161.18 v1(90.06,161.24)
  L3_IN1 w0.076: v1(94.69,54.64) 94.54,54.49 94.54,54.1 95.02,53.62 98.08,53.62 100.8,56.34 102.56,56.34 105,58.78 105,76.65 104.29,77.36 104.29,92.09 105.23,93.03 105.23,106 111.1,111.86 111.1,127.44 111.71,128.04 111.71,143.89 107.26,148.34 107.26,149.51 99.01,157.76 91.68,157.76 90.48,158.96 90.48,161.44 90.41,161.52 90.13,161.52 90.06,161.44 v1(90.06,161.24)
LAN_MDI1-: length 135.8
  TOP w0.102: LT2.12 91.15,162.02 90.86,161.73 90.86,161.39 90.99,161.26 v1(91.04,161.26) ; v1(94.08,54.64) 94.24,54.48 U1901.5
  L3_IN1 w0.076: v1(94.08,54.64) 94.23,54.49 94.23,53.98 94.89,53.32 98.21,53.32 100.93,56.04 102.69,56.04 105.31,58.65 105.31,76.78 104.6,77.49 104.6,91.96 105.54,92.9 105.54,105.87 111.4,111.74 111.4,127.31 112.01,127.92 112.01,144.02 107.57,148.46 107.57,149.63 99.13,158.07 91.8,158.07 90.79,159.08 90.79,161.02 91.02,161.26 v1(91.04,161.26)
