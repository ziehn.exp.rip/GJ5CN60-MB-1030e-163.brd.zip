# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AUDIO_CLK: length 124
  TOP w0.102: v1(100.02,25.61) 99.64,25.23 99.64,22.56 100.53,21.67 R289.1 ; v1(125.9,123.74) 125.9,123.73 125.57,123.4 U26.G27
  L3_IN1 w0.089: v1(100.02,25.61) 100.02,25.96 100.41,26.34 102.23,26.34 106.63,30.74 109.34,30.74 110.35,31.75 111.1,31.75 111.63,32.29 111.63,32.44 112.8,33.61 112.8,36.4 115.41,39.02 115.41,58.22 111.72,61.9 111.72,82.35 110.84,83.23 110.84,88.37 112.3,89.83 112.3,103.92 119.2,110.82 119.2,118.9 121.36,121.06 121.36,121.49 122.88,123.02 124.41,123.02 124.67,123.28 124.81,123.28 125.27,123.74 v1(125.9,123.74)
PCH_AUDIO_CLK_R: length 3.6
  TOP w0.076: U28.AM3 106.59,22.27 106.35,22.03 105.97,22.03 105.74,21.8 103.96,21.8
  TOP w0.102: R289.2 103.53,21.8 103.96,21.8
PCH_AUDIO_SDI: length 126.2
  TOP w0.076: U28.AN3 106.26,21.8 105.61,21.16 103.96,21.16
  TOP w0.102: v1(99.52,26.11) 99.21,25.8 99.21,22.45 100.27,21.39 101.97,21.39 102.2,21.16 103.96,21.16
  L3_IN1 w0.089: v1(120.88,122.48) 120.88,121.72 118.85,119.69 118.85,110.98 111.94,104.07 111.94,89.98 110.47,88.51 110.47,83.31 111.36,82.42 111.36,61.75 115.05,58.06 115.05,39.29 112.51,36.75 112.51,33.75 111.38,32.62 111.38,32.41 111.07,32.11 110.37,32.11 109.21,30.95 106.54,30.95 102.25,26.65 100.06,26.65 v1(99.52,26.11)
  BOTTOM w0.102: v1(120.88,122.48) 120.88,122.66 121.23,123.02 R7.1
PCH_AUDIO_SDO: length 123.1
  TOP w0.076: v1(125.24,121.35) 125.57,121.68 U26.G25
  TOP w0.102: R166.1 101.85,21.92 100.93,21.92 100.15,22.7 100.15,24.61 100.51,24.97 101.17,24.97 v1(101.29,25.1)
  L3_IN1 w0.089: v1(125.24,121.35) 125.24,121.55 124.15,122.63 123.14,122.63 122,121.49 122,121.09 119.71,118.8 119.71,110.82 112.66,103.77 112.66,89.68 111.08,88.09 111.08,83.28 112.09,82.27 112.09,62.06 115.78,58.37 115.78,38.44 114.88,37.54 114.88,33.61 113.36,32.08 113.36,31.79 112.41,30.84 111.96,30.84 109.83,28.71 104.88,28.71 101.29,25.12 v1(101.29,25.1)
PCH_AUDIO_SDO_R: length 3.1
  TOP w0.076: 103.96,22.16 105.72,22.16 105.86,22.3 U28.AM2
  TOP w0.102: 103.96,22.16 103.8,22.16 R166.2
PCH_BL_EN: length 211.2
  TOP w0.089: 130.35,20.25 129.4,19.3 129.2,19.3 129.04,19.45 128.49,19.45 128.41,19.37 127.98,19.37 U28.AV46
  TOP w0.102: v1(131.27,20.78) 130.89,20.78 130.35,20.25
  L3_IN1 w0.089: v1(138,48.97) 138.63,48.34 138.63,35.26 139.9,33.99 v1(139.9,25.99)
  L6_IN2 w0.089: v1(139.9,25.99) 139.9,24.46 138.11,22.67 135.13,22.67 132.83,20.36 131.56,20.36 131.27,20.65 v1(131.27,20.78)
  L8_IN3 w0.102: v1(86.51,156.64) 86.51,156.24 86.97,155.78 102.26,155.78 105.8,152.24 105.8,130.89 105.12,130.2 105.12,110.05 103.63,108.56 103.63,101.04 100.47,97.87 100.47,90.69 97.38,87.6 97.38,83.18 98.16,82.39 98.16,80.51 100.95,77.71 100.95,70.65 103.58,68.02 103.58,65.23 102.6,64.25 102.6,60.95 103.3,60.25 103.3,60.18 v1(103.33,60.15)
  BOTTOM w0.102: U29.2 85.27,155.4 v1(86.51,156.64) ; U5.94 146.57,26.31 145.62,27.26 141.17,27.26 v1(139.9,25.99) ; v1(103.33,60.15) 103.73,59.74 104.22,59.74 104.49,60.02 105.97,60.02 107.76,58.22 127.92,58.22 137.17,48.97 v1(138,48.97)
PCH_BL_PWM: length 213.6
  TOP w0.089: v1(129.87,20.73) 129.82,20.78 129.52,20.78 128.87,20.13 U28.AU48
  L3_IN1 w0.089: v1(135.71,48.09) 133.41,45.79 133.41,26.99 130.76,24.34 130,24.34 129.49,23.83 129.49,22.3 129.87,21.92 v1(129.87,20.73)
  L8_IN3 w0.102: v1(100.47,58.44) 100.16,58.74 100.16,62.42 97.95,64.64 97.95,69.66 100.52,72.23 100.52,77.53 97.64,80.41 97.64,82.29 96.94,83 96.94,87.88 100.04,90.97 100.04,98.05 103.2,101.22 103.2,108.74 104.69,110.23 104.69,130.38 105.37,131.07 105.37,152.06 103.08,154.34 69.13,154.34 67.82,155.65 v1(67.82,156.21)
  BOTTOM w0.102: v1(67.82,156.21) 67.82,155.1 67.97,154.94 R1022.1 ; v1(100.47,58.44) 100.53,58.37 101.26,58.37 102.03,57.61 106.36,57.61 107.17,56.8 127.25,56.8 135.71,48.34 v1(135.71,48.09)
PCH_BM_BUSY#: length 4
  TOP w0.089: U28.BF36 123.14,15.5 123.09,15.45 123.09,15.45 123.08,15.43 123.08,15.24 122.62,14.79 122.62,13.66 122,13.04 v1(121.94,13.04)
  BOTTOM w0.102: TP28.1 121.94,12.45 v1(121.94,13.04)
PCH_EXT_PWR_GATE#: length 1.5
  TOP w0.089: U28.AP41 v2(125.46,20.85)
  BOTTOM w0.102: v2(125.46,20.85) 125.17,21.15 TP27.1
PCH_JTAGX: length 4.3
  TOP w0.076: 103.96,26.5 104.2,26.5 105.34,25.35 105.41,25.35 106.05,24.72 106.88,24.72 107.05,24.55 U28.AH4
  TOP w0.102: TP51.1 103.96,26.5
PCH_LAN_WAKE#: length 80.5
  TOP w0.076: 127.48,13.41 127.48,14.28 126.95,14.81 U28.BG44
  TOP w0.102: v1(99.03,44.48) 99.08,44.48 99.14,44.53 103.2,44.53 Q68.D ; v1(126.69,10.24) 126.66,10.24 126.24,10.66 126.24,11.31 126.69,11.76 R288.2 126.69,12.36 127.48,13.15 127.48,13.41 ; Q105.D 97.81,21.75 97.81,23.63 v1(97.94,23.75)
  L8_IN3 w0.089: v1(99.03,44.48) 98.98,44.48 98.58,44.88 98.09,44.88 97.72,44.51 97.72,36.97 96.2,35.45 96.2,26.96 97.94,25.21 v1(97.94,23.75) 99.14,23.75 101.52,21.36 101.52,20.62 101.89,20.25 102.22,20.25 103.29,21.32 105.63,21.32 106.38,20.57 106.38,20.36 106.97,19.77 109.92,19.77 110.95,18.75 113.49,18.75 113.82,18.41 113.82,15.66 113.06,14.9 113.06,13.03 113.55,12.54 116.75,9.35 118.53,9.35 119.4,10.21 122.99,10.21 123.39,10.62 126.31,10.62 v1(126.69,10.24)
PCH_LANPHYPWR: length 4
  TOP w0.076: 125.4,13.41 125.4,13.42 125.29,13.54 125.29,15.31 125.33,15.36 U28.BF41
  TOP w0.102: 125.4,13.41 125.4,11.79 TP33.1
PCH_PCIE_WAKE#: length 8.2
  TOP w0.076: 131.14,15.66 131.14,15.69 129.61,17.22 129.04,17.22 U28.BB47
  TOP w0.102: R290.1 133.17,11.94 133.17,12.65 132.41,13.41 132.41,14.39 131.14,15.66
PCH_PLTRST_PROC: length 196.3
  TOP w0.076: v1(108.02,25.33) 108.03,25.33 108.03,25.1 107.69,24.77 U28.AG5
  TOP w0.102: v1(176.22,128.83) 173.81,131.24 165.53,131.24 163.59,129.3 163.59,129.05 162.77,128.23 161.39,128.23 U26.BP35
  L3_IN1 w0.089: v1(176.22,128.83) 176.22,127.97 176.86,127.33 182.02,127.33 184.34,125.01 184.34,108.55 182.03,106.24 182.03,97.25 182.51,96.76 182.51,87.49 184.13,85.87 184.13,82.57 183.25,81.69 183.25,74.83 184.65,73.43 184.65,67.31 181.78,64.44 169.84,64.44 166.2,60.8 146.16,60.8 132.31,46.95 132.31,28.84 130.86,27.38 128.73,27.38 127.96,28.15 127.33,28.15 126.27,29.21 123.33,29.21 122.57,29.97 118.98,29.97 118.73,30.22 114.11,30.22 113.09,29.2 112.55,29.2 110.87,27.52 110.87,27.23 108.97,25.33 v1(108.02,25.33)
PCH_PM_SYNC: length 4.1
  TOP w0.076: v1(107.39,25.33) 107.24,25.18 U28.AF3
  BOTTOM w0.102: v1(107.39,25.33) 107.39,25.61 107.62,25.83 108.05,25.83 108.15,25.94 108.15,26.62 108.71,27.18 R91.2
PCH_PWROK: length 206.1
  TOP w0.089: U28.AY42 v2(126.08,17.92)
  TOP w0.102: R301.2 140.56,13.11 140.56,22.53 v1(140.54,22.56) ; U23.1 179.08,136.87 v1(178.64,136.43)
  L6_IN2 w0.089: v1(180.79,46.06) 180.77,46.05 179.98,46.05 178.81,44.88 178.81,33.99 176.51,31.69 164.3,31.69 161.8,34.19 154.96,34.19 154.09,33.32 154.09,32.62 152.15,30.69 149.98,30.69 143.76,24.46 142.32,24.46 140.54,22.69 v1(140.54,22.56) 138.34,20.36 135.12,20.36 133.04,18.28 128.91,18.28 128.06,17.43 128.04,17.43 128.04,17.43 127.67,17.43 127.35,17.12 127.35,16.81 127.23,16.69 126.28,16.69 126.19,16.78 126.19,17.82 v2(126.08,17.92)
  L8_IN3 w0.089: v1(180.79,46.06) 180.8,46.08 180.8,46.19 182.3,47.7 182.3,62.12 187.11,66.93 187.11,76.64 185.97,77.78 185.97,97.98 190.8,102.82 190.8,104.76 191.7,105.66 191.7,107.04 192.32,107.66 192.32,130.87 186.85,136.34 186.76,136.43 v1(178.64,136.43)
  BOTTOM w0.102: v2(126.08,17.92) 126.19,17.82 126.19,16.64 R249.2 ; U5.86 146.47,23.11 146.25,23.32 145.62,23.32 144.68,22.38 140.71,22.38 v1(140.54,22.56)
PCH_SMB_CLK: length 115.4
  TOP w0.076: U28.BE26 118.24,15.94 118.29,15.9 118.29,15.57 118.6,15.25 118.6,14.72 118.9,14.42 118.9,13.85 118.57,13.51 118.57,13.41
  TOP w0.102: v1(100.05,58.02) 100.34,57.72 Q109.6 ; v1(118.9,8.31) 118.9,9.11 119.12,9.34 119.12,11.33 119.05,11.41 119.05,12.45 118.64,12.86 R287.1 118.57,13.41
  L6_IN2 w0.089: v1(118.9,8.31) 118.32,7.73 117.75,7.73 113.31,12.18 109.7,12.18 106.13,8.61 103.51,8.61 101.86,6.96 100.38,6.96 98.88,8.46 96.79,8.46 96.59,8.26 87.87,8.26 85.31,10.82 85.31,16.89 83.82,18.38 83.82,22.67 83.7,22.78 83.7,35.99 78.71,40.99 78.71,42 78.05,42.66 78.05,45.38 83.78,51.11 85.17,51.11 85.56,51.5 85.56,52.71 89.45,56.59 90.5,56.59 92.33,58.43 99.64,58.43 v1(100.05,58.02)
PCH_SMB_CLK_DDR: length 136.8
  TOP w0.102: Q109.1 98.87,56.99 ; 98.87,56.99 98.9,56.99 99.47,57.56 R264.2 99.47,58.32 99.99,58.84 101.08,58.84 101.29,58.63 106.63,58.63 108.88,60.87 108.88,64.63 111.95,67.71 111.95,72.17 111.95,72.18 111.95,72.7 113.38,74.12 v1(114.84,74.12) 116.15,75.42 CN11.253 ; 98.87,56.99 99.39,56.47 99.39,55.85 v1(99.52,55.72) ; v1(114.11,86.54) 115.17,86.54 116.15,87.51 CN1.253 ; L51.2 150.55,14.03 151.08,14.56 v1(151.08,14.81)
  L3_IN1 w0.089: v1(151.08,14.81) 149.48,16.41 149.48,20.82 148.94,21.36 148.94,23.65 144.27,28.32 144.27,33.27 141.73,35.81 141.73,45.88 v1(141.05,46.56)
  L8_IN3 w0.089: v1(114.84,74.12) 114.84,74.69 113.51,76.03 113.51,82.91 114.65,84.04 114.65,85.91 114.11,86.45 v1(114.11,86.54)
  BOTTOM w0.102: v1(141.05,46.56) 140.84,46.76 134.89,46.76 130.78,50.87 130.78,51.87 126.67,55.98 106.82,55.98 106.01,56.8 102.96,56.8 102.33,56.16 100,56.16 99.56,55.72 v1(99.52,55.72)
PCH_SMB_DATA: length 110.1
  TOP w0.076: U28.BF26 118.08,15.61 118.08,15.54 118.44,15.18 118.44,14.65 118.74,14.36 118.74,13.92 118.24,13.41
  TOP w0.102: Q109.3 98.03,55.69 97.1,56.62 v1(97.1,57.48) ; v1(118.05,8.34) 118.05,8.76 118.79,9.5 118.79,10.32 118.13,10.98 118.13,12.37 117.68,12.83 R135.1 118.24,13.41
  L6_IN2 w0.089: v1(97.1,57.48) 97.1,57.52 96.63,57.99 92.65,57.99 90.89,56.24 89.69,56.24 85.77,52.32 85.77,51.41 85.26,50.9 84.07,50.9 80.23,47.07 80.23,42.91 80.21,42.88 80.21,39.78 83.91,36.08 83.91,22.93 84.05,22.79 84.05,18.44 85.53,16.96 85.53,10.89 87.96,8.46 96.5,8.46 96.71,8.66 98.97,8.66 100.46,7.17 101.78,7.17 103.42,8.81 106.04,8.81 109.61,12.38 113.39,12.38 117.43,8.34 v1(118.05,8.34)
PCH_SMB_DATA_DDR: length 120.6
  TOP w0.102: v1(116.77,78.83) 116.12,79.49 116.12,79.99 116.09,80.02 116.09,80.07 115.9,80.27 CN1.254 ; v1(151.71,14.81) 151.35,14.45 L51.3 ; v1(118.01,73.69) 115.9,71.58 CN11.254 115.9,67.39 114.79,66.28 114.79,65.22 113.93,64.36 111.6,64.36 110.31,63.07 110.31,60.4 106.63,56.72 104.85,56.72 104.38,56.25 v1(104.38,56.12) 104.38,55.11 104.09,54.82 101.98,54.82 R266.1 101.11,55.69 Q109.4
  L3_IN1 w0.089: v1(141.68,46.56) 141.93,46.31 141.93,35.89 144.47,33.35 144.47,28.4 149.14,23.73 149.14,21.45 149.68,20.91 149.68,16.59 150.95,15.32 151.21,15.32 v1(151.71,14.81)
  L8_IN3 w0.089: v1(116.77,78.83) 117.34,78.27 117.34,74.36 v1(118.01,73.69)
  BOTTOM w0.102: v1(141.68,46.56) 141.27,46.15 140.88,46.15 140.47,46.56 134.69,46.56 130.5,50.75 130.5,51.77 126.52,55.76 106.76,55.76 105.92,56.59 104.71,56.59 104.38,56.26 v1(104.38,56.12)
PCH_SPI0_IO2: length 4.2
  TOP w0.076: U28.AY48 129.08,18.58 129.11,18.61 130.62,18.61 131.14,19.13
  TOP w0.102: R58.2 131.14,19.13
PCH_SPI0_IO3: length 5.5
  TOP w0.076: 131.14,18.11 130.98,18.28 129.24,18.28 129.08,18.11 128.09,18.11 127.88,17.9 U28.BA46
  TOP w0.102: 131.14,18.11 132.1,18.11 132.71,17.5 R74.2
PCH_SPI_CLK: length 2.9
  TOP w0.102: R71.1 136.09,29.98 U20.6
PCH_SPI_CLK_R: length 20.1
  TOP w0.089: U28.AW47 128.4,19.09 128.48,19.01 128.99,19.01 129.05,18.94 130.19,18.94 130.5,19.26 130.5,19.39 v1(130.63,19.52)
  TOP w0.102: v1(135.84,32.21) 136.07,32.21 136.47,31.8 R71.2
  L3_IN1 w0.089: v1(130.63,19.52) 130.63,20.98 131.52,21.87 133.27,21.87 135.08,23.68 135.08,30.43 135.84,31.19 v1(135.84,32.21)
PCH_SPI_CS0#: length 7.3
  TOP w0.076: 131.14,19.61 131.14,19.51 130.4,18.77 128.98,18.77 128.91,18.84 128.49,18.84 U28.AY47
  TOP w0.102: U20.1 133.55,20.15 133.17,19.76 131.29,19.76 131.14,19.61
PCH_SPI_HOLD#: length 16.5
  TOP w0.102: R59.1 v1(135.58,29.72) 134.82,28.96 134.82,27.59 ; v1(134.21,18.11) 134.21,17.5 134.06,17.35 R74.1
  L3_IN1 w0.089: v1(134.21,18.11) 134.31,18.21 134.31,22.05 135.58,23.32 v1(135.58,29.72)
PCH_SPI_SI: length 13.1
  TOP w0.076: v1(130.76,21.8) 130.89,21.92 131.14,21.92
  TOP w0.102: U20.5 137.36,25.99 135.33,23.96 133.04,23.96 132.41,23.32 132.41,22.81 131.52,21.92 131.14,21.92
  BOTTOM w0.102: R75.1 128.6,20.15 130,21.54 130.5,21.54 v1(130.76,21.8)
PCH_SPI_SI_R: length 3.6
  TOP w0.089: U28.AU41 125.46,19.55 v2(125.56,19.45)
  BOTTOM w0.102: R75.2 127.09,20.68 127.09,20.69 126.43,20.69 R72.1 126.06,19.95 v2(125.56,19.45)
PCH_SPI_SO: length 14.4
  TOP w0.102: 134.82,21.34 134.82,22.56 135.84,23.57 137.87,23.57 138.12,23.32 138.12,19.13 137.31,18.32 135.2,18.32 134.9,18.62 133.93,18.62 133.7,18.39 133.7,18.32 R57.1
PCH_SPI_SO_R: length 5.7
  TOP w0.076: U28.BA45 127.89,18.18 128.02,18.31 128.96,18.31 129.05,18.31 129.18,18.44 130.79,18.44 130.94,18.6 131.09,18.6 131.14,18.64
  TOP w0.102: R57.2 132.31,18.64 131.14,18.64
PCH_SPI_WP: length 4.7
  TOP w0.102: R58.1 135.63,19.13 R60.1 136.09,19.33 U20.3
PCH_SUSCLK: length 47.4
  TOP w0.076: 127.2,13.41 127.2,14.3 126.69,14.81 126.69,15.66 127.19,16.16 U28.BE45
  TOP w0.102: CNWLAN1.50 92.2,10.7 v1(92.29,10.8) ; 127.2,13.41 127.2,13.16 126.19,12.14 126.19,11.76 126.03,11.61 126.03,10.12 v1(126.06,10.09)
  L6_IN2 w0.089: v1(92.29,10.8) 93.36,11.86 96.06,11.86 97.99,13.8 108.36,13.8 109.05,14.48 112.88,14.48 113.99,15.59 119.35,15.59 120.12,14.83 120.12,14.53 120.36,14.28 120.36,13.39 120.73,13.03 120.91,13.03 121.8,12.14 122.59,12.14 124.65,10.09 v1(126.06,10.09)
PCH_THERMTRIP#: length 4.3
  TOP w0.076: U28.AD3 106.63,26.37 106.42,26.57 105.55,26.57 105.26,26.86 105.25,26.86 105.1,27 104.6,27 104.21,27.38 103.96,27.38
  TOP w0.102: 103.96,27.38 R94.2
PCH_VRALERT#: length 4.4
  TOP w0.076: 120.98,14.56 120.13,13.71 120.13,13.3
  TOP w0.089: 120.98,14.56 120.98,15.19 120.7,15.47 120.7,15.83 120.94,16.06 U28.BE32
  TOP w0.102: 120.13,13.3 119.63,12.8 TP31.1
PCH_WLANPWR: length 23.3
  TOP w0.076: v1(126.06,13.33) 125.98,13.41 125.93,13.41 125.68,13.67 125.68,14.87 125.62,14.93 125.62,15.17 125.77,15.33 125.77,16.15 125.96,16.34 U28.BD42
  BOTTOM w0.102: v1(126.06,13.33) 126.06,13.16 125.55,12.65 125.55,11.76 123.39,9.6 115.65,9.6 113.49,11.76 111.84,11.76 110.9,10.82 R258.1
PCH_XATL24_IN: length 12.7
  TOP w0.076: U28.U10 110.28,29.72 109.96,29.72 109.78,29.54 109.17,29.54 v1(109.12,29.49)
  BOTTOM w0.102: v1(109.12,29.49) 109.07,29.44 108.3,29.44 107.56,30.19 106.84,30.19 R352.1 106.53,29.87 105.31,29.87 C277.1 104.82,29.54 100.31,29.54 Y3.1
PCH_XCLK_BIASREF: length 4.5
  TOP w0.102: R340.2 105.05,29.11 105.99,30.05 106.32,30.05 U28.T3
PCH_XTAL24_OUT: length 4.7
  TOP w0.076: v1(108.53,29.92) 108.59,29.86 U28.U9
  BOTTOM w0.102: v1(108.53,29.92) 108.53,30.16 107.8,30.89 R352.2 106.35,31.17 105.97,31.17 R349.2
PCIE4_CLKN_MD2_SSD1: length 51.9
  TOP w0.102: v2(111.84,27.64) 111.99,27.64 112.22,27.4 112.22,27.18 U28.AC14
  TOP w0.114: CNSSD1.53 152.32,37.27 152.46,37.14 152.46,36.51 152.2,36.25 v2(152.11,36.25)
  L8_IN3 w0.102: v2(152.11,36.25) 152.47,35.89 152.47,35.38 151.99,34.9 138.5,34.9 136.49,32.9 135.55,32.9 135.2,32.54 133.47,32.54 131.67,30.75 131.67,29.88 131.43,29.64 130.4,29.64 129.44,28.68 128.91,28.68 128.53,29.06 125.04,29.06 124.61,29.49 123.34,29.49 122.86,29.97 122.72,29.97 121.26,31.42 121.06,31.42 120.33,32.16 117.85,32.16 116.58,30.89 115.52,30.89 115.29,30.66 114.18,30.66 112.99,29.47 112.99,29.13 112.09,28.22 112.09,27.89 v2(111.84,27.64)
PCIE4_CLKP_MD2_SSD1: length 51.9
  TOP w0.102: U28.AC15 112.63,26.95 112.42,27.16 112.42,27.61 v2(112.58,27.78)
  TOP w0.114: v2(153.04,36.25) 152.7,36.6 152.7,37.15 152.82,37.27 CNSSD1.55
  L8_IN3 w0.102: v2(153.04,36.25) 152.67,35.88 152.67,35.29 152.08,34.7 138.58,34.7 136.57,32.69 135.64,32.69 135.28,32.34 133.55,32.34 131.88,30.66 131.88,29.8 131.52,29.44 130.49,29.44 129.52,28.48 128.82,28.48 128.44,28.86 124.96,28.86 124.53,29.29 123.26,29.29 122.78,29.77 122.63,29.77 121.18,31.22 120.98,31.22 120.24,31.96 117.93,31.96 116.66,30.69 115.6,30.69 115.37,30.46 114.27,30.46 113.2,29.39 113.2,29.04 112.29,28.14 112.29,27.88 112.39,27.78 v2(112.58,27.78)
PCIE6_CLKN_MD2_SSD2: length 75.5
  TOP w0.114: v2(175.11,36.36) 175.45,36.7 175.45,36.91 175.45,37.2 175.32,37.32 CNSSD2.53 ; U28.AE14 v2(111.99,25.24)
  L8_IN3 w0.102: v2(175.11,36.36) 175.47,36 175.47,35.2 174.92,34.65 168.22,34.65 167.23,35.64 154.28,35.64 152.73,34.09 141.3,34.09 139.14,31.93 138.05,31.93 136.68,30.56 134.21,30.56 131.42,27.77 128.67,27.77 128.21,28.22 123.31,28.22 121.46,30.08 115.86,30.08 115.63,29.85 114.52,29.85 113.8,29.13 113.8,27.81 112.22,26.23 112.22,25.49 112.21,25.48 112.21,25.47 v2(111.99,25.24)
PCIE6_CLKP_MD2_SSD2: length 75.5
  TOP w0.114: U28.AE15 v2(112.75,25.24) ; v2(176.03,36.36) 175.69,36.7 175.69,36.81 175.69,37.2 175.82,37.32 CNSSD2.55
  L8_IN3 w0.102: v2(176.03,36.36) 175.67,36 175.67,35.11 175,34.45 168.14,34.45 167.15,35.44 154.36,35.44 152.81,33.89 141.38,33.89 139.22,31.73 138.13,31.73 136.76,30.36 134.3,30.36 131.5,27.56 128.59,27.56 128.13,28.02 123.23,28.02 121.38,29.87 115.94,29.87 115.71,29.64 114.6,29.64 114.01,29.05 114.01,27.73 112.42,26.14 112.42,25.57 v2(112.75,25.24)
PCIE9_RXN: length 48.4
  TOP w0.089: U28.G36 v2(123.34,34.5)
  TOP w0.114: v2(163.09,40.08) 163.45,39.73 163.45,39.2 163.32,39.08 CNSSD2.5
  L8_IN3 w0.102: v2(123.34,34.5) 123.23,34.88 123.04,34.99 123.04,35.4 124.37,36.73 125.11,36.73 127.96,39.58 133.38,39.58 135,41.2 144.96,41.2 145.82,40.34 149.25,40.34 150.77,38.81 162.93,38.81 163.32,39.2 163.32,39.86 v2(163.09,40.08)
PCIE9_RXP: length 48.4
  TOP w0.089: U28.F36 v2(123.72,35.16)
  TOP w0.114: v2(164.03,40.08) 163.69,39.74 163.69,39.2 163.82,39.08 CNSSD2.7
  L8_IN3 w0.102: v2(164.03,40.08) 163.85,40.08 163.52,39.75 163.52,39.12 163.02,38.61 150.69,38.61 149.17,40.14 145.74,40.14 144.87,41 135.09,41 133.46,39.37 128.04,39.37 125.2,36.53 124.46,36.53 123.25,35.32 123.25,35.11 123.33,35.06 v2(123.72,35.16)
PCIE9_TXN: length 44.1
  TOP w0.114: CNSSD2.11 164.82,39.08 164.95,39.2 164.95,40.31 v2(164.67,40.59)
  BOTTOM w0.114: v2(164.67,40.59) 164.77,40.59 165.09,40.91 165.09,41.23 164.32,42 149.01,42 147.99,40.97 133.17,40.97 128.68,45.47 127.52,45.47 127.41,45.35 C239.2
PCIE9_TXN_C: length 14.8
  TOP w0.076: 122.01,40.49 122.01,40.32 122.2,40.13 122.2,36.75 122.2,36.75 122.33,36.63 122.33,36.3 122.25,36.23 122.15,36.23 122.07,36.3 122.07,36.44 U28.C34
  TOP w0.114: v2(124.03,45.04) 124.1,45.11 124.1,45.34 123.98,45.46 122.43,45.46 122.01,45.04 122.01,40.49
  BOTTOM w0.114: C239.1 126.19,45.34 124.23,45.34 124.03,45.14 v2(124.03,45.04)
PCIE9_TXP: length 44.1
  TOP w0.114: v2(165.56,40.59) 165.19,40.23 165.19,39.2 165.32,39.08 CNSSD2.13
  BOTTOM w0.114: C223.2 127.62,45.71 128.78,45.71 133.27,41.21 147.89,41.21 148.91,42.24 164.42,42.24 165.33,41.33 165.33,40.82 v2(165.56,40.59)
PCIE9_TXP_C: length 14.8
  TOP w0.076: U28.D34 121.88,36.11 121.88,36.69 122.05,36.86 122.05,40.07 121.86,40.25 121.86,40.4 121.77,40.49
  TOP w0.114: v2(124.03,45.98) 123.75,45.7 122.33,45.7 121.77,45.14 121.77,40.49
  BOTTOM w0.114: C223.1 126.14,45.58 124.42,45.58 v2(124.03,45.98)
PCIE10_RXN: length 51.5
  TOP w0.089: U28.K37 v2(123.84,33.12)
  TOP w0.114: CNSSD2.17 166.32,37.27 166.45,37.14 166.45,36.68 v2(166.1,36.33)
  L8_IN3 w0.102: v2(123.84,33.12) 124.07,33.35 124.32,33.35 124.42,33.45 124.78,33.45 125.97,32.26 126.99,32.26 127.29,32.57 129.22,32.57 133.58,36.93 134.47,36.93 136.05,38.51 141.42,38.51 142.16,37.77 143.97,37.77 144.75,36.99 147.16,36.99 148.4,35.75 150.81,35.75 151.81,36.76 164.01,36.76 164.79,37.54 166.16,37.54 166.47,37.23 166.47,36.7 v2(166.1,36.33)
PCIE10_RXP: length 51.6
  TOP w0.089: v2(124.11,33.86) U28.J37
  TOP w0.114: v2(167.04,36.33) 166.69,36.68 166.69,37.14 166.82,37.27 CNSSD2.19
  L8_IN3 w0.102: v2(167.04,36.33) 166.67,36.7 166.67,37.32 166.24,37.75 164.71,37.75 163.92,36.96 151.73,36.96 150.72,35.95 148.48,35.95 147.24,37.19 144.84,37.19 144.05,37.98 142.24,37.98 141.51,38.71 135.96,38.71 134.39,37.14 133.5,37.14 129.13,32.77 127.21,32.77 126.9,32.46 126.05,32.46 124.86,33.66 124.31,33.66 v2(124.11,33.86)
PCIE10_TXN: length 48.2
  TOP w0.114: v2(167.33,40.39) 167.33,40.47 167.68,40.81 167.96,40.81 168.08,40.69 168.08,39.18 167.82,38.92 CNSSD2.23
  BOTTOM w0.114: C224.2 127.85,43.7 129.04,43.7 132.52,40.22 148.17,40.22 149.28,41.34 158.25,41.34 160.71,38.88 166,38.88 166.57,39.45 166.57,40.58 166.72,40.73 167,40.73 v2(167.33,40.39)
PCIE10_TXN_C: length 10.9
  TOP w0.076: U28.C35 122.68,36.47 122.68,37.61 122.63,37.66 122.63,40.43 122.67,40.47 122.67,40.49
  TOP w0.114: v2(124.26,43.21) 124.05,43.41 123.21,43.41 122.67,42.87 122.67,40.49
  BOTTOM w0.114: C224.1 126.17,43.58 124.63,43.58 v2(124.26,43.21)
PCIE10_TXP: length 48.2
  TOP w0.114: CNSSD2.25 168.32,40.79 168.06,41.05 167.48,41.05 v2(167.33,41.19)
  BOTTOM w0.114: C237.2 127.61,43.95 129.14,43.95 132.62,40.47 148.07,40.47 149.18,41.58 158.35,41.58 160.81,39.12 165.9,39.12 166.33,39.55 166.33,40.68 166.62,40.97 167.2,40.97 167.33,41.1 v2(167.33,41.19)
PCIE10_TXP_C: length 11
  TOP w0.076: U28.B35 122.53,37.02 122.53,37.54 122.47,37.6 122.47,40.43 122.43,40.47 122.43,40.49
  TOP w0.114: v2(124.2,44.05) 124.2,43.87 123.99,43.65 123.11,43.65 122.43,42.97 122.43,40.49
  BOTTOM w0.114: C237.1 126.17,43.83 124.32,43.83 124.2,43.95 v2(124.2,44.05)
PCIE11_RXN: length 53.9
  TOP w0.089: v2(124.55,34.67) 124.48,34.67 124.31,34.5 U28.G38
  TOP w0.114: CNSSD2.29 169.32,37.27 169.45,37.14 169.45,36.57 v2(169.1,36.22)
  L8_IN3 w0.102: v2(124.55,34.67) 124.85,34.67 125.13,34.95 125.4,34.95 125.91,35.46 125.91,36.38 128.29,38.76 133.72,38.76 135.34,40.39 144,40.39 145.58,38.81 149.62,38.81 150.44,38 150.97,38 150.99,37.98 163.5,37.98 164.29,38.76 168.37,38.76 169.39,37.74 169.39,36.51 v2(169.1,36.22)
PCIE11_RXP: length 53.9
  TOP w0.089: v2(124.92,35.39) 124.69,35.16 U28.F39
  TOP w0.114: CNSSD2.31 169.82,37.27 169.69,37.14 169.69,36.57 v2(170.04,36.22)
  L8_IN3 w0.102: v2(124.92,35.39) 125.14,35.16 125.31,35.16 125.7,35.55 125.7,36.46 128.21,38.97 133.63,38.97 135.26,40.59 144.09,40.59 145.66,39.02 149.71,39.02 150.52,38.2 151.05,38.2 151.08,38.18 163.42,38.18 164.2,38.97 168.45,38.97 169.59,37.82 169.59,36.66 v2(170.04,36.22)
PCIE11_TXN: length 49.9
  TOP w0.114: v2(170.31,40.12) 170.31,40.31 170.62,40.63 170.91,40.63 171.08,40.47 171.08,39.38 170.82,39.13 CNSSD2.35
  BOTTOM w0.114: C229.2 127.81,41.86 128.99,41.86 132.63,38.22 168.79,38.22 169.49,38.92 169.49,40.29 169.66,40.46 169.96,40.46 v2(170.31,40.12)
PCIE11_TXN_C: length 9.7
  TOP w0.076: 123.33,40.49 123.24,40.4 123.24,40.25 123.01,40.02 123.01,39.79 123.11,39.69 123.11,39.47 123.01,39.37 123.01,37.13 123.09,37.05 U28.B36
  TOP w0.114: 123.33,40.49 123.33,40.9 123.43,40.99 123.43,41.3 123.33,41.4 123.33,42.12 123.47,42.26 123.67,42.26 123.94,41.98 124.06,41.98 124.17,41.87 124.17,41.62 v2(124.1,41.55)
  BOTTOM w0.114: C229.1 126.12,41.98 124.53,41.98 v2(124.1,41.55)
PCIE11_TXP: length 49.9
  TOP w0.114: v2(170.31,41.04) 170.48,40.87 171.01,40.87 171.32,40.57 CNSSD2.37
  BOTTOM w0.114: v2(170.31,41.04) 169.97,40.7 169.56,40.7 169.25,40.39 169.25,39.02 168.69,38.46 132.73,38.46 129.09,42.1 127.81,42.1 C250.2
PCIE11_TXP_C: length 9.7
  TOP w0.076: 123.09,40.49 123.09,40.32 122.86,40.09 122.86,36.83 U28.C36
  TOP w0.114: v2(124.15,42.5) 123.37,42.5 123.09,42.22 123.09,40.49
  BOTTOM w0.114: v2(124.15,42.5) 124.43,42.22 126.36,42.22 C250.1
PCIE12_RXN: length 58.9
  TOP w0.089: U28.H42 126.08,34.68 v2(125.98,34.78)
  TOP w0.114: v2(173.04,36.34) 172.69,36.69 172.69,37.14 172.82,37.27 CNSSD2.43
  L8_IN3 w0.102: v2(125.98,34.78) 125.83,34.62 125.83,34.4 125.91,34.32 126.52,34.32 126.72,34.52 128.57,34.52 132.4,38.36 133.88,38.36 135.51,39.98 143.03,39.98 143.82,39.2 144.62,39.2 145.41,38.41 149.46,38.41 150.29,37.57 163.67,37.57 164.46,38.36 167.41,38.36 168.1,37.67 168.1,35.93 168.56,35.46 170.3,35.46 170.76,35.93 170.76,37.29 171.14,37.67 172.41,37.67 172.85,37.24 172.85,36.53 v2(173.04,36.34)
PCIE12_RXP: length 58.9
  TOP w0.089: U28.J41 125.37,34.44 v2(125.35,34.47)
  TOP w0.114: CNSSD2.41 172.32,37.27 172.45,37.14 172.45,36.69 v2(172.1,36.34)
  L8_IN3 w0.102: v2(125.35,34.47) 125.47,34.47 125.83,34.12 126.61,34.12 126.8,34.32 128.65,34.32 132.49,38.15 133.97,38.15 135.59,39.78 142.95,39.78 143.74,38.99 144.54,38.99 145.32,38.2 149.37,38.2 150.21,37.37 163.75,37.37 164.54,38.15 167.33,38.15 167.89,37.59 167.89,35.84 168.48,35.26 170.38,35.26 170.97,35.84 170.97,37.21 171.23,37.47 172.33,37.47 172.64,37.16 172.64,36.81 172.17,36.34 v2(172.1,36.34)
PCIE12_TXN: length 52.1
  TOP w0.114: v2(173.6,35.99) 173.95,36.34 173.95,37.2 173.82,37.32 CNSSD2.47
  BOTTOM w0.114: C235.2 128.08,40.33 129.16,40.33 131.93,37.56 173.84,37.56 174.1,37.29 174.1,36.36 173.74,35.99 v2(173.6,35.99)
PCIE12_TXN_C: length 8
  TOP w0.076: v2(124.15,39.7) 124.15,39.75 123.85,40.06 123.68,40.06 123.52,39.89 123.52,39.07 123.42,38.97 123.42,37.55 123.52,37.45 123.52,36.37 123.44,36.29 123.44,36.05 123.51,35.98 123.71,35.98 123.76,36.04 U28.D38
  BOTTOM w0.114: C235.1 126.56,39.75 126.3,40.01 126.29,40 124.55,40 124.26,39.7 v2(124.15,39.7)
PCIE12_TXP: length 52.1
  TOP w0.114: v2(174.54,35.99) 174.19,36.34 174.19,37.2 174.32,37.32 CNSSD2.49
  BOTTOM w0.114: C234.2 127.58,40.57 129.26,40.57 132.03,37.8 173.94,37.8 174.34,37.39 174.34,36.19 v2(174.54,35.99)
PCIE12_TXP_C: length 8.1
  TOP w0.076: U28.E37 123.29,35.98 123.29,36.35 123.37,36.43 123.37,37.38 123.26,37.49 123.26,39.03 123.37,39.13 123.37,39.96 123.62,40.21 124.03,40.21 124.13,40.31 v2(124.13,40.33)
  BOTTOM w0.114: v2(124.13,40.33) 124.23,40.24 126.19,40.24 C234.1
PCIE14_RXN: length 48.5
  TOP w0.076: v1(127.99,35.8) 128.02,35.84 U28.D46
  TOP w0.114: C266.2 93.04,46.49 93.04,46.04 v2(93.4,45.68)
  L3_IN1 w0.102: v2(93.4,45.68) 93.31,45.68 93.01,45.97 93.01,46.25 94.7,47.93 99.25,47.93 99.51,47.68 105.28,47.68 106.6,46.36 109.04,46.36 109.42,45.98 v2(109.42,45.84)
  BOTTOM w0.114: v2(109.42,45.84) 109.77,46.19 111.1,46.19 111.74,45.56 119.14,45.56 119.42,45.28 121.03,45.28 121.88,44.43 121.88,39.22 122.81,38.29 124.48,38.29 125.09,38.9 125.63,38.9 126.59,37.94 127.61,37.94 128.15,37.39 128.15,36.52 127.96,36.33 127.96,35.83 v1(127.99,35.8)
PCIE14_RXP: length 48.5
  TOP w0.076: U28.C47 128.41,36.21 v1(128.47,36.15)
  TOP w0.114: v2(92.59,45.68) 92.8,45.89 92.8,45.89 92.8,46.35 C265.2
  L3_IN1 w0.102: v2(92.59,45.68) 92.81,45.9 92.81,46.33 94.61,48.14 99.34,48.14 99.59,47.88 105.36,47.88 106.68,46.56 109.2,46.56 v2(109.42,46.78)
  BOTTOM w0.114: v2(109.42,46.78) 109.77,46.43 111.2,46.43 111.84,45.8 119.24,45.8 119.52,45.52 121.13,45.52 122.12,44.53 122.12,39.32 122.91,38.53 124.38,38.53 124.99,39.14 125.73,39.14 126.69,38.18 127.71,38.18 128.4,37.49 128.4,36.22 v1(128.47,36.15)
PCIE14_TXN: length 37.8
  TOP w0.114: U1901.14 91.87,51.04 91.79,50.96 91.47,50.96 v1(91.13,50.63)
  L6_IN2 w0.102: v2(109.55,47.54) 109.25,47.84 108.27,47.84 108.11,47.68 101.77,47.68 99.72,49.74 93.29,49.74 92.15,50.88 91.39,50.88 v1(91.13,50.63)
  BOTTOM w0.114: C287.1 123.83,47.2 123.5,47.52 123.17,47.52 121.59,45.94 119.7,45.94 119.01,46.62 112.7,46.62 111.44,47.88 109.89,47.88 v2(109.55,47.54)
PCIE14_TXP: length 37.8
  TOP w0.114: v1(91.13,51.36) 91.29,51.2 91.69,51.2 91.93,51.44 U1901.13
  L6_IN2 w0.102: v2(109.55,48.47) 109.18,48.1 108.17,48.1 108.01,47.94 101.87,47.94 99.82,49.99 93.4,49.99 92.26,51.13 91.36,51.13 v1(91.13,51.36)
  BOTTOM w0.114: C300.1 123.83,48.09 123.5,47.76 123.07,47.76 121.49,46.18 119.8,46.18 119.11,46.86 112.8,46.86 111.54,48.12 109.89,48.12 v2(109.55,48.47)
PCIE15_RXN: length 54.3
  TOP w0.076: U28.F44 127,35.07 v1(127.08,35)
  TOP w0.114: v2(90.75,18.76) 90.37,18.39 90.37,18.02 90.45,17.94 CNWLAN1.43
  BOTTOM w0.114: v1(127.08,35) 127.24,35 127.37,34.88 127.72,34.88 128.22,34.38 128.22,31.32 126.36,29.46 122.84,29.46 122.21,30.09 113.22,30.09 110.84,27.72 110.84,26.44 110.84,26.09 108.9,24.15 103.9,24.15 99.95,20.2 96.52,20.2 95.73,19.4 95.55,19.4 95.31,19.16 95.31,18.98 95.07,18.74 94.89,18.74 94.65,18.5 94.65,18.32 94.4,18.08 94.23,18.08 93.99,17.84 93.99,17.66 93.42,17.1 92.75,17.1 92.63,17.22 92.28,17.22 92.16,17.1 91.81,17.1 91.69,17.22 91.35,17.22 91.22,17.1 90.88,17.1 90.26,17.72 90.26,18.46 90.56,18.76 v2(90.75,18.76)
PCIE15_RXP: length 54.3
  TOP w0.076: U28.E45 127.44,35.37 v1(127.57,35.37)
  TOP w0.114: CNWLAN1.41 89.95,17.94 90.13,18.12 90.13,18.43 v2(89.82,18.75)
  BOTTOM w0.114: v2(89.82,18.75) 90.02,18.55 90.02,17.62 90.78,16.86 93.52,16.86 96.62,19.95 100.05,19.95 104,23.91 109,23.91 111.09,25.99 111.09,26.54 111.09,27.62 113.32,29.85 122.11,29.85 122.74,29.22 126.46,29.22 128.46,31.22 128.46,34.48 v1(127.57,35.37)
PCIE15_TXN: length 46
  TOP w0.114: CNWLAN1.37 88.95,19.2 88.63,19.52 88.17,19.52 v2(87.96,19.73)
  BOTTOM w0.114: C241.1 119.63,37.54 119.36,37.27 117.4,37.27 116.15,36.02 116.15,32.66 114.24,30.75 112.95,30.75 110.18,27.99 110.18,26.37 108.63,24.81 103.55,24.81 101.28,22.55 97.75,22.55 97.12,21.91 94.42,21.91 92.28,19.76 89.23,19.76 88.85,19.38 88.31,19.38 v2(87.96,19.73)
PCIE15_TXP: length 46
  TOP w0.114: CNWLAN1.35 88.45,17.94 88.71,18.2 88.71,19.1 88.53,19.28 88.24,19.28 87.96,19 v2(87.96,18.79)
  BOTTOM w0.114: C242.1 119.63,36.66 119.26,37.03 117.5,37.03 116.39,35.92 116.39,32.56 114.34,30.51 113.05,30.51 110.43,27.89 110.43,26.27 108.73,24.57 103.65,24.57 101.38,22.3 97.85,22.3 97.22,21.67 94.52,21.67 92.38,19.52 89.33,19.52 88.95,19.14 88.31,19.14 v2(87.96,18.79)
PCIE17_RXN: length 30.2
  TOP w0.089: v2(126.31,33.61) 126.31,33.61 126.15,33.44 U28.K43
  TOP w0.102: CNSSD1.43 149.82,37.28 149.68,37.14 149.68,37.04 149.68,37.04 149.68,36.74 v2(149.96,36.46)
  L8_IN3 w0.102: v2(126.31,33.61) 126.45,33.48 126.9,33.48 127.01,33.38 128.29,33.38 132.66,37.75 134.14,37.75 135.71,39.32 141.76,39.32 142.5,38.59 144.37,38.59 145.16,37.8 149.2,37.8 149.88,37.12 149.88,36.54 v2(149.96,36.46)
PCIE17_RXP: length 30.2
  TOP w0.089: v2(126.69,32.97) 126.85,33.12 U28.K44
  TOP w0.102: v2(149.18,36.46) 149.46,36.73 149.46,37.14 149.32,37.28 CNSSD1.41
  L8_IN3 w0.102: v2(126.69,32.97) 126.9,33.18 128.37,33.18 128.59,33.39 128.73,33.39 128.94,33.61 128.94,33.75 129.16,33.96 129.3,33.96 129.52,34.18 129.52,34.32 129.73,34.53 129.87,34.53 130.09,34.75 130.09,34.89 130.3,35.1 130.44,35.1 130.66,35.32 130.66,35.46 132.74,37.54 134.22,37.54 135.8,39.12 141.68,39.12 142.41,38.38 144.28,38.38 145.07,37.6 147.42,37.6 147.52,37.5 147.83,37.5 147.93,37.6 148.31,37.6 148.41,37.5 148.71,37.5 148.81,37.6 149.12,37.6 149.68,37.04 149.68,36.89 149.24,36.46 v2(149.18,36.46)
PCIE17_TXN: length 23.6
  TOP w0.114: C236.2 133.88,40.97 134.2,40.65 134.37,40.65 134.95,41.23 145.01,41.23 145.48,40.76 145.9,40.76 146.19,41.05 146.19,41.53 145.73,41.99 v2(145.52,41.99) ; CNSSD1.47 150.82,39.08 150.95,39.2 150.95,39.93 v2(150.67,40.21)
  L8_IN3 w0.102: v2(145.52,41.99) 145.89,41.62 145.89,41.35 146.27,40.97 150.7,40.97 150.96,40.71 150.96,40.51 v2(150.67,40.21)
PCIE17_TXN_C: length 8.7
  TOP w0.076: 127.52,39.32 127.52,39.26 127.23,38.97 126.34,38.97 125.93,38.56 125.93,37.76 125.86,37.68 U28.A42
  TOP w0.114: C236.1 132.12,40.5 128.55,40.5 127.52,39.47 127.52,39.32
PCIE17_TXP: length 23.6
  TOP w0.114: CNSSD1.49 151.32,39.08 151.19,39.21 151.19,39.94 v2(151.46,40.21) ; C233.2 133.88,40.08 134.2,40.41 134.47,40.41 135.05,40.99 144.91,40.99 145.38,40.52 146,40.52 146.43,40.95 146.43,41.96 v2(146.46,41.99)
  L8_IN3 w0.102: v2(146.46,41.99) 146.09,41.62 146.09,41.44 146.36,41.18 150.78,41.18 151.16,40.79 151.16,40.51 v2(151.46,40.21)
PCIE17_TXP_C: length 8.7
  TOP w0.076: 127.76,39.32 127.76,39.31 127.67,39.22 127.67,39.2 127.29,38.81 126.4,38.81 126.09,38.5 126.09,37.56 126.01,37.48 U28.B42
  TOP w0.114: C233.1 132.41,40.26 128.65,40.26 127.76,39.37 127.76,39.32
PCIE18_RXN: length 29.6
  TOP w0.089: U28.P41 v2(125.46,31.88)
  TOP w0.102: 146.32,38.17 146.32,37.28 146.51,37.09 146.51,36.79 v2(146.18,36.46)
  TOP w0.114: 146.32,38.17 CNSSD1.29
  L8_IN3 w0.102: v2(125.46,31.88) 125.25,31.67 125.25,31.04 125.4,30.88 125.4,30.88 125.56,30.72 125.56,30.72 125.72,30.56 126.95,30.56 127.28,30.89 128.68,30.89 129.13,31.35 130.19,31.35 134.76,35.92 136.11,35.92 137.1,36.91 138.56,36.91 139.14,37.49 141,37.49 142.78,35.72 143.87,35.72 143.97,35.81 144.28,35.81 144.37,35.72 144.68,35.72 144.78,35.81 145.08,35.81 145.18,35.72 145.49,35.72 145.59,35.81 145.89,35.81 145.99,35.72 146.29,35.72 146.54,35.96 146.54,36.17 146.24,36.46 v2(146.18,36.46)
PCIE18_RXP: length 29.6
  TOP w0.089: U28.R40 v2(124.73,31.57)
  TOP w0.102: v2(146.96,36.46) 146.73,36.68 146.73,37.19 146.82,37.28 CNSSD1.31
  L8_IN3 w0.102: v2(146.96,36.46) 146.74,36.24 146.74,35.87 146.38,35.51 142.7,35.51 140.92,37.29 139.23,37.29 138.64,36.71 137.19,36.71 136.2,35.72 134.85,35.72 130.27,31.14 129.22,31.14 128.76,30.69 127.36,30.69 127.03,30.36 126.87,30.36 125.64,30.36 125.04,30.96 125.04,31.26 v2(124.73,31.57)
PCIE18_TXN: length 2.1
  TOP w0.114: C230.2 147.95,39.83 147.95,39.25 147.82,39.13 CNSSD1.35
PCIE18_TXN_C: length 30.1
  TOP w0.076: U28.C42 126.04,36.63 125.97,36.55 125.81,36.55 125.72,36.65 125.72,37.34 125.6,37.45 125.6,38.61 126.07,39.08 126.13,39.08 126.21,39.15
  TOP w0.114: C230.1 148.04,41.44 148.04,42.14 147.68,42.51 144.45,42.51 144.35,42.41 144.04,42.41 143.94,42.51 143.63,42.51 143.53,42.41 143.23,42.41 143.13,42.51 142.79,42.51 142.66,42.39 142.32,42.39 142.2,42.51 141.85,42.51 141.73,42.39 141.39,42.39 141.26,42.51 140.92,42.51 140.79,42.39 140.45,42.39 140.33,42.51 130.68,42.51 130.56,42.39 130.21,42.39 130.09,42.51 129.75,42.51 129.65,42.41 129.34,42.41 129.24,42.51 128.94,42.51 128.84,42.41 128.53,42.41 128.43,42.51 128.13,42.51 128.03,42.41 127.73,42.41 127.63,42.51 127.32,42.51 126.71,41.89 126.71,39.65 126.21,39.15
PCIE18_TXP: length 2.1
  TOP w0.114: C226.2 148.19,39.79 148.19,39.25 148.32,39.13 CNSSD1.37
PCIE18_TXP_C: length 30.1
  TOP w0.076: U28.D42 125.74,36.4 125.74,36.4 125.56,36.58 125.56,37.28 125.45,37.39 125.45,38.68 126.03,39.25 126.03,39.32 126.04,39.32
  TOP w0.114: C226.1 148.28,41.3 148.28,42.24 147.78,42.75 127.22,42.75 126.47,41.99 126.47,39.75 126.04,39.32
PCIE19_RXN: length 25.5
  TOP w0.089: U28.M44 126.58,31.76 126.58,31.25 v2(126.74,31.09)
  TOP w0.114: v2(143.18,36.46) 143.45,36.73 143.45,37.14 143.32,37.27 CNSSD1.17
  L8_IN3 w0.102: v2(126.74,31.09) 126.62,31.21 126.62,31.55 126.72,31.65 127.12,31.65 127.45,31.32 128.23,31.32 128.66,31.75 130.02,31.75 130.48,32.21 130.48,32.97 130.69,33.18 130.83,33.18 131.05,33.4 131.05,33.54 131.27,33.75 131.41,33.75 131.62,33.97 131.62,34.11 131.84,34.32 131.98,34.32 132.19,34.54 132.19,34.68 133.84,36.33 134.73,36.33 136.3,37.9 136.61,37.9 136.71,37.8 137.02,37.8 137.12,37.9 137.42,37.9 137.52,37.8 137.82,37.8 137.92,37.9 138.23,37.9 138.33,37.8 138.63,37.8 138.73,37.9 141.17,37.9 141.91,37.16 143.48,37.16 143.59,37.06 143.59,36.81 143.24,36.46 v2(143.18,36.46)
PCIE19_RXP: length 25.5
  TOP w0.089: U28.N42 126.33,31.84 126.41,31.75 126.41,31.43 126.18,31.19 v2(126.11,31.19)
  TOP w0.114: v2(143.96,36.46) 143.69,36.73 143.69,37.14 143.82,37.27 CNSSD1.19
  L8_IN3 w0.102: v2(126.11,31.19) 126.13,31.21 126.13,31.35 126.64,31.85 127.2,31.85 127.53,31.52 128.14,31.52 128.57,31.96 129.94,31.96 130.28,32.3 130.28,33.05 133.75,36.53 134.64,36.53 136.22,38.1 141.26,38.1 141.99,37.37 143.57,37.37 143.79,37.15 143.79,36.63 v2(143.96,36.46)
PCIE19_TXN: length 11.8
  TOP w0.114: CNSSD1.23 144.82,39.08 145.08,39.33 145.08,39.8 144.63,40.25 137.63,40.25 136.91,39.53 136.07,39.53 135.84,39.3 C228.2
PCIE19_TXN_C: length 11.7
  TOP w0.076: 128.49,39.15 128.48,39.14 128.47,39.14 128.45,39.17 127.71,38.43 126.66,38.43 126.44,38.22 126.44,37.67 126.44,37.18 126.4,37.13 126.4,36.74 126.48,36.66 126.59,36.66 126.64,36.71 U28.C44
  TOP w0.114: C228.1 134.92,39.33 134.81,39.45 134.18,39.45 134.07,39.34 132.15,39.34 131.89,39.6 131.36,39.6 131.27,39.5 130.96,39.5 130.86,39.6 130.56,39.6 130.46,39.5 130.15,39.5 130.05,39.6 129.75,39.6 129.65,39.5 129.35,39.5 129.25,39.6 128.94,39.6 128.49,39.15
PCIE19_TXP: length 11.8
  TOP w0.114: CNSSD1.25 145.32,39.9 144.73,40.49 137.53,40.49 136.81,39.77 136.05,39.77 C243.2
PCIE19_TXP_C: length 11.7
  TOP w0.076: U28.D43 126.46,36.45 126.25,36.67 126.25,37.2 126.29,37.24 126.29,38.28 126.59,38.59 126.72,38.59 127.65,38.59 128.31,39.25 128.31,39.32 128.32,39.32
  TOP w0.114: C243.1 134.58,39.69 134.08,39.69 133.97,39.58 132.25,39.58 131.99,39.84 128.84,39.84 128.32,39.32
PCIE20_RXN: length 25.7
  TOP w0.089: U28.R35 v2(122.47,31.27)
  TOP w0.114: CNSSD1.5 140.32,37.27 140.45,37.14 140.45,36.04 v2(140.18,35.77)
  L8_IN3 w0.102: v2(140.18,35.77) 140.47,36.05 140.47,36.31 140.1,36.68 139.48,36.68 138.9,36.1 137.44,36.1 136.45,35.11 135.1,35.11 130.53,30.53 129.62,30.53 129.12,30.03 127.96,30.03 127.6,30.03 127.59,30.03 127.57,30.03 127.21,29.67 125.3,29.67 124.39,30.58 122.97,30.58 122.75,30.8 122.75,30.99 v2(122.47,31.27)
PCIE20_RXP: length 25.7
  TOP w0.089: U28.R37 v2(123.23,31.27)
  TOP w0.114: v2(140.96,35.77) 140.69,36.04 140.69,37.14 140.82,37.27 CNSSD1.7
  L8_IN3 w0.102: v2(123.23,31.27) 122.95,30.99 122.95,30.88 123.05,30.78 124.47,30.78 125.38,29.87 127.13,29.87 127.48,30.23 127.51,30.23 127.51,30.23 129.04,30.23 129.54,30.74 130.44,30.74 135.01,35.31 136.36,35.31 137.35,36.3 138.81,36.3 139.4,36.88 140.18,36.88 140.67,36.39 140.67,36.05 v2(140.96,35.77)
PCIE20_TXN: length 11
  TOP w0.114: CNSSD1.11 141.82,39.08 142.08,39.33 142.08,39.47 141.96,39.59 137.91,39.59 136.57,38.25 134.46,38.25 134.21,38.5 133.94,38.5 133.83,38.38 133.83,38.25 C249.2
PCIE20_TXN_C: length 7.2
  TOP w0.076: 129.03,38.68 129.03,38.68 129.01,38.7 128.8,38.7 128.15,38.04 127.03,38.04 126.86,37.88 126.86,37.77 U28.A44
  TOP w0.114: 129.03,38.68 130.28,38.68 130.38,38.58 130.68,38.58 130.78,38.68 131.18,38.68 131.28,38.58 131.58,38.58 131.68,38.68 131.94,38.68 132.24,38.38 132.64,38.38 132.74,38.28 132.74,38.08 C249.1
PCIE20_TXP: length 11
  TOP w0.114: CNSSD1.13 142.32,39.57 142.06,39.83 137.81,39.83 136.47,38.49 134.56,38.49 134.31,38.74 133.58,38.74 C245.2
PCIE20_TXP_C: length 7.2
  TOP w0.076: 129.03,38.92 129.03,38.92 128.96,38.85 128.74,38.85 128.08,38.2 126.96,38.2 126.71,37.94 126.71,37.81 126.71,37.81 126.71,37.56 126.95,37.32 U28.B44
  TOP w0.114: C245.1 132.15,38.81 132.04,38.92 129.03,38.92
PCIE_DETECT_SSD1: length 43.2
  TOP w0.076: v1(130.76,23.35) 130.73,23.35 130.53,23.14 129.33,23.14 128.96,22.78 128.44,22.78 128.01,22.35 U28.AM46
  TOP w0.102: R342.2 156.32,40.1 CNSSD1.69 156.32,35.67 154.25,33.61 154.25,29.84 v1(154.23,29.82)
  L8_IN3 w0.089: v1(130.76,23.35) 130.76,24.21 132,25.45 133.09,25.45 136.06,28.43 138.63,28.43 140.52,30.31 153.87,30.31 154.23,29.94 v1(154.23,29.82)
  BOTTOM w0.102: v3(154.41,31.3) 154.23,31.12 v1(154.23,29.82)
PCIE_DETECT_SSD2: length 64
  TOP w0.102: v3(177.8,33.91) 179.32,35.44 CNSSD2.69 179.32,40.06 R335.2
  TOP w0.114: U28.AJ43 126.21,24.36 v1(126.31,24.46)
  L8_IN3 w0.089: v3(177.8,33.91) 177.8,32.77 175.54,30.51 140.43,30.51 138.55,28.63 135.97,28.63 133,25.66 129.28,25.66 129.07,25.86 127.2,25.86 126.31,24.97 v1(126.31,24.46)
PCIE_RCOMPN: length 2
  TOP w0.254: v1(111.96,37.67) 111.47,37.18 U28.B12
  BOTTOM w0.254: R366.2 112.55,37.09 v1(111.96,37.67)
PCIE_RCOMPP: length 1.9
  TOP w0.254: U28.A13 111.48,37.95 111.84,38.31 v1(111.96,38.31)
  BOTTOM w0.254: R366.1 112.5,38.31 v1(111.96,38.31)
PCIE_TXN14_C: length 16
  TOP w0.076: U28.C39 124.31,38.07 124.92,38.67 124.92,38.94 125.14,39.17 125.14,39.39 125.14,39.51 125.58,39.94 125.58,40.35 125.53,40.39 125.53,40.49
  TOP w0.114: 125.53,40.49 125.53,42 127.34,43.81 127.34,44.13 127.24,44.22 127.24,44.53 127.34,44.63 127.34,45 127.24,45.1 127.24,45.41 127.34,45.51 127.34,45.81 127.24,45.91 127.24,46.22 127.34,46.31 127.34,46.62 127.24,46.72 127.24,47.02 127.34,47.12 127.34,47.43 127.1,47.67 126.07,47.67 125.93,47.53 125.93,47.15 v2(126.01,47.07)
  BOTTOM w0.114: C287.2 125.5,47.58 125.78,47.58 126.01,47.35 v2(126.01,47.07)
PCIE_TXP14_C: length 16
  TOP w0.076: U28.D39 124.23,35.97 124.51,36.25 124.51,36.62 124.46,36.67 124.46,38.01 125.07,38.61 125.07,38.88 125.3,39.11 125.3,39.45 125.73,39.88 125.73,40.35 125.77,40.39 125.77,40.49
  TOP w0.114: 125.77,40.49 125.77,41.9 127.58,43.71 127.58,47.53 127.19,47.92 126.32,47.92 v2(126.06,48.18)
  BOTTOM w0.114: v2(126.06,48.18) 126.06,48.11 125.79,47.84 125.36,47.84 C300.2
PEG_TXN0: length 10
  TOP w0.076: 120.43,121.79 120.45,121.79 120.5,121.75 121.08,121.75 121.37,121.46 121.84,121.46 121.98,121.61 121.98,121.73 121.91,121.8 121.7,121.8 U26.A25
  TOP w0.114: 120.43,121.79 118.28,121.79 116.79,123.29 116.55,123.29 116.11,123.73 114.51,123.73 113.89,123.73 113.86,123.73 113.69,123.9 C1476.1
PEG_TXN1: length 8.8
  TOP w0.076: 120.52,120.88 120.78,120.63 121.73,120.63 121.94,120.84 121.94,121.01 122.19,121.26 122.47,121.26 122.75,120.98 U26.C24
  TOP w0.114: C1477.1 115.79,122.8 116.05,122.8 116.38,122.47 116.61,122.47 118.07,121.02 120.38,121.02 120.52,120.88
PEG_TXN2: length 9.8
  TOP w0.076: U26.A23 121.69,120.22 121.87,120.22 121.94,120.15 121.94,120.02 121.76,119.84 121.36,119.84 121.04,120.16 120.55,120.16 120.53,120.18 120.46,120.18 120.44,120.2 120.43,120.2
  TOP w0.114: C1478.1 113.69,121.77 113.87,121.59 116.33,121.59 117.73,120.2 120.43,120.2
PEG_TXN3: length 8.6
  TOP w0.076: U26.C22 122.75,119.41 122.46,119.7 122.19,119.7 121.95,119.46 121.95,119.3 121.76,119.1 120.69,119.1 120.61,119.18 120.61,119.2 120.61,119.21
  TOP w0.114: C1479.1 115.8,120.7 116.19,120.7 117.42,119.47 120.34,119.47 120.61,119.21
PEG_TXN4: length 9.6
  TOP w0.076: U26.A21 121.76,118.71 121.89,118.71 121.97,118.64 121.97,118.45 121.84,118.32 121.36,118.32 121.11,118.57 120.46,118.57 120.43,118.54
  TOP w0.114: 120.43,118.54 120.22,118.54 119.99,118.77 117.04,118.77 116.29,119.53 113.79,119.53 113.67,119.64 C1480.1
PEG_TXN5: length 8.3
  TOP w0.076: U26.C20 122.71,117.83 122.43,118.12 122.2,118.12 121.94,117.86 121.94,117.72 121.73,117.5 120.75,117.5 120.44,117.8 120.43,117.8
  TOP w0.114: C1481.1 115.78,118.56 116.19,118.56 116.69,118.06 119.65,118.06 119.91,117.8 120.43,117.8
PEG_TXN6: length 9.2
  TOP w0.076: 120.43,117.02 120.46,117 121.22,117 121.52,116.7 121.75,116.7 121.96,116.9 121.96,117.01 121.88,117.1 121.72,117.1 U26.A19
  TOP w0.114: C1482.1 113.69,117.64 113.99,117.34 119.26,117.34 119.58,117.02 120.43,117.02
PEG_TXN7: length 8.2
  TOP w0.076: 120.43,116.32 120.53,116.32 120.91,115.93 121.83,115.93 121.98,116.09 121.98,116.35 122.17,116.54 122.69,116.54 U26.C18
  TOP w0.114: 120.43,116.32 115.92,116.32 C1483.1
PEG_TXN8: length 9.1
  TOP w0.076: 120.43,115.33 120.53,115.33 120.6,115.4 121.11,115.4 121.36,115.14 121.73,115.14 122.06,115.47 U26.B17
  TOP w0.114: C1488.1 113.93,114.95 116.47,114.95 116.85,115.33 120.43,115.33
PEG_TXN9: length 7.9
  TOP w0.076: U26.B16 122.07,114.68 121.79,114.96 121.31,114.96 121.13,115.15 120.85,115.15 120.45,114.74 120.43,114.74
  TOP w0.114: C1489.1 115.51,114.42 115.51,114.17 115.62,114.06 116.28,114.06 116.96,114.74 120.43,114.74
PEG_TXN10: length 9.3
  TOP w0.076: 120.43,114.01 120.49,113.95 120.62,113.95 120.84,114.18 122.02,114.18 122.3,113.89 U26.B15
  TOP w0.114: C1490.1 114,113.18 116.39,113.18 117.22,114.01 120.43,114.01
PEG_TXN11: length 8.3
  TOP w0.076: 120.43,113.27 120.58,113.27 120.92,113.61 121.22,113.61 121.41,113.42 122.38,113.42 122.47,113.33 122.47,113.2 122.38,113.11 U26.B14
  TOP w0.114: 120.43,113.27 117.76,113.27 116.52,112.02 115.71,112.02 115.59,112.14 C1491.1
PEG_TXN12: length 9.6
  TOP w0.076: U26.B13 122.31,112.43 122.15,112.6 121.44,112.6 121.21,112.37 120.49,112.37 120.43,112.42
  TOP w0.114: C1510.1 113.93,111.09 116.61,111.09 117.95,112.42 120.43,112.42
PEG_TXN13: length 8.2
  TOP w0.076: U26.B12 122.5,111.53 122.57,111.46 122.57,111.35 122.4,111.18 120.5,111.18 120.44,111.23 120.43,111.23
  TOP w0.114: C1512.1 115.59,110.26 115.94,109.91 116.66,109.91 117.71,110.97 119.93,110.97 120.19,111.23 120.43,111.23
PEG_TXN14: length 9.7
  TOP w0.076: 120.43,110.06 120.66,110.28 121.9,110.28 122.31,110.7 U26.B11
  TOP w0.114: 120.43,110.06 120.37,110 118.23,110 116.87,108.63 114.07,108.63 C1514.1
PEG_TXN15: length 8.5
  TOP w0.076: 120.43,109.5 120.44,109.5 120.49,109.45 121.07,109.45 121.25,109.63 122.5,109.63 122.65,109.77 122.65,109.88 122.57,109.96 U26.B10
  TOP w0.114: C1516.1 115.93,107.84 116.97,107.84 118.63,109.5 120.43,109.5
PEG_TXP0: length 10
  TOP w0.076: 120.43,121.55 120.45,121.55 120.5,121.59 121.02,121.59 121.3,121.31 121.9,121.31 122.16,121.57 122.16,121.62 U26.B25
  TOP w0.114: C1492.1 113.69,123.2 113.99,123.49 114.51,123.49 116.01,123.49 116.45,123.04 116.69,123.04 118.18,121.55 120.43,121.55
PEG_TXP1: length 8.8
  TOP w0.076: 120.43,120.66 120.51,120.66 120.69,120.48 121.8,120.48 121.93,120.61 122.04,120.61 122.16,120.49 122.27,120.49 122.35,120.57 122.35,120.95 U26.B24
  TOP w0.114: C1493.1 115.55,122.1 115.43,122.21 115.43,122.44 115.55,122.56 115.95,122.56 116.28,122.23 116.51,122.23 117.97,120.78 120.28,120.78 120.4,120.66 120.43,120.66
PEG_TXP2: length 9.7
  TOP w0.076: 120.43,119.95 121.03,119.95 121.3,119.69 121.83,119.69 122.1,119.96 122.1,120.09 122.2,120.19 U26.B23
  TOP w0.114: 120.43,119.95 117.63,119.95 116.23,121.35 113.98,121.35 C1494.1
PEG_TXP3: length 8.6
  TOP w0.076: 120.43,119.04 120.52,118.95 121.82,118.95 122,119.13 122.06,119.13 122.13,119.05 122.13,118.94 122.18,118.89 122.26,118.89 122.35,118.98 122.35,119.37 U26.B22
  TOP w0.114: 120.43,119.04 120.24,119.23 117.32,119.23 116.09,120.46 115.63,120.46 115.51,120.34 115.51,120.1 C1495.1
PEG_TXP4: length 9.6
  TOP w0.076: 120.43,118.3 120.44,118.3 120.45,118.31 120.45,118.32 120.55,118.42 121.04,118.42 121.3,118.16 121.9,118.16 122.12,118.39 122.12,118.54 122.2,118.62 U26.B21
  TOP w0.114: 120.43,118.3 120.12,118.3 119.89,118.53 116.94,118.53 116.19,119.28 114.04,119.28 C1496.1
PEG_TXP5: length 8.4
  TOP w0.076: U26.B20 122.31,117.44 122.24,117.36 122.13,117.36 122.04,117.45 121.93,117.45 121.83,117.35 120.65,117.35 120.43,117.56
  TOP w0.114: C1497.1 115.51,117.86 115.39,117.98 115.39,118.18 115.52,118.32 116.09,118.32 116.59,117.82 119.55,117.82 119.81,117.56 120.43,117.56
PEG_TXP6: length 9.2
  TOP w0.076: U26.B19 121.82,116.55 121.45,116.55 121.16,116.84 120.48,116.84 120.43,116.8
  TOP w0.114: C1498.1 113.99,117.1 119.16,117.1 119.48,116.78 120.42,116.78 120.43,116.8
PEG_TXP7: length 8.2
  TOP w0.076: 120.43,116.07 120.55,116.07 120.85,115.78 121.89,115.78 122.08,115.96 122.62,115.96 122.7,116.04 122.7,116.18 122.6,116.28 122.34,116.28 U26.B18
  TOP w0.114: 120.43,116.07 115.71,116.07 115.59,115.96 C1499.1
PEG_TXP8: length 9.1
  TOP w0.076: U26.A17 121.66,115.37 121.59,115.3 121.43,115.3 121.18,115.55 120.45,115.55 120.43,115.56
  TOP w0.114: C1504.1 113.55,115.6 113.47,115.52 113.47,115.3 113.58,115.19 116.37,115.19 116.75,115.57 120.43,115.57 120.43,115.56
PEG_TXP9: length 7.9
  TOP w0.076: 120.43,114.5 120.61,114.5 120.72,114.39 122.53,114.39 122.82,114.68
  TOP w0.089: 122.82,114.68 U26.C16
  TOP w0.114: C1505.1 115.8,113.82 116.38,113.82 117.06,114.5 120.43,114.5
PEG_TXP10: length 9.3
  TOP w0.076: 120.43,113.76 120.44,113.76 120.47,113.8 120.68,113.8 120.91,114.02 121.25,114.02 121.32,113.95 121.32,113.74 121.47,113.6 121.71,113.6 121.79,113.68 121.79,113.82 121.71,113.89 U26.A15
  TOP w0.114: C1506.1 114.03,112.94 116.49,112.94 117.32,113.76 120.43,113.76
PEG_TXP11: length 8.3
  TOP w0.076: U26.C14 122.78,113.11 122.46,112.79 120.93,112.79 120.62,113.1 120.51,113.1 120.43,113.03
  TOP w0.114: 120.43,113.03 117.86,113.03 116.62,111.78 115.87,111.78 C1507.1
PEG_TXP12: length 9.5
  TOP w0.076: 120.43,112.18 120.44,112.18 120.48,112.22 121.29,112.22 121.49,112.02 121.85,112.02 121.92,112.1 121.92,112.24 121.85,112.32 U26.A13
  TOP w0.114: 120.43,112.18 118.05,112.18 116.71,110.85 114.07,110.85 113.69,110.47 C1509.1
PEG_TXP13: length 8.2
  TOP w0.076: U26.C12 122.46,111.03 120.47,111.03 120.43,110.99
  TOP w0.114: C1511.1 115.84,109.67 116.76,109.67 117.81,110.73 120.03,110.73 120.29,110.99 120.43,110.99
PEG_TXP14: length 9.7
  TOP w0.076: 120.43,110.4 120.47,110.44 121.84,110.44 122.02,110.61 122.02,110.72 121.94,110.8 121.72,110.8 U26.A11
  TOP w0.114: C1513.1 113.96,108.88 116.77,108.88 118.13,110.24 120.27,110.24 120.43,110.4
PEG_TXP15: length 8.5
  TOP w0.076: U26.C10 122.81,109.81 122.81,109.72 122.57,109.48 121.31,109.48 121.13,109.3 120.48,109.3 120.43,109.26
  TOP w0.114: 120.43,109.26 118.73,109.26 117.07,107.6 115.9,107.6 C1515.1
PEX_CLKREQ#: length 44.1
  TOP w0.1: 95.66,98.13 95.77,98.13 96.11,97.79 98.83,97.79
  TOP w0.102: G1.BL26 95.51,98.28 95.66,98.13 ; 98.83,97.79 101.24,97.79 101.9,97.13 101.9,96.12 102.06,95.96 102.85,95.96 106.09,92.71 106.09,85.35 R756.1 R765.1 105.66,83.47 107.4,81.73 107.4,79.05 106.88,78.53 106.88,76.69 109.42,74.15 109.42,68.91 108.69,68.18 107.42,68.18 106.06,66.82 Q78.S
PEX_RST#: length 139
  TOP w0.1: 103.33,95.1 102.67,95.76 101.66,95.76 101.47,95.94 101.47,97.21 101.09,97.59 96.02,97.59 95.68,97.93 95.25,97.93 94.9,98.28 G1.BK26
  TOP w0.102: 103.33,95.1 105.08,93.35 105.08,83.67 107.2,81.55 107.2,79.14 106.63,78.57 106.63,76.66 108.94,74.35 108.94,73.43 R3204.1 108.04,72.54 Q99.4 108.04,71.31 108.91,70.44 108.91,68.79 108.51,68.38 106.22,68.38 105.49,67.64 105.49,65.36 103.41,63.29 103.41,61.41 v1(103.3,61.29) ; v1(165.23,26.5) R158.2
  L3_IN1 w0.089: v1(156.89,51.57) 160.46,48 160.46,42.83 160.46,36.29 164.14,32.61 164.14,29.44 164.39,29.18 164.39,27.33 v1(165.23,26.5)
  BOTTOM w0.102: v1(156.89,51.57) 152.73,55.73 131.73,55.73 128.4,59.06 108.08,59.06 105.41,61.73 103.73,61.73 v1(103.3,61.29)
PEX_RST_HOLD#_GC6: length 8.2
  TOP w0.102: G1.BG3 92.65,82 92.32,81.67 92.32,80.43 94.11,78.64 94.11,75.42 94.44,75.09 R2810.2
PEX_RXN0: length 18.9
  TOP w0.089: v1(123.29,121.38) 123.39,121.38 123.62,121.61 U26.D25
  BOTTOM w0.076: 120.49,121.76 120.52,121.73 121.47,121.73 122.04,121.16 123.21,121.16 123.29,121.23 v1(123.29,121.38)
  BOTTOM w0.114: 120.49,121.76 120.43,121.81 115.08,121.81 109.23,115.96 108.44,115.96 108.33,116.08 108.33,116.3 108.44,116.41 C822.1
PEX_RXN1: length 22.2
  TOP w0.089: v1(124.65,120.62) 124.61,120.66 124.61,120.85 124.74,120.98 U26.F24
  BOTTOM w0.076: 120.43,120.85 120.44,120.85 120.46,120.83 120.47,120.83 120.54,120.76 121.8,120.76 122.36,120.2 122.86,120.2 123.05,120.39 123.47,120.39 123.5,120.42 123.5,120.72 123.76,120.98 124.14,120.98 124.49,120.62 v1(124.65,120.62)
  BOTTOM w0.114: 120.43,120.85 115.64,120.85 109.82,115.03 106.69,115.03 C824.1
