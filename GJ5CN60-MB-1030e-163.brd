# Allegro board GJ5CN60-MB-1030e-163.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND POWER on BOTTOM (solid shape): 146.05,188.49 146.05,185.68 145.73,185.35 145.61,184.91 145.61,184.45 145.87,183.83 146.49,183.57 147.19,183.57 147.43,183.35 147.75,183.27 154.85,183.27 155.17,183.35 155.42,183.57 156.12,183.57 156.74,183.83 157,184.45 157,184.91 156.88,185.35 156.56,185.68 156.56,188.49 156.84,188.77 159.6,188.77 160.39,188.44 160.72,187.65 160.72,175.75 161.27,174.42 162.6,173.87 164.84,173.87 164.92,173.79 164.92,173.49 164.79,173.36 162.6,173.36 160.91,174.06 160.21,175.75 160.21,176.51 157.88,178.84 157.73,179.07 157.5,179.22 156,180.72 155.09,180.72 154,181.82 154,182.66 153.9,182.76 148.77,182.76 148.54,182.53 148.54,181.74 148.26,181.46 147.29,181.46 146.89,181.05 146.89,179.17 144.26,176.55 142.02,176.55 141.55,176.08 141.55,175.16 140.82,174.42 137.21,174.42 136.07,175.57 136.07,176.58 136.4,176.92 137.92,176.92 138.27,177 138.58,177.24 138.75,177.6 138.75,178 138.58,178.36 138.27,178.6 138.26,178.6 138.26,185.49 138.54,185.77 141.78,185.77 142.76,186.17 143.16,187.15 143.16,188.49 143.44,188.77 145.77,188.77
GND POWER on BOTTOM (solid shape): 22.05,98.76 22.05,90.88 22.81,90.12 22.81,82.26 22.77,82.18 22.68,82.16 22.38,82.14 22.12,81.97 22.05,81.93 21.54,82.17 21.03,81.93 20.95,81.97 20.13,82.01 20.16,81.18 20.2,81.11 19.96,80.6 20.2,80.09 19.96,79.58 20.2,79.07 20.16,79 20.52,78.01 20.88,79 20.84,79.07 21.08,79.58 20.84,80.09 20.88,80.17 20.92,80.2 20.95,80.24 21.03,80.28 21.54,80.04 22.05,80.28 22.12,80.24 22.38,80.07 22.68,80.05 22.77,80.03 22.81,79.95 22.81,78.18 21.92,77.3 18.74,77.3 18.24,77.8 18.24,87.07 20.14,88.98 20.14,91.65 19.51,92.28 16.46,92.28 13.28,95.46 13.28,97.87 15.32,99.9 20.9,99.9
GND POWER on BOTTOM (solid shape): outline of 452 points within 19.76,117.96 104.72,164.26
GND POWER on BOTTOM (solid shape): outline of 135 points within 0.38,0.38 195.82,188.12
GND POWER on L3_IN1 (solid shape): 103.9,186.34 103.9,178.6 103.89,178.6 103.58,178.36 103.41,178 103.41,177.6 103.58,177.24 103.89,177 104.24,176.92 105.53,176.92 105.78,176.67 105.78,176.14 105.76,176.13 105.76,175.03 105.18,174.45 96.72,174.45 95.89,175.28 95.89,179.44 94.79,180.55 94.79,186.34 95.06,186.62 103.62,186.62
GND POWER on L3_IN1 (solid shape): 124,185.49 124,178.6 123.99,178.6 123.68,178.36 123.51,178 123.51,177.6 123.68,177.24 123.99,177 124.34,176.92 125.5,176.92 125.81,176.61 125.81,174.86 125.17,174.22 122.58,174.22 122.07,174.73 117.09,174.73 116.36,175.47 116.36,176.79 116.48,176.92 117.82,176.92 118.17,177 118.48,177.24 118.65,177.6 118.65,178 118.48,178.36 118.17,178.6 118.16,178.6 118.16,185.49 118.44,185.77 123.72,185.77
GND POWER on L3_IN1 (solid shape): 56.67,187.84 56.67,181.8 57.35,180.94 58.34,181.42 71.26,181.42 72.25,180.94 72.93,181.8 72.93,187.84 73.21,188.12 74.85,188.12 74.93,188.08 74.97,188 74.97,186 75.23,185.38 75.85,185.12 79.7,185.12 79.79,185.08 79.82,185 79.82,180.27 79.58,180.02 77.43,180.02 77.08,179.69 77.08,176.73 76.4,176.05 73.23,176.05 72.21,177.07 72.21,179.1 70.89,180.42 70.38,180.42 69.7,181.11 59.82,181.11 59.54,180.83 59.54,177.3 57.66,175.42 55.5,175.42 53.14,173.05 41.83,173.05 41.12,173.76 41.12,175.42 41.22,175.52 46.27,175.52 47.24,176.31 46.66,177.4 46.66,186.04 46.93,186.32 52.12,186.32 53.1,186.72 53.51,187.7 53.51,187.84 53.78,188.12 56.39,188.12
GND POWER on L3_IN1 (solid shape): outline of 187 points within 0.38,0.38 195.82,188.77
GND POWER on L6_IN2 (solid shape): 103.9,186.34 103.9,178.6 103.89,178.6 103.58,178.36 103.41,178 103.41,177.6 103.58,177.24 103.89,177 104.24,176.92 105.53,176.92 105.78,176.67 105.78,176.14 105.76,176.13 105.76,175.03 105.18,174.45 96.72,174.45 95.89,175.28 95.89,179.44 94.79,180.55 94.79,186.34 95.06,186.62 103.62,186.62
GND POWER on L6_IN2 (solid shape): 124,185.49 124,178.6 123.99,178.6 123.68,178.36 123.51,178 123.51,177.6 123.68,177.24 123.99,177 124.34,176.92 125.5,176.92 125.81,176.61 125.81,174.86 125.17,174.22 122.58,174.22 122.07,174.73 117.09,174.73 116.36,175.47 116.36,176.79 116.48,176.92 117.82,176.92 118.17,177 118.48,177.24 118.65,177.6 118.65,178 118.48,178.36 118.17,178.6 118.16,178.6 118.16,185.49 118.44,185.77 123.72,185.77
GND POWER on L6_IN2 (solid shape): 56.67,187.84 56.67,181.8 57.35,180.94 58.34,181.42 71.26,181.42 72.25,180.94 72.93,181.8 72.93,187.84 73.21,188.12 74.85,188.12 74.93,188.08 74.97,188 74.97,186 75.23,185.38 75.85,185.12 79.7,185.12 79.79,185.08 79.82,185 79.82,180.52 79.32,180.02 77.43,180.02 77.08,179.69 77.08,176.6 76.53,176.05 73.23,176.05 72.21,177.07 72.21,179.1 70.89,180.42 70.38,180.42 69.7,181.11 59.82,181.11 58.62,179.91 58.62,176.38 57.66,175.42 55.5,175.42 53.14,173.05 41.83,173.05 41.12,173.76 41.12,175.42 41.22,175.52 46.27,175.52 47.24,176.31 46.66,177.4 46.66,186.04 46.93,186.32 52.12,186.32 53.1,186.72 53.51,187.7 53.51,187.84 53.78,188.12 56.39,188.12
GND POWER on L6_IN2 (solid shape): outline of 185 points within 0.38,0.38 195.82,188.77
GND POWER on L8_IN3 (solid shape): 103.9,186.34 103.9,178.6 103.89,178.6 103.58,178.36 103.41,178 103.41,177.6 103.58,177.24 103.89,177 104.24,176.92 105.53,176.92 105.78,176.67 105.78,176.14 105.76,176.13 105.76,175.03 105.18,174.45 96.6,174.45 95.89,175.16 95.89,179.44 94.79,180.55 94.79,186.34 95.06,186.62 103.62,186.62
GND POWER on L8_IN3 (solid shape): 124,185.49 124,178.6 123.99,178.6 123.68,178.36 123.51,178 123.51,177.6 123.68,177.24 123.99,177 124.34,176.92 125.5,176.92 125.81,176.61 125.81,174.86 125.17,174.22 122.58,174.22 122.07,174.73 117.09,174.73 116.36,175.47 116.36,176.79 116.48,176.92 117.82,176.92 118.17,177 118.48,177.24 118.65,177.6 118.65,178 118.48,178.36 118.17,178.6 118.16,178.6 118.16,185.49 118.44,185.77 123.72,185.77
GND POWER on L8_IN3 (solid shape): 56.67,187.84 56.67,181.8 57.35,180.94 58.34,181.42 71.26,181.42 72.25,180.94 72.93,181.8 72.93,187.84 73.21,188.12 74.85,188.12 74.93,188.08 74.97,188 74.97,186 75.23,185.38 75.85,185.12 79.7,185.12 79.79,185.08 79.82,185 79.82,180.39 79.45,180.02 77.43,180.02 77.08,179.69 77.08,176.98 76.15,176.05 73.23,176.05 72.21,177.07 72.21,179.1 70.89,180.42 70.38,180.42 69.7,181.11 59.82,181.11 59.54,180.83 59.54,177.3 57.66,175.42 55.5,175.42 53.14,173.05 41.83,173.05 41.12,173.76 41.12,175.42 41.22,175.52 46.27,175.52 47.24,176.31 46.66,177.4 46.66,186.04 46.93,186.32 52.12,186.32 53.1,186.72 53.51,187.7 53.51,187.84 53.78,188.12 56.39,188.12
GND POWER on L8_IN3 (solid shape): outline of 181 points within 59.88,113.83 63.04,117.43
GND POWER on L8_IN3 (solid shape): 75.31,115.62 75.42,115.64 75.48,115.55 75.48,115.16 75.47,115.13 75.44,115.11 75.12,114.78 75.44,114.45 75.47,114.44 75.48,114.4 75.48,113.61 75.45,113.6 75.22,113.33 75.36,113.01 75.4,112.93 75.36,112.85 75.3,112.36 75.79,112.36 75.86,112.38 75.93,112.35 76.57,111.7 76.57,110.94 75.9,110.94 75.81,110.99 75.81,111.09 75.69,111.58 75.23,111.38 75.18,111.33 75.12,111.32 75.07,111.33 75.03,111.46 74.93,111.56 74.9,111.63 74.93,111.71 75.08,111.98 74.93,112.26 74.9,112.33 74.93,112.41 75.07,112.75 74.8,113.01 74.76,113.02 74.76,113.61 74.78,113.65 74.81,113.66 75.13,113.99 74.81,114.32 74.78,114.34 74.76,114.37 74.76,115.07
GND POWER on L8_IN3 (solid shape): outline of 211 points within 56.9,132.32 60.37,135.23
GND POWER on L8_IN3 (solid shape): outline of 608 points within 63.15,109.66 69.36,115.61
GND POWER on L8_IN3 (solid shape): outline of 184 points within 0.38,0.38 195.82,188.77
GND POWER on TOP: 186.98,88.64 186.64,88.98 186.64,91.39 187.53,92.28 187.53,92.28 187.73,92.48 189.76,92.48 189.85,92.39 189.85,89.25 189.24,88.64
GND POWER on TOP: 186.64,99.4 181.69,99.4 181.67,99.42 181.67,100.8 182.2,101.32 187.12,101.32 187.45,100.99 187.45,100.21
GND POWER on TOP: 2.49,39.42 6.53,39.42 6.81,39.14 6.81,36.68 6.65,36.53 2.54,36.53 2.21,36.86 2.21,39.14
GND POWER on TOP: 80.71,75.39 82.82,75.39 83.15,75.06 83.15,69.96 82.69,69.5 80.36,69.5 80.05,69.81 80.05,74.73
GND POWER on TOP: 189.31,106.76 192.56,106.76 192.7,106.63 192.7,105.79 192.4,105.49 189.36,105.49 189.2,105.66 189.2,106.65
GND POWER on TOP: 21.13,61.95 25.5,61.95 25.55,61.9 25.55,57.61 25.45,57.51 21.21,57.51 21.11,57.61 21.11,61.93
GND POWER on TOP: outline of 86 points within 106.81,17.92 125.28,36.75 ; 5 cut-outs
GND POWER on TOP: 92.91,41.23 92.79,41.35 92.79,42.5 92.87,42.58 93.05,42.5 93.25,42.52 93.28,42.53 93.47,42.73 93.47,43.01 93.47,43.02 93.47,43.18 93.55,43.26 100.66,43.26 101.04,42.88 101.04,41.48 100.79,41.23
GND POWER on TOP: 86.12,41.22 87.84,41.22 88.02,41.04 88.02,39.32 87.9,39.2 86.18,39.2 86.04,39.34 86.04,41.14
GND POWER on TOP: 179.56,104.82 181.22,104.82 181.61,104.43 181.61,101.6 181.43,101.43 175.18,101.43 174.99,101.62 174.99,102.46 175.1,102.57 178.8,102.57 179.18,102.95 179.18,104.43
GND POWER on TOP: 69.47,66.7 71.14,66.7 71.37,66.47 71.37,62.97 71.25,62.84 70.41,62.84 70.2,63.05 68.32,63.05 67.84,63.53 67.84,65.59 68.6,66.35 69.11,66.35
GND POWER on TOP: 84.43,42.3 84.5,42.24 84.5,40.02 84.5,39.82 84.3,39.63 81.5,39.63 81.24,39.88 81.24,40.66 80.96,40.95 80.93,41.3 80.63,41.48 79.2,41.48 78.94,41.74 78.94,42.12 79.12,42.3
GND POWER on TOP: 175.12,98.77 178.51,98.77 178.86,98.42 178.86,95.95 179.48,95.33 179.48,93.62 180.11,93 180.11,91.65 179.9,91.44 175.14,91.44 174.76,91.82 174.76,98.4
GND POWER on TOP: 165.43,15.32 166.32,15.32 166.45,15.19 166.45,12.91 166.32,12.78 165.68,12.78 165.3,13.16 165.3,13.54 165.18,13.67 164.54,13.67 164.29,13.92 164.29,14.81 164.41,14.94 165.05,14.94
GND POWER on TOP: outline of 498 points within 89,88.25 96.59,110.77
GND POWER on TOP: 173.99,132.67 172.64,131.32 165.18,131.32 164.79,131.7 164.79,132.95 165.25,133.4 166.72,133.4 167.13,133.81 170.97,133.81 171.27,134.12 171.27,143.72 171.65,144.1 173.56,144.1 173.99,143.67
GND POWER on TOP: 49.48,61.8 52.65,61.8 53.16,61.29 53.16,58.5 52.78,58.12 49.48,58.12 49.22,58.37 49.22,61.55
GND POWER on TOP: 192.43,75.16 193.65,75.16 193.72,75.09 193.72,69.07 193.39,68.74 192.51,68.74 192.34,68.9 192.34,75.07
GND POWER on TOP: 130.27,38.35 130.27,37.69 130.07,37.49 129.86,37.49 129.48,37.11 129.19,37.11 129.12,37.05 129.12,35.57 129.02,35.47 128.63,35.47 128.56,35.54 128.56,36.77 128.26,37.07 128.1,37.07 127.91,37.26 127.91,37.26 127.73,37.43 127.52,37.43 127.32,37.63 127.32,37.8 127.38,37.85 128.46,37.85 129.04,38.43 130.2,38.43
GND POWER on BOTTOM: 130.54,169.63 129.53,168.61 123.49,168.61 123.16,168.94 123.16,170.33 123.43,170.59 128.94,170.59 129.32,170.98 129.32,173.99 129.57,174.23 130.37,174.23 130.54,174.06
GND POWER on BOTTOM: 171.34,151.55 170.9,151.11 165.62,151.11 164.98,151.74 164.98,154.31 165.61,154.94 165.61,158.45 166.06,158.91 169.7,158.91 171.34,157.27
GND POWER on BOTTOM: 161.84,161.28 161.84,154.91 160.78,153.85 159.43,152.5 159.43,150.44 159.04,150.04 157.08,150.04 156.6,150.51 156.6,152.16 155.32,153.44 155.32,161.29 155.88,161.85 161.27,161.85
GND POWER on BOTTOM: 108.71,88.85 108.48,89.08 108.48,93.93 116.51,101.96 124.13,101.96 126.56,99.53 126.56,94.7 122.87,91.02 120.89,91.02 120.62,90.76 120.62,89.49 119.98,88.85
GND POWER on BOTTOM: 162.76,137.85 164.3,137.85 164.49,137.66 164.49,132.92 166.23,131.18 166.66,131.18 166.83,131.02 166.83,126.06 166.32,125.56 165.05,125.56 164.67,125.94 164.67,131.14 164.16,131.65 162.86,131.65 162.6,131.91 162.6,137.7
GND POWER on BOTTOM: 47.32,63.96 47.32,62.56 46.94,62.18 42.37,62.18 41.99,62.56 41.99,63.96 42.37,64.34 46.94,64.34
GND POWER on BOTTOM: 115.39,145.37 115.14,145.62 115.14,148.42 116.46,149.74 148.86,149.74 152.48,146.13 152.48,143.79 150.57,141.89 149.91,141.89 149.38,141.35 149.38,135.03 149.1,134.75 147.6,134.75 147.4,134.95 147.4,141.94 149.55,144.1 149.55,144.86 149.05,145.37
GND POWER on BOTTOM: 111.96,68.28 111.71,68.53 111.71,76.28 111.71,76.29 111.71,76.92 111.96,77.17 113.23,77.17 113.35,77.05 113.35,73.53 113.32,73.5 113.11,73.5 113.11,73.5 113.07,73.5 112.14,72.3 113.07,71.11 113.11,71.1 113.11,68.41 112.98,68.28
GND POWER on BOTTOM: 96.24,11.18 97.41,11.18 97.63,10.96 97.63,10.28 96.76,9.41 96.76,6.91 96.78,6.89 96.78,6.31 96.62,6.14 95.6,6.14 95.56,6.18 95.56,10.5
GND POWER on BOTTOM: 170.38,20.78 171.27,20.78 172.29,19.76 172.29,18.62 172.03,18.37 171.53,18.37 171.27,18.11 171.27,17.48 170.89,17.1 170.38,17.1 170.26,17.22 170.26,20.65
GND POWER on BOTTOM: 149.17,158.65 149.17,158.65 149.17,156.64 148.97,156.44 145.97,156.44 145.31,157.1 145.31,164.09 144.95,164.45 141.1,164.45 140.76,164.12 140.76,159.92 140.24,159.4 137.41,159.4 137.2,159.61 137.2,163.85 136.63,164.42 133.76,164.42 133.31,163.97 133.31,159.81 132.64,159.14 130.4,159.14 129.72,159.82 129.72,164.42 129.37,164.76 126.68,164.76 126.5,164.59 126.5,159.66 126.32,159.47 125.98,159.47 125,158.49 121.55,158.49 121.55,158.53 121.37,158.7 121.37,165.91 121.67,166.21 144.9,166.21 145.59,165.51 147.84,165.51 149.17,164.18
GND POWER on BOTTOM: 41.03,70.18 47.3,70.18 47.58,69.89 47.58,67.27 47.02,66.71 41.05,66.71 40.92,66.84 40.92,70.07
GND POWER on BOTTOM: 162.89,144.28 170.13,144.28 170.56,143.84 170.56,142.24 170.33,142.01 162.51,142.01 162.33,142.19 162.33,143.72
GND POWER on BOTTOM: 178.35,59.04 178.51,58.88 178.51,56.59 177.5,55.59 175.04,55.59 174.75,55.88 174.75,57.91 174.65,58.01 170.74,58.01 170.38,57.65 170.38,56.85 170,56.47 167.26,56.47 166.98,56.75 166.98,58.94 167.08,59.04
GND POWER on BOTTOM: 182.57,82.5 183.46,82.5 183.59,82.38 183.59,80.72 183.21,80.34 183.21,79.02 182.8,78.62 180.72,78.62 180.64,78.69 180.64,80.57
GND POWER on BOTTOM: 68.72,88.48 68.1,89.11 68.1,89.21 68.18,89.28 68.24,89.37 68.24,89.38 68.91,90.04 68.91,93.93 68.71,94.14 68.2,94.14 68.15,94.19 68.15,94.67 68.2,94.72 68.86,94.72 69.04,94.9 69.04,95.58 68.83,95.79 68.83,101.68 68.96,101.81 69.34,101.81 69.47,101.93 69.47,102.37 69.39,102.44 69.09,102.44 68.91,102.62 68.91,104.14 68.83,104.22 68.83,107.22 67.56,108.49 67.56,108.64 68.1,109.17 68.29,109.17 69.39,108.07 69.39,107.39 69.54,107.24 69.95,107.24 70.08,107.11 70.08,104.88 69.8,104.6 69.8,103.86 70.08,103.58 70.08,103.46 69.8,103.18 69.8,102.57 70.08,102.29 70.08,102.01 69.85,101.78 69.85,101.07 70.08,100.84 70.08,96.47 69.93,96.32 69.93,92.79 70.13,92.59 70.13,90.1 70.31,89.92 70.31,88.52 70.27,88.48 69.44,88.48 69.3,88.51 69.16,88.49 69.15,88.48
GND POWER on BOTTOM: 45.29,55.32 47.32,55.32 47.45,55.2 47.45,49.74 47.19,49.48 45.29,49.48 45.16,49.61 45.16,55.2
GND POWER on BOTTOM: 165.3,133.43 170.38,133.43 171.14,132.67 171.14,132.03 171.02,131.91 165.81,131.91 165.05,132.67 165.05,133.18
GND POWER on BOTTOM: 15.32,68.41 15.95,68.41 16.08,68.28 16.08,66.88 16.2,66.75 16.97,66.75 17.22,66.5 17.22,66.12 16.97,65.87 15.44,65.87 14.55,64.98 14.55,62.94 14.43,62.82 13.92,62.82 13.54,63.2 13.54,65.36 13.16,65.74 11.25,65.74 10.87,66.12 10.87,66.25 11.51,66.88 12.52,66.88 12.9,66.5 14.3,66.5 15.06,67.26 15.06,68.15
GND POWER on BOTTOM: 94.03,158.14 99.69,158.14 100.18,157.66 100.18,156.14 99.26,155.22 94.74,155.22 93.55,156.42 93.55,157.66
GND POWER on L2_GND1: outline of 183 points within 0.38,0.38 195.82,188.77 ; 3 cut-outs
GND POWER on L4_VCC1: 116.64,67.39 113.11,70.92 113.11,83.12 111.71,84.51 111.71,85.95 113.11,87.35 113.11,101.19 115.65,103.73 115.65,105.89 121.59,111.84 127.35,111.84 127.99,111.2 146.48,111.2 146.76,111.48 146.91,111.33 164.9,111.33 165.41,111.84 166.09,111.84 170.26,107.67 170.26,103.1 174.57,98.78 174.57,96.11 178.51,92.18 178.51,78.08 180.67,75.92 180.67,69.53 178.53,67.39
GND POWER on L4_VCC1: outline of 243 points within 0.38,0.38 195.82,188.77
GND POWER on L4_VCC1: 41.33,70.06 39.17,72.22 31.04,72.22 29.54,73.72 29.54,81.85 28.52,82.86 28.52,121.51 32.21,125.2 32.21,130.94 32.66,131.4 42.85,131.4 43.89,132.44 43.89,146.02 46.41,148.54 78.08,148.54 78.71,147.91 80.7,147.91 81.71,148.92 85.19,148.92 86.58,147.53 93.19,147.53 94.97,145.75 95.86,145.75 96.21,145.39 96.21,133.66 92.53,129.98 92.53,122.53 93.8,121.26 93.8,119.95 83.54,109.68 68.68,109.68 66.88,107.88 66.88,86.67 50.26,70.06
GND POWER on L5_VCC2: 118.37,32.59 117.3,33.66 117.3,39.12 110.84,45.57 110.84,53.45 103.86,60.43 103.86,68.74 102.84,69.76 102.84,70.45 103.5,71.12 103.5,81.64 102.52,82.63 99.11,82.63 95.75,79.28 89.37,79.28 88.85,79.79 88.85,83.54 90.48,85.17 95.56,85.17 107.14,96.75 107.14,109.19 110.95,113 112.37,111.59 127.61,111.59 127.99,111.2 146.99,111.2 147.12,111.33 164.9,111.33 167.31,113.74 172.06,113.74 177.75,108.05 177.75,98.65 178.51,97.89 178.51,78.08 180.67,75.92 180.67,63.71 180.16,63.2 121.79,63.2 119.43,60.84 119.43,50.32 123.98,45.77 123.98,33.46 123.11,32.59
GND POWER on L5_VCC2: outline of 183 points within 0.38,0.38 195.82,188.77 ; 1 cut-out
GND POWER on L5_VCC2: 31.04,71.71 29.16,73.59 29.16,119.1 36.25,126.19 43.49,126.19 45.67,128.37 45.67,143.36 48.57,146.26 93.82,146.26 95.2,144.88 95.2,119.31 86.33,110.44 81.89,110.44 81.89,113.84 81.68,114.05 81.01,114.05 80.85,113.88 80.85,110.44 71.65,110.44 71.65,113.69 71.3,114.04 70.51,114.04 70.31,113.84 70.31,110.44 68.55,110.44 66.75,108.64 66.75,86.42 61.44,81.11 54.83,81.11 51.76,78.04 51.76,71.71 ; 1 cut-out
GND POWER on L7_GND2: outline of 183 points within 0.38,0.38 195.82,188.77
GND POWER on L9_GND3: outline of 183 points within 0.38,0.38 195.82,188.77 ; 1 cut-out
GND_BQ24781S on L3_IN1: 70.42,41.74 71.2,41.74 71.58,41.35 71.58,39.03 71.34,38.79 66.54,38.79 66.28,38.53 66.28,35.53 65.86,35.11 61.68,35.11 58.93,37.86 58.93,41.84 59.74,42.64 59.74,43.84 59.41,44.17 58.53,44.17 57.96,44.74 57.96,45.58 58.32,45.94 67.75,45.94 67.83,45.86 67.83,44.33
PVDD_+1.8VA on TOP (solid shape): 61.21,61.17 61.21,57.74 60.96,57.48 58.67,57.48 58.42,57.74 58.42,60.66 59.05,61.29 61.09,61.29
VCCDPHY_1P24 on BOTTOM: 116.89,23.73 116.66,23.96 115.39,23.96 113.23,21.8 113.23,15.57 113.49,15.32 114.38,15.32 115.09,16.03 115.09,21.9 115.65,22.46 116.69,22.46 116.89,22.66
VIN on TOP (solid shape): 145.03,167.8 145.03,165.43 144.88,165.28 121.64,165.28 121.49,165.43 121.49,168 121.74,168.25 144.58,168.25
VIN on TOP (solid shape): 83.94,47.84 83.94,45.59 83.65,45.3 81.25,45.3 81.22,45.32 81.22,47.51 81.23,47.51 81.23,47.81 81.54,48.12 83.67,48.12
VIN on TOP (solid shape): 148.9,172.45 148.9,170.75 148.54,170.39 145.19,170.39 144.89,170.68 144.89,171.88 144.9,171.89 144.9,172.42 145.07,172.59 148.76,172.59
VIN on TOP (solid shape): 93.25,161.49 93.25,157.77 93.04,157.56 91.6,157.56 91.48,157.69 91.48,160.07 91.65,160.25 91.65,161.48 91.81,161.64 93.1,161.64
VIN on TOP (solid shape): 193.87,114.2 193.87,109.61 193.76,109.5 191.7,109.5 191.62,109.58 191.62,111.17 191.38,111.41 190.28,111.41 190.12,111.57 190.12,115.04 190.25,115.16 192.91,115.16
VIN on TOP (solid shape): 45.67,62.94 45.67,57.23 45.48,57.04 41.79,57.04 41.35,56.59 41.35,54.18 40.97,53.8 38.3,53.8 38.05,54.05 38.05,55.83 37.67,56.21 37.67,60.4 38.94,61.67 43.89,61.67 44.65,62.44 44.65,62.69 45.03,63.07 45.54,63.07
VIN on TOP (solid shape): outline of 140 points within 6.3,57.86 14.05,63.33
VIN on TOP: 181.18,5.54 183.34,5.54 183.59,5.29 183.59,3.36 183.35,3.11 181.34,3.11 181.09,3.37 181.09,5.45
VIN on TOP: 181.4,101.17 181.4,99.12 181.28,99 178.77,99 178.51,99.26 178.51,101.17 178.64,101.3 181.28,101.3
VIN on TOP: 2.64,46.82 11.51,46.82 12.14,46.18 12.14,40.41 11.53,39.8 2.44,39.8 2.18,40.06 2.18,46.36
VIN on TOP: 162.58,162.41 165.76,162.41 166.51,161.66 166.51,160.03 166.32,159.85 164.95,159.85 164.35,159.24 162.39,159.24 162.3,159.34 162.3,162.13
VIN on BOTTOM: 40.97,62.06 47.32,62.06 47.95,61.42 47.95,58.75 46.75,57.55 40.4,57.55 39.57,58.37 39.57,60.66
VIN on L3_IN1: 12.05,61.72 14.16,61.72 15.24,60.64 15.24,54.86 10.62,50.24 10.62,41.61 9.09,40.08 4.52,40.08 3.25,41.35 3.25,45.16 5.03,46.94 5.03,62.06 5.92,62.94 7.7,62.94 10.11,60.53 10.86,60.53
VIN on L5_VCC2: 79.81,1.48 79.2,2.09 79.2,31.17 77.4,32.97 54.79,32.97 54.43,33.33 54.43,35.11 53.77,35.77 4.37,35.77 1.47,38.67 1.47,52.15 19.74,52.15 27.13,59.54 27.13,63.46 27.88,64.21 33.84,64.21 35.11,65.48 45.82,65.48 47.83,63.47 47.83,54.84 50.14,52.53 80.87,52.53 92.89,40.51 92.89,34.85 96.14,31.6 96.14,16.03 99.64,12.53 176.58,12.53 181.18,17.12 181.18,76.13 179.02,78.29 179.02,98.1 178.26,98.86 178.26,108.26 172.27,114.25 167.75,114.25 167.46,114.54 167.46,145.09 164.39,148.16 119.69,148.16 116.39,151.46 106.86,151.46 100.03,158.3 92.38,158.3 91.34,159.34 91.34,167.31 92.89,168.86 115.24,168.86 116.39,170.01 142.17,170.01 146.87,174.7 159.1,174.7 161.13,172.67 166.98,172.67 171.67,167.97 193.9,167.97 194.77,167.11 194.77,155.76 193.75,154.74 193.75,136.63 194.77,135.61 194.77,94.16 193.37,92.77 193.37,2.34 192.5,1.48 ; 2 cut-outs
VIN on L6_IN2: 91.52,162 95.2,162 96.09,161.12 107.64,161.12 111.2,164.67 121.74,164.67 122.88,165.81 122.88,167.34 123.27,167.72 129.36,167.72 129.87,167.21 129.87,157.81 128.47,156.42 91.64,156.42 90.63,157.43 90.63,161.12
VIN on L6_IN2: 6.17,63.2 8.33,63.2 9.35,62.18 13.16,62.18 14.55,60.79 14.55,58.88 11.12,55.45 11.12,53.04 8.46,50.37 8.46,42.12 6.3,39.96 3.38,39.96 1.73,41.61 1.73,55.32 5.41,59.01 5.41,62.44
VIN on L8_IN3: 3.38,62.18 3.38,48.97 3.89,48.47 3.89,46.94 2.74,45.8 2.74,40.47 3.5,39.7 8.97,39.7 9.47,40.21 9.47,46.43 5.92,49.99 5.92,56.21 8.33,58.63 8.33,63.07 7.95,63.45 4.65,63.45
VIN_1.2VS on TOP (solid shape): 193.78,109.24 193.78,107.64 193.14,106.99 188.6,106.99 188.39,107.21 188.39,107.72 188.12,107.99 186,107.99 185.9,108.09 185.9,108.33 185.96,108.39 188.71,108.39 188.78,108.47 188.78,109.26 188.84,109.32 193.71,109.32
VIN_+1.0VA on TOP: 85.55,45.07 85.8,44.82 85.8,44.39 85.97,44.22 88.86,44.22 89,44.08 89,43.72 89.05,43.66 89.92,43.66 90,43.58 90,43.43 89.89,43.32 89.06,43.32 89,43.27 89,43.06 89.01,43.05 89.01,42.78 88.92,42.69 79.26,42.69 79.07,42.88 79.07,43.77 80.38,45.07
VIN_+3.3VA on TOP: 181.18,10.75 182.32,10.75 183.46,9.6 183.46,5.9 183.34,5.77 180.31,5.77 179.02,7.06 179.02,10.49 179.4,10.87 179.4,12.14 179.27,12.27 179.02,12.27 178.89,12.4 178.89,15.04 178.97,15.12 179.27,15.12 179.4,15.24 179.4,15.98 179.5,16.08 179.63,16.08 179.7,16.01 179.7,15.42 180.06,15.07 180.24,15.07 180.29,15.01 180.29,11.64
VIN_+3.3VA on BOTTOM: 179.4,11.26 182.32,11.26 182.96,10.62 182.96,8.08 182.45,7.57 179.91,7.57 179.02,8.46 179.02,10.87
VIN_+5VA on TOP: 185.84,94.03 184.86,93.04 180.42,93.04 179.91,93.55 179.91,95.71 179.14,96.48 179.14,98.8 179.15,98.82 186.77,98.82 186.91,98.68 186.91,97.86 187.53,97.23 187.53,95.84 187.91,95.46 190.58,95.46 191.08,94.95 191.72,94.95 191.85,94.82 191.72,94.69 190.96,94.69 190.83,94.57 190.83,94.31 190.54,94.03
VIN_+VCCCORE on TOP (solid shape): 144.86,165.1 144.86,156.92 144.55,156.62 144.55,154.89 144.47,154.82 144.25,154.82 144.12,154.94 144.12,158.6 143.57,159.14 142.37,159.14 142.04,159.47 142.04,164.99 142.18,165.13 144.82,165.13
VIN_+VCCCORE on TOP (solid shape): 129.35,164.95 129.35,157.03 129.31,156.99 129.05,156.99 129.03,156.97 129.03,154.93 128.99,154.89 128.74,154.89 128.71,154.92 128.71,158.9 128.54,159.07 127.49,159.07 126.83,159.73 126.83,165.05 126.88,165.1 129.2,165.1
VIN_+VCCCORE on TOP (solid shape): 136.68,164.95 136.68,156.53 136.42,156.28 136.42,154.51 136.35,154.44 136.07,154.44 136.02,154.49 136.02,158.27 135.94,158.35 135.66,158.35 135.55,158.46 135.55,159.31 135.44,159.42 134.41,159.42 134.01,159.82 134.01,164.75 134.36,165.1 136.52,165.1
VIN_+VCCCORE on TOP (solid shape): 121.23,167.97 121.23,164.98 121.11,164.85 121.11,159.12 121.01,159.03 121.01,156.88 120.98,156.84 120.84,156.84 120.78,156.78 120.78,154.91 120.77,154.9 120.46,154.9 120.41,154.94 120.41,159.01 120.23,159.19 115.62,159.19 115.18,159.64 115.18,166.26 117.15,168.23 120.98,168.23
VIN_+VCCCORE on L3_IN1 (solid shape): 144.75,165.31 144.75,160.29 144.48,160.02 141.37,160.02 140.92,160.47 140.92,164.77 140.63,165.06 138.81,165.06 138.4,164.65 138.31,164.62 138.23,164.68 137.17,164.56 138.14,164.1 138.25,164.13 138.32,164.03 138.32,163.11 138.02,162.61 138.32,162.12 138.32,161.41 138.28,161.4 137.9,161.04 137.98,160.52 138.01,160.49 137.17,159.65 135.22,159.65 135.12,159.74 134.2,159.74 133.65,160.29 133.65,163.97 133.38,164.24 133.32,164.32 133.25,164.39 132.94,164.52 132.61,164.44 131.98,164.44 131.75,164.49 131.52,164.45 130.79,164.45 130.22,163.88 130.22,160.12 129.71,159.61 127.76,159.61 126.84,160.53 126.84,164.7 126.63,164.91 122.64,164.91 122.27,164.54 122.27,159.62 122.06,159.41 117.08,159.41 116.73,159.76 116.73,164.93 117.49,165.69 144.37,165.69
VIN_+VCCCORE on BOTTOM: 139.48,155.18 126.62,155.18 126.08,155.71 125.07,155.71 124.6,156.33 123.96,155.9 120.26,155.9 118.89,157.26 118.27,157.26 118.26,157.26 116.75,157.26 116.37,157.64 116.37,165.64 116.78,166.05 121.05,166.05 121.05,158.37 121.36,158.06 125.04,158.06 125.05,158.03 125.53,157.84 125.77,158.29 125.76,158.32 126.86,159.42 126.86,164.09 127.16,164.39 129.1,164.39 129.37,164.12 129.37,159.42 130.09,158.7 133.2,158.7 133.64,159.15 133.67,159.14 134.12,159.4 133.9,159.87 133.87,159.88 133.87,163.87 134.14,164.14 136.23,164.14 136.73,163.65 136.73,159.4 137.2,158.93 140.7,158.93 141.05,159.28 141.08,159.27 141.54,159.53 141.3,160 141.27,160.01 141.27,163.95 141.54,164.22 144.15,164.22 144.87,163.5 144.87,157.46 144.5,157.09 141.4,157.09
VIN_+VCCGT on TOP (solid shape): 149.55,169.37 150.32,169.37 151.21,168.48 151.21,166.7 151.97,165.94 154.89,165.94 155.67,165.16 155.67,157.68 155.17,157.18 155.17,154.84 155.27,154.74 155.27,153.62 155.34,153.55 155.34,151.51 155.23,151.41 155.03,151.41 154.93,151.32 154.93,149.36 154.88,149.31 154.56,149.31 154.46,149.41 154.46,153.03 154,153.49 150.95,153.49 149.4,155.04 149.4,161.14 149.4,161.14 149.4,161.9 147.14,164.16 146.51,164.16 145.36,165.31 145.36,167.97 144.9,168.43 144.9,170.05 145.08,170.23 148.69,170.23
VIN_+VCCGT on BOTTOM: 150.99,153.47 149.43,155.03 149.43,164.53 148.1,165.87 145.54,165.87 145.11,166.3 145.11,168.31 145.61,168.81 152.78,168.81 154.96,166.63 154.96,153.54 154.89,153.47
VIN_LCD on TOP (solid shape): 73.51,164.2 73.51,162.58 73.36,162.43 72.48,162.43 72.11,162.06 72.11,160.31 72.02,160.22 70.32,160.22 70.23,160.31 70.23,162.33 70.86,162.96 71.72,162.96 72.14,163.38 72.14,164.3 72.32,164.47 73.23,164.47
VIN_LCD_CON on TOP (solid shape): 72.02,159.62 72.02,157.73 71.55,157.25 69.32,157.25 68.99,157.58 68.99,157.84 69.92,158.78 69.92,159.54 70.07,159.69 71.95,159.69
VIN_LCD_CON on BOTTOM (solid shape): 71.46,159.59 71.46,158.21 71.71,157.96 71.71,157.54 71.65,157.48 70.09,157.48 69.97,157.6 69.97,158.01 70.13,158.17 70.13,159.57 70.22,159.66 71.39,159.66
VIN_NV on TOP (solid shape): 11.12,116.54 11.12,115.78 10.49,115.14 4.9,115.14 4.01,116.03 4.01,117.17 4.14,117.3 10.36,117.3
VIN_NV on TOP (solid shape): 2.74,57.61 11.62,57.61 11.81,57.42 11.81,54.61 11.12,53.93 4.77,53.93 3.38,55.32 1.6,55.32 1.09,55.83 1.09,57.86 1.27,58.04 2.31,58.04
VIN_NV on BOTTOM (solid shape): 16.27,91.77 19,91.77 19.76,91.01 19.76,89.23 16.97,86.44 14.3,86.44 13.47,87.26 13.47,92.54 13.73,92.79 15.25,92.79
VIN_NV on L5_VCC2: 1.47,52.66 1.47,117.17 28.65,117.17 28.65,73.59 26.62,71.56 26.62,59.75 19.53,52.66
VIN_VCCIO on TOP (solid shape): 95.75,161.4 95.75,160.27 95.96,160.06 97.66,160.06 97.83,160.23 97.83,160.41 97.89,160.47 100.61,160.47 100.63,160.44 100.63,159.06 100.53,158.96 96.57,158.96 96.3,158.68 93.52,158.68 93.41,158.8 93.41,161.26 93.41,161.26 93.41,161.37 93.56,161.53 95.62,161.53
VIN_VCCIO on BOTTOM: 93.9,161.39 96.09,161.39 96.37,161.12 96.37,158.73 96.24,158.6 93.67,158.6 93.47,158.8 93.47,160.96
VIN_VCCSA on TOP (solid shape): 165.71,159.54 165.71,153.55 165.63,153.47 164.44,153.47 164.01,153.04 164.01,151.46 163.79,151.25 163.79,149.9 163.79,149.9 163.79,149.47 163.75,149.43 163.45,149.43 163.42,149.46 163.42,153.01 163.17,153.27 162.84,153.27 162.32,153.79 162.32,159.04 162.38,159.11 164.51,159.11 164.97,159.57 165.68,159.57
VIN_VCCSA on BOTTOM (solid shape): 165.4,157.99 165.4,155.06 163.61,153.27 162.81,153.27 162.32,153.76 162.32,158.15 162.42,158.25 165.14,158.25
AC_IN+ on TOP (solid shape): 41.23,175.22 41.23,168.9 41.02,168.7 35.75,168.7 35.52,168.92 35.52,175.4 35.64,175.52 40.93,175.52
BAT+ on TOP (solid shape): 36.94,48.59 36.94,41.61 34.57,39.23 34.57,37.88 34.44,37.74 33.54,37.74 32.89,38.39 32.89,39.06 32.74,39.21 32.04,39.21 31,38.18 27.32,38.18 27.22,38.28 27.22,41.02 27.36,41.16 29.04,41.16 29.54,41.65 29.54,42.62 29.03,43.13 27.89,43.13 27.38,43.64 27.38,46.36 27.53,46.51 30.4,46.51 31.27,47.38 31.27,48.55 31.44,48.72 36.82,48.72
BAT+ on BOTTOM (solid shape): 40.03,46.81 40.03,43.95 39.78,43.69 33.27,43.69 31.31,41.73 30.25,41.73 29.8,42.17 29.8,45.52 31.38,47.09 39.75,47.09
BATT- on TOP (solid shape): 52.89,48.37 52.89,39.78 51.78,38.67 45.63,38.67 45.21,39.09 45.21,40.47 45.02,40.66 45.02,48.6 45.28,48.85 52.41,48.85
BATT- on BOTTOM (solid shape): 52.68,47.65 52.68,44.14 52.43,43.9 40.66,43.9 40.58,43.98 40.58,47.45 41.09,47.96 52.36,47.96
CHG_LX on TOP: 46.43,63.45 48.46,63.45 48.72,63.2 48.72,58.5 49.48,57.74 50.24,57.74 50.37,57.61 50.37,53.55 49.73,52.91 46.68,52.91 46.05,53.55 46.05,63.07
CODEC_GND on L2_GND1: 18.6,53.29 17.33,54.56 14.28,54.56 13.79,55.05 13.79,59.16 14.3,59.66 14.3,63.98 15.29,64.98 16.18,64.98 16.82,65.61 21.39,65.61 21.64,65.87 26.51,65.87 27.38,65 27.38,64.19 25.62,62.44 21.05,62.44 20.65,62.03 20.65,57.38 20.93,57.1 21.41,57.1 21.41,55.81 21.28,55.68 21.28,53.52 21.05,53.29
CODEC_GND on L9_GND3: 8.56,49.86 8.46,49.97 8.46,54.84 8.56,54.94 12.88,54.94 13.41,55.47 13.41,59.16 14.3,60.05 14.3,63.98 15.29,64.98 16.18,64.98 16.82,65.61 21.39,65.61 21.64,65.87 26.51,65.87 27.38,65 27.38,64.19 25.62,62.44 21.05,62.44 20.65,62.03 20.65,57.38 20.93,57.1 21.41,57.1 21.41,55.81 21.28,55.68 21.28,53.52 21.05,53.29 18.39,53.29 14.96,49.86
CORE_PLLVDD_GPU on BOTTOM: 91.5,87.71 89.47,87.71 89.25,87.93 89.25,88.8 89.49,89.03 90.2,89.03 90.21,89.03 90.38,89.03 90.7,89.36 94.13,89.36 94.36,89.13 94.36,88.42 94.14,88.2 91.99,88.2
CORE_PLLVDD_GPU on L8_IN3: 95.11,98.46 96.12,97.45 96.12,88.05 95.45,87.38 90.01,87.38 89.96,87.43 89.26,87.43 87.96,88.73 87.96,96.85 89.57,98.46
DC_IN on TOP: 6.75,47.7 6.57,47.53 3.85,47.53 3.76,47.62 3.76,53.65 3.8,53.7 11.54,53.7 11.61,53.63 11.61,48.54 10.77,47.7
DC_IN+ on TOP (solid shape): 40.41,167.51 45.03,167.51 45.67,166.88 45.67,164.95 45.29,164.57 36,164.57 35.69,164.88 35.69,167.79 35.97,168.08 39.85,168.08
DC_IN+ on BOTTOM (solid shape): 45.8,166.83 45.8,164.2 45.29,163.69 43.65,163.69 42.75,164.59 36,164.59 35.72,164.87 35.72,167.3 35.93,167.52 45.11,167.52
DC_IN+ on TOP: 3.5,52.15 3.25,51.9 1.85,51.9 1.6,51.64 1.6,51.26 1.85,51.01 3.25,51.01 3.5,50.75 3.5,48.47 3.38,48.34 2.49,48.34 2.36,48.21 2.36,47.45 2.11,47.2 1.35,47.2 1.09,47.45 1.09,54.82 1.35,55.07 3.12,55.07 3.5,54.69
DC_IN+ on L4_VCC1: 0.62,47.2 0.38,47.43 0.38,56.73 0.44,56.73 0.86,57.14 0.86,57.14 1.47,57.76 1.47,140.18 5.54,144.25 5.54,148.27 1.73,152.08 1.73,160.5 3.86,162.64 21.64,162.64 29.64,170.64 44.39,170.64 44.63,170.41 44.63,159.67 43.73,158.78 37.64,158.78 31.7,152.84 31.7,125.41 28.02,121.72 28.02,83.01 20.16,83.01 19.38,82.23 19.38,53.4 13.18,47.2
DC_IN_B on TOP (solid shape): 36.65,55.83 36.65,49.36 36.4,49.1 31.32,49.1 30.81,48.59 30.81,47.7 30.11,47.01 25.95,47.01 24.74,45.8 20.52,45.8 20.27,46.05 20.27,46.69 20.01,46.94 17.73,46.94 17.35,47.32 17.35,51.13 18.74,52.53 24.46,52.53 24.71,52.78 26.62,52.78 27.57,53.74 28.84,53.74 30.05,54.94 33.1,54.94 34.24,56.09 36.4,56.09
DC_IN_B on L6_IN2: 23.95,54.82 35.13,54.82 35.89,54.05 35.89,50.88 32.59,47.58 21.92,47.58 20.9,48.59 20.9,51.77
EC_3.3VA on TOP: 152.35,28.53 157.81,28.53 158.19,28.15 158.19,27.77 158.57,27.38 160.98,27.38 161.49,26.88 161.49,26.75 163.52,24.72 163.52,15.19 163.27,14.94 162.51,14.94 162.13,14.56 161.24,14.56 160.98,14.81 159.59,14.81 158.19,16.21 158.19,25.23 157.17,26.24 152.73,26.24 152.22,26.75 152.22,28.4
FBVDDQ_MEM on TOP (solid shape): 85.1,110.26 85.1,110.11 84,109.01 83.85,109.01 83.8,109.06 83.77,109.13 83.8,109.2 83.92,109.44 83.85,109.71 83.78,109.82 83.78,109.98 83.81,110.03 83.84,110.1 83.94,110.2 83.96,110.2 84.11,110.24 84.23,110.33 85.02,110.33
FBVDDQ_MEM on TOP (solid shape): 70.21,110.41 70.34,110.26 70.53,110.2 70.55,110.2 70.65,110.1 70.68,110.03 70.72,109.98 70.72,109.82 70.64,109.71 70.61,109.3 70.97,109.1 71,109.09 71.02,109.06 71.04,109.01 71.04,108.96 69.25,108.96 69.15,109.06 69.15,109.25 69.23,109.48 69.15,109.71 69.15,110.13 69.15,110.16 69.19,110.21 69.22,110.2 69.43,110.25 69.58,110.41
FBVDDQ_MEM on TOP (solid shape): 67.93,91.45 68.01,91.43 68.05,91.35 68.05,89.51 67.95,89.41 67.75,89.41 67.5,89.56 67.22,89.49 67.1,89.41 66.95,89.41 66.91,89.44 66.86,89.47 66.81,89.59 66.72,89.74 66.58,89.84 66.55,89.85 66.55,90.56 66.66,90.67 66.72,90.82 66.72,90.83 66.93,91.04 66.95,91.05 67.1,91.05 67.22,90.98 67.64,90.96 67.82,91.34 67.84,91.41 67.91,91.45
FBVDDQ_MEM on TOP (solid shape): 30.05,94.01 30.05,91.84 29.99,91.75 29.88,91.76 29.8,91.81 29.71,91.83 29.7,91.84 29.46,92.07 29.46,92.65 28.34,92.65 28.34,91.63 29.05,91.63 29.27,91.41 29.27,91.39 29.51,91.1 29.88,91.16 29.99,91.17 30.05,91.08 30.05,89.49 30.02,89.48 29.8,89.12 30.03,88.78 30.03,87.94 29.75,87.94 29.75,86.97 30.05,86.97 30.05,85.09 29.87,84.92 24.27,84.92 23.25,83.89 21.25,83.89 20.08,85.06 20.08,90.55 22.95,93.42 27.41,93.42 28.14,94.16 29.89,94.16
FBVDDQ_MEM on TOP (solid shape): 67.22,107.78 67.49,107.7 67.73,107.83 67.9,107.83 68,107.73 68,106.78 67.94,106.78 67.69,106.86 67.66,106.9 67.23,106.9 67.23,106.47 67.25,106.45 67.28,106.37 67.23,106.3 67.1,106.21 66.95,106.21 66.91,106.24 66.87,106.26 66.83,106.3 66.82,106.32 66.75,106.51 66.55,106.65 66.55,107.36 66.68,107.5 66.73,107.68 66.75,107.75 66.81,107.78 66.86,107.8 66.92,107.83 67.14,107.83
FBVDDQ_MEM on TOP (solid shape): 72.14,88.38 72.22,88.34 72.24,88.25 72.16,88.03 72.13,88 72.13,87.57 72.56,87.57 72.58,87.58 72.66,87.61 72.73,87.57 72.82,87.44 72.82,87.28 72.8,87.26 72.6,87.06 72.58,87.05 72.48,87.02 72.38,86.96 71.5,86.96 71.19,87.26 71.18,87.28 71.18,87.44 71.25,87.56 70.95,88.16 70.64,87.56 70.72,87.44 70.72,87.28 70.68,87.23 70.65,87.16 70.55,87.06 70.53,87.06 70.4,87.03 70.29,86.96 69.27,86.96 69.27,87.05 69.13,87.19 69.1,87.24 69.08,87.28 69.08,87.44 69.15,87.56 69.22,87.84 69.07,88.09 69.07,88.26 69.2,88.38
FBVDDQ_MEM on TOP (solid shape): 81.22,88.28 81.22,88.09 81.07,87.84 81.14,87.56 81.22,87.44 81.22,87.28 81.2,87.26 81,87.06 80.98,87.05 80.83,87 80.72,86.88 80.07,86.88 79.99,86.97 79.88,87.04 79.88,87.04 79.74,87.14 79.57,87.3 79.57,87.44 79.65,87.56 79.35,88.16 79.04,87.56 79.12,87.44 79.12,87.28 79.1,87.26 78.7,86.86 77.98,86.86 77.86,87 77.68,87.06 77.67,87.06 77.53,87.2 77.5,87.25 77.48,87.28 77.48,87.44 77.56,87.57 77.63,87.61 77.71,87.58 77.73,87.57 78.16,87.57 78.16,88 78.13,88.03 78.06,88.25 78.07,88.34 78.15,88.38 81.12,88.38
FBVDDQ_MEM on TOP (solid shape): 77.24,88.38 77.32,88.34 77.34,88.25 77.32,88.2 77.3,88.17 77.27,88.16 76.91,87.96 76.94,87.56 77.02,87.44 77.02,87.28 76.98,87.23 76.95,87.16 76.85,87.06 76.83,87.06 76.66,87.01 76.52,86.88 75.81,86.88 75.8,86.91 75.72,87.05 75.42,87.22 75.38,87.28 75.38,87.44 75.45,87.56 75.15,88.16 74.84,87.56 74.92,87.44 74.92,87.28 74.88,87.23 74.85,87.16 74.75,87.06 74.73,87.06 74.58,87.02 74.46,86.93 73.62,86.93 73.29,87.26 73.27,87.28 73.27,87.44 73.35,87.56 73.38,87.96 73.02,88.16 72.99,88.17 72.97,88.2 72.96,88.25 72.97,88.34 73.05,88.38
FBVDDQ_MEM on TOP (solid shape): 83.27,110.06 83.3,110.01 83.3,109.81 83.19,109.7 83.12,109.68 83.05,109.7 82.73,109.76 82.54,109.48 82.54,109.4 82.1,108.96 78.06,108.96 78.06,109.01 78.13,109.23 78.16,109.27 78.16,109.7 77.73,109.7 77.71,109.68 77.63,109.65 77.56,109.69 77.48,109.82 77.48,109.98 77.5,110.02 77.54,110.08 77.71,110.21 77.8,110.27 77.87,110.36 78.7,110.36 78.71,110.34 78.79,110.23 79.06,110.08 79.09,110.02 79.12,109.98 79.12,109.82 79.04,109.71 79.35,109.1 79.65,109.71 79.57,109.82 79.57,109.98 79.62,110.05 79.64,110.12 79.65,110.13 79.72,110.2 79.73,110.2 79.9,110.26 80.02,110.38 80.72,110.38 80.83,110.27 80.98,110.21 81.1,110.17 81.15,110.13 81.15,110.12 81.17,110.05 81.22,109.98 81.22,109.82 81.14,109.71 81.45,109.1 81.75,109.71 81.67,109.82 81.67,109.98 81.71,110.03 81.74,110.1 81.84,110.2 81.86,110.2 82.06,110.27 82.19,110.43 82.21,110.46 82.87,110.46
FBVDDQ_MEM on TOP (solid shape): 67.87,106.06 67.96,106.04 68,105.96 68,100.48 67.94,100.48 67.69,100.56 67.66,100.6 67.23,100.6 67.23,100.17 67.25,100.15 67.28,100.07 67.23,100 67.1,99.91 66.95,99.91 66.91,99.94 66.87,99.96 66.73,100.1 66.72,100.12 66.67,100.28 66.55,100.4 66.55,101.06 66.66,101.17 66.72,101.32 66.72,101.33 66.93,101.54 66.95,101.55 67.1,101.55 67.22,101.48 67.82,101.78 67.22,102.09 67.1,102.01 66.95,102.01 66.91,102.04 66.87,102.06 66.73,102.2 66.72,102.22 66.68,102.37 66.57,102.49 66.57,103.18 66.67,103.28 66.72,103.42 66.72,103.43 66.93,103.64 66.95,103.65 67.1,103.65 67.22,103.58 67.82,103.88 67.22,104.19 67.1,104.11 66.95,104.11 66.91,104.14 66.87,104.16 66.83,104.2 66.82,104.22 66.75,104.4 66.6,104.53 66.57,104.54 66.57,105.28 66.68,105.4 66.73,105.57 66.73,105.59 66.83,105.69 66.9,105.72 66.95,105.75 67.1,105.75 67.22,105.68 67.63,105.65 67.82,106.01 67.83,106.04 67.86,106.06
FBVDDQ_MEM on TOP (solid shape): 74.68,110.3 74.68,110.26 74.86,110.07 74.89,110.02 74.92,109.98 74.92,109.82 74.84,109.71 75.15,109.1 75.45,109.71 75.38,109.82 75.38,109.98 75.42,110.05 75.44,110.12 75.45,110.13 75.52,110.2 75.54,110.2 75.74,110.26 75.88,110.41 76.51,110.41 76.64,110.26 76.83,110.2 76.85,110.2 76.95,110.1 76.98,110.03 77.02,109.98 77.02,109.82 76.94,109.71 76.91,109.3 77.27,109.1 77.3,109.09 77.32,109.06 77.34,109.01 77.34,108.96 71.76,108.96 71.76,109.01 71.83,109.23 71.86,109.27 71.86,109.7 71.43,109.7 71.41,109.68 71.33,109.65 71.26,109.69 71.18,109.82 71.18,109.98 71.21,110.03 71.24,110.1 71.34,110.2 71.36,110.2 71.55,110.26 71.68,110.41 72.37,110.41 72.38,110.37 72.47,110.23 72.78,110.04 72.82,109.98 72.82,109.82 72.74,109.71 73.05,109.1 73.35,109.71 73.27,109.82 73.27,109.98 73.31,110.03 73.34,110.1 73.44,110.2 73.46,110.2 73.65,110.26 73.78,110.4 73.8,110.43 74.55,110.43
FBVDDQ_MEM on TOP (solid shape): outline of 87 points within 66.55,91.51 68.05,99.76
FBVDDQ_MEM on L3_IN1 (solid shape): outline of 326 points within 83.19,132.29 88.31,135.73
FBVDDQ_MEM on L3_IN1 (solid shape): outline of 352 points within 41.25,107.61 44.77,110.66
FBVDDQ_MEM on L3_IN1 (solid shape): outline of 799 points within 73.8,132.29 77.05,138.82
FBVDDQ_MEM on L3_IN1 (solid shape): outline of 1451 points within 66.36,88.54 84.51,110.37
FBVDDQ_MEM on L3_IN1 (solid shape): outline of 9962 points within 48.33,132.29 96.33,148.91
FBVDDQ_MEM on L6_IN2 (solid shape): outline of 923 points within 48.64,131.74 53.89,140.02
FBVDDQ_MEM on L6_IN2 (solid shape): outline of 2479 points within 47.65,134.66 63.12,148.21
FBVDDQ_MEM on L6_IN2 (solid shape): outline of 8319 points within 64.31,92.61 99.67,148.82
FBVDDQ_MEM on L6_IN2 (solid shape): outline of 9183 points within 23.32,70.43 48.17,119.66
FBVDDQ_MEM on L8_IN3 (solid shape): outline of 1060 points within 47.51,130.59 52.49,138.99
FBVDDQ_MEM on L8_IN3 (solid shape): outline of 1208 points within 66.15,99.89 84.2,110.78
FBVDDQ_MEM on L8_IN3 (solid shape): outline of 8565 points within 47.23,130.44 97.53,148.88
FBVDDQ_MEM on BOTTOM: outline of 551 points within 22.43,70.42 97.98,149.69 ; 3 cut-outs
FBVDDQ_MEM on L8_IN3: outline of 998 points within 24.03,70.44 81.74,120.05
FBVDDQ_MEM_VIN on TOP (solid shape): 10.64,95.05 10.64,90.1 11.12,89.61 11.63,89.61 11.76,89.49 11.76,88.85 11.61,88.7 10.89,88.7 10.87,88.68 1.9,88.68 1.29,89.29 1.29,90.88 4.95,90.88 4.95,90.07 5.77,90.07 5.77,90.88 5.71,90.88 5.71,91.11 5.78,91.24 5.79,91.29 5.79,91.34 5.79,91.39 5.78,91.45 5.74,91.53 5.71,91.57 5.68,91.61 5.64,91.65 5.59,91.68 5.51,91.71 5.46,91.72 5.41,91.72 5.36,91.72 5.3,91.71 5.22,91.68 5.18,91.65 5.14,91.61 5.1,91.57 5.08,91.53 5.06,91.5 5,91.44 5,90.88 1.29,90.88 1.29,95.34 1.66,95.71 9.98,95.71
FBVDDQ_MEM_VIN on BOTTOM (solid shape): outline of 99 points within 1.34,88.76 13.28,95.69
GPPJ_RCOMP_1P8 on TOP (solid shape): 106.35,16.26 106.35,16.04 106.07,15.76 105.46,15.76 103.1,13.4 101.07,13.4 100.99,13.49 100.99,14.08 101.09,14.18 102.83,14.18 105.21,16.56 106.05,16.56
HDMI_5V_C on TOP (solid shape): 61.28,179.35 61.28,174.95 61.13,174.8 59.77,174.8 59.72,174.85 59.72,179.21 59.95,179.44 61.18,179.44
HDMI_+5V on TOP (solid shape): 61.33,174.27 61.33,172.13 61.25,172.04 59.69,172.04 59.66,172.08 59.66,174.19 59.81,174.34 61.26,174.34
HDMI_HPD_CN on TOP (solid shape): 60.73,180.79 60.73,179.84 60.53,179.64 59.87,179.64 59.46,179.23 59.46,176.6 58.52,175.66 58.52,173.68 58.12,173.29 53.9,173.29 53.59,173.59 53.59,175.91 54.09,176.41 56.62,176.41 57.5,177.29 57.5,179.34 59.13,180.97 60.55,180.97
LX_+1.0VA on TOP: 85,42.19 85.19,42.39 88.89,42.39 88.98,42.3 88.98,41.88 89.2,41.66 91.06,41.66 91.17,41.55 91.17,32.88 90.88,32.59 85.8,32.59 85,33.4 ; 1 cut-out
LX_+1.8VA on TOP (solid shape): 66.42,62.41 66.42,59.92 66.19,59.69 64.82,59.69 64.39,60.12 64.39,60.89 64.24,61.04 63.3,61.04 63.22,61.12 63.22,61.73 63.3,61.8 64.18,61.8 64.41,62.02 64.44,62.02 64.48,62.05 64.51,62.05 64.85,62.11 65,62.43 65.03,62.51 65.1,62.54 66.29,62.54
LX_+3.3VA on TOP: 182.7,17.48 183.08,17.48 183.97,16.59 187.53,16.59 187.78,16.34 187.78,10.24 187.4,9.86 183.84,9.86 182.7,11 181.18,11 180.54,11.64 180.54,14.94 180.67,15.07 181.18,15.07 181.43,15.32 181.43,16.21 181.69,16.46 182.32,16.46 182.45,16.59 182.45,17.22
LX_+5VA on TOP: 185.05,92.72 186,93.68 190.79,93.68 190.83,93.64 190.83,93.17 191.06,92.94 191.06,92.94 192.73,92.94 192.93,93.15 192.93,93.79 192.95,93.8 193.62,93.8 193.72,93.71 193.72,92.38 193.39,92.05 193.39,85.28 193.15,85.04 185.75,85.04 185.05,85.75
LX_VCCIO on TOP (solid shape): 108.79,159.54 108.79,156.47 108.53,156.22 105.16,156.22 104.95,156 100.17,156 99.87,156.31 99.87,157.66 99.82,157.7 96.72,157.7 96.62,157.81 96.62,158.6 96.8,158.79 100.57,158.79 100.68,158.68 100.68,158.11 100.8,157.99 101.86,157.99 102,157.86 102.18,157.81 102.21,157.81 102.26,157.82 102.3,157.83 103.71,157.83 103.83,157.96 103.83,159.59 104.03,159.78 104.34,159.82 104.51,160.08 108.25,160.08
NVVDD on TOP (solid shape): 69.04,73.99 69.04,70.95 68.66,70.56 53.92,70.56 53.67,70.82 53.67,72.98 54.94,74.25 68.78,74.25
NVVDD on TOP (solid shape): 70.51,104.23 70.56,104.25 70.59,104.2 70.59,100.79 70.53,100.7 70.42,100.72 70.35,100.8 70.25,100.8 70.25,100.87 70.03,101.1 70.03,101.74 70.25,101.97 70.25,102.35 70.05,102.55 70.05,103.14 70.18,103.27 70.18,103.34 70.18,103.35 70.23,103.53 70.18,103.71 70.18,103.72 70.18,103.77 70.03,103.92 70.03,104.21 70.48,104.21
NVVDD on TOP (solid shape): 73.36,96.8 73.41,96.81 73.44,96.77 73.44,96.75 73.49,96.72 73.61,96.57 73.61,96.39 73.55,96.34 73.51,96.27 73.5,96.25 73.44,96.22 73.44,95.4 73.49,95.37 73.62,95.12 73.47,94.89 73.42,94.86 73.42,94.64 73.57,94.49 73.57,94.37 73.44,94.25 73.44,94 73.49,93.97 73.62,93.73 73.49,93.5 73.44,93.47 73.44,93.24 73.59,93.09 73.59,93 73.56,92.95 73.51,92.96 73.37,93.1 72.86,93.1 72.76,93.09 72.7,93.18 72.7,96.04 72.84,96.18 72.85,96.22 72.88,96.3 72.95,96.36 73,96.39 73,96.58 73.05,96.63 73.17,96.66 73.26,96.74 73.32,96.76
NVVDD on TOP (solid shape): 73.36,96.8 73.41,96.81 73.44,96.77 73.44,96.75 73.49,96.72 73.61,96.57 73.61,96.39 73.55,96.34 73.51,96.27 73.5,96.25 73.44,96.22 73.44,95.4 73.49,95.37 73.62,95.12 73.47,94.89 73.42,94.86 73.42,94.64 73.57,94.49 73.57,94.37 73.44,94.25 73.44,94 73.49,93.97 73.62,93.73 73.49,93.5 73.44,93.47 73.44,93.24 73.59,93.09 73.59,93 73.56,92.95 73.51,92.96 73.37,93.1 72.86,93.1 72.76,93.09 72.7,93.18 72.7,96.04 72.84,96.18 72.85,96.22 72.88,96.3 72.95,96.36 73,96.39 73,96.58 73.05,96.63 73.17,96.66 73.26,96.74 73.32,96.76
NVVDD on TOP (solid shape): 80.74,96.4 80.78,96.41 80.89,96.32 80.91,96.29 80.99,96.21 80.99,95.45 80.92,95.38 80.92,95.36 80.89,95.32 80.82,95.25 80.82,95.01 80.92,94.9 80.92,94.88 80.94,94.75 80.94,94.11 80.95,94.1 80.95,94.07 80.94,94.03 80.92,93.98 80.92,93.96 80.89,93.92 80.82,93.85 80.82,93.61 80.92,93.5 80.92,93.46 80.97,93.41 80.97,93 80.61,93 80.47,92.86 80.36,92.84 80.3,92.93 80.3,93.5 80.26,93.53 80.17,93.73 80.26,93.94 80.3,93.97 80.3,94.9 80.26,94.93 80.17,95.13 80.26,95.34 80.3,95.37 80.3,96.26 80.55,96.26 80.58,96.29 80.64,96.33 80.69,96.38 80.74,96.39
NVVDD on TOP (solid shape): 80.74,96.4 80.78,96.41 80.89,96.32 80.91,96.29 80.99,96.21 80.99,95.45 80.92,95.38 80.92,95.36 80.82,95.25 80.82,95.01 80.92,94.9 80.92,94.88 80.94,94.75 80.94,94.11 80.95,94.1 80.95,94.07 80.94,94.03 80.92,93.98 80.92,93.96 80.82,93.85 80.82,93.61 80.92,93.5 80.92,93.46 80.97,93.41 80.97,93 80.61,93 80.47,92.86 80.36,92.84 80.3,92.93 80.3,93.5 80.26,93.53 80.17,93.73 80.26,93.94 80.3,93.97 80.3,94.9 80.26,94.93 80.17,95.13 80.26,95.34 80.3,95.37 80.3,96.26 80.55,96.26 80.58,96.29 80.64,96.33 80.69,96.38 80.74,96.39
NVVDD on TOP (solid shape): 80.74,96.4 80.78,96.41 80.89,96.32 80.91,96.29 80.99,96.21 80.99,95.45 80.92,95.38 80.92,95.36 80.82,95.25 80.82,95.01 80.92,94.9 80.92,94.88 80.94,94.75 80.94,94.11 80.95,94.07 80.94,94.03 80.92,93.98 80.92,93.96 80.82,93.85 80.82,93.61 80.92,93.5 80.92,93.46 80.97,93.41 80.97,93 80.61,93 80.47,92.86 80.36,92.84 80.3,92.93 80.3,93.5 80.26,93.53 80.17,93.73 80.26,93.94 80.3,93.97 80.3,94.9 80.26,94.93 80.17,95.13 80.26,95.34 80.3,95.37 80.3,96.26 80.55,96.26 80.58,96.29 80.64,96.33 80.69,96.38 80.74,96.39
NVVDD on TOP (solid shape): 73.36,96.8 73.41,96.81 73.44,96.77 73.44,96.75 73.49,96.72 73.61,96.57 73.61,96.39 73.55,96.34 73.51,96.27 73.5,96.25 73.44,96.22 73.44,95.4 73.49,95.37 73.62,95.12 73.47,94.89 73.42,94.86 73.42,94.64 73.57,94.49 73.57,94.37 73.44,94.25 73.44,94 73.49,93.97 73.62,93.73 73.49,93.5 73.44,93.47 73.44,93.24 73.59,93.09 73.59,93 73.56,92.95 73.51,92.96 73.37,93.1 72.86,93.1 72.76,93.09 72.7,93.18 72.7,96.04 72.84,96.18 72.85,96.22 72.88,96.3 72.95,96.36 73,96.39 73,96.58 73.01,96.61 73.05,96.63 73.17,96.66 73.26,96.74 73.32,96.76
NVVDD on TOP (solid shape): 70.64,96.77 70.64,96.75 70.69,96.72 70.81,96.58 70.81,96.39 70.75,96.34 70.71,96.27 70.7,96.25 70.64,96.22 70.64,95.34 70.77,95.21 70.77,95.05 70.62,94.9 70.62,94.64 70.77,94.49 70.77,94.37 70.64,94.25 70.64,93.24 70.79,93.09 70.79,93.02 70.76,92.97 70.71,92.98 70.57,93.12 70.06,93.12 70.06,93.12 70,93.11 69.97,93.16 69.97,93.36 70.05,93.44 70.06,93.47 70.09,93.51 70.13,93.55 70.17,93.58 70.17,93.89 70.13,93.92 70.09,93.95 70.06,94 70.05,94.02 69.9,94.17 69.9,94.66 70.04,94.81 70.08,94.9 70.13,94.95 70.17,94.98 70.17,95.29 70.13,95.32 70.08,95.36 70.04,95.46 69.97,95.52 69.97,96.11 70.04,96.18 70.05,96.22 70.08,96.3 70.15,96.36 70.2,96.39 70.2,96.58 70.21,96.61 70.25,96.63 70.37,96.66 70.46,96.74 70.55,96.76 70.58,96.79
NVVDD on TOP (solid shape): 70.64,96.77 70.64,96.75 70.69,96.72 70.81,96.58 70.81,96.39 70.75,96.34 70.71,96.27 70.7,96.25 70.64,96.22 70.64,95.34 70.77,95.21 70.77,95.05 70.62,94.9 70.62,94.64 70.77,94.49 70.77,94.37 70.64,94.25 70.64,93.24 70.79,93.09 70.79,93.02 70.76,92.97 70.71,92.98 70.57,93.12 70.06,93.12 70.06,93.12 70,93.11 69.97,93.16 69.97,93.36 70.05,93.44 70.06,93.47 70.09,93.51 70.13,93.55 70.17,93.58 70.17,93.89 70.13,93.92 70.09,93.95 70.06,94 70.05,94.02 69.9,94.17 69.9,94.66 70.04,94.81 70.08,94.9 70.13,94.95 70.17,94.98 70.17,95.29 70.13,95.32 70.08,95.36 70.04,95.46 69.97,95.52 69.97,96.11 70.04,96.18 70.05,96.22 70.08,96.3 70.15,96.36 70.2,96.39 70.2,96.58 70.21,96.61 70.25,96.63 70.37,96.66 70.46,96.74 70.55,96.76 70.58,96.79
NVVDD on TOP (solid shape): 70.64,96.77 70.64,96.75 70.69,96.72 70.81,96.58 70.81,96.39 70.75,96.34 70.71,96.27 70.7,96.25 70.64,96.22 70.64,95.34 70.77,95.21 70.77,95.05 70.62,94.9 70.62,94.64 70.77,94.49 70.77,94.37 70.64,94.25 70.64,93.24 70.79,93.09 70.79,93.02 70.76,92.97 70.71,92.98 70.57,93.12 70.06,93.12 70.06,93.12 70,93.11 69.97,93.16 69.97,93.36 70.05,93.44 70.06,93.47 70.09,93.51 70.13,93.55 70.17,93.58 70.17,93.89 70.13,93.92 70.09,93.95 70.06,94 70.05,94.02 69.9,94.17 69.9,94.66 70.04,94.81 70.08,94.9 70.13,94.95 70.17,94.98 70.17,95.29 70.13,95.32 70.08,95.36 70.04,95.46 69.97,95.52 69.97,96.11 70.04,96.18 70.05,96.22 70.08,96.3 70.15,96.36 70.2,96.39 70.2,96.58 70.21,96.61 70.25,96.63 70.37,96.66 70.46,96.74 70.55,96.76 70.58,96.79
NVVDD on TOP (solid shape): 80.3,104.3 80.36,104.39 80.47,104.37 80.6,104.24 81.07,104.24 81.07,103.95 80.92,103.8 80.92,103.76 80.91,103.74 80.84,103.6 80.84,103.44 80.84,103.43 80.84,103.36 80.88,103.33 80.91,103.29 80.95,103.21 81.12,103.04 81.12,102.62 80.95,102.46 80.91,102.36 80.86,102.32 80.82,102.29 80.82,101.98 80.86,101.95 80.91,101.9 80.95,101.81 81.09,101.66 81.09,101.22 80.95,101.08 80.92,100.98 80.88,100.93 80.84,100.9 80.84,100.87 80.76,100.88 80.69,100.89 80.64,100.93 80.58,100.97 80.53,101.06 80.3,101.06 80.3,101.93 80.28,101.96 80.22,102.13 80.28,102.3 80.3,102.33 80.3,102.63 80.28,102.66 80.21,102.83 80.28,103.01 80.3,103.03 80.3,103.33 80.28,103.36 80.22,103.53 80.28,103.7 80.3,103.73
NVVDD on TOP (solid shape): 80.3,104.3 80.36,104.39 80.47,104.37 80.6,104.24 81.07,104.24 81.07,103.95 80.92,103.8 80.92,103.76 80.91,103.74 80.84,103.6 80.84,103.44 80.84,103.43 80.84,103.36 80.88,103.33 80.91,103.29 80.95,103.21 81.12,103.04 81.12,102.62 80.95,102.46 80.91,102.36 80.86,102.32 80.82,102.29 80.82,101.98 80.86,101.95 80.91,101.9 80.95,101.81 81.09,101.66 81.09,101.22 80.95,101.08 80.92,100.98 80.88,100.93 80.84,100.9 80.84,100.87 80.76,100.88 80.69,100.89 80.64,100.93 80.58,100.97 80.53,101.06 80.3,101.06 80.3,101.93 80.28,101.96 80.22,102.13 80.28,102.3 80.3,102.33 80.3,102.63 80.28,102.66 80.21,102.83 80.28,103.01 80.3,103.03 80.3,103.33 80.28,103.36 80.22,103.53 80.28,103.7 80.3,103.73
